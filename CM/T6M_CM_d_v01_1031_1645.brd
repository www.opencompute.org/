# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPLD_WDT3_R: length 10.1
  TOP w0.102: U43.112 156.03,36.89 155.99,36.92 v1(155.31,36.92)
  BOTTOM w0.102: R1179.1 151.17,38.46 151.83,37.8 152.52,37.8 153.39,36.92 v1(155.31,36.92) 155.31,37.35 156.54,38.58 R1195.1
CPU_NODE1_PROCHOT_N: length 31.7
  TOP w0.102: v1(82.04,87.33) 81.71,87 U2.E57 ; Q42.C 106.95,84.37 v1(106.54,83.97)
  IN3 w0.114: v1(82.04,87.33) 85.68,87.33 88.81,84.2 v1(89.19,84.2) 89.91,84.92 90.76,84.92 92.29,86.45 94.06,86.45 94.83,87.22 97.68,87.22 100.54,84.37 101.15,84.37 102.36,83.16 104.3,83.16 105.11,83.97 v1(106.54,83.97)
  BOTTOM w0.102: v1(89.19,84.2) 89.46,83.92 R1216.1
CPU_RSV_1: length 228.2
  TOP w0.102: v1(149.21,180.03) 149.06,179.88 U129.14 ; v1(82.01,99.25) 82.32,99.25 82.9,98.67 84.52,98.67 84.66,98.53 85.42,98.53 85.67,98.79 85.67,102.44 84.06,104.05 56.71,104.05 v1(55.91,103.26) ; U128.14 v1(91.53,181.02)
  IN1 w0.114: v1(45.61,168.3) 45.61,152.23 45.69,152.15 45.69,150.96 45.53,150.8 45.53,143.86 46.91,142.48 46.91,137.29 49.61,134.59 49.61,124.82 54.74,119.69 54.74,107.61 55.91,106.43 v1(55.91,103.26)
  IN2 w0.114: v1(45.61,168.3) 46.54,169.24 50.79,169.24 51.34,169.79 52.99,169.79 59.62,176.42 59.62,176.98 60.55,177.91 60.55,179.52 61.47,180.44 90.95,180.44 v1(91.53,181.02) 92.03,181.53 93.65,181.53 93.92,181.8 95.88,181.8 96.05,181.63 101.1,181.63 101.26,181.79 101.62,181.79 102.87,180.54 104.03,180.54 104.33,180.83 105.52,180.83 105.87,181.18 106.49,181.18 106.53,181.14 109.49,181.14 110.51,180.12 111.87,180.12 112.36,179.63 114.32,179.63 115.88,181.2 118.5,181.2 118.66,181.36 120.69,181.36 120.93,181.61 122,181.61 123.19,180.41 124.13,180.41 125.68,178.87 148.04,178.87 v1(149.21,180.03)
  BOTTOM w0.102: v1(82.01,99.25) 81.08,99.25 80.28,98.45 R110.2
CPU_RSV_1_R: length 12.1
  TOP w0.102: v1(78.68,85.88) 79.38,85.88 U2.H52
  BOTTOM w0.102: v1(78.68,85.88) 78.68,86.17 78.53,86.32 78.53,86.71 79.22,87.4 79.22,88.17 79.46,88.42 79.46,90.65 79.5,90.87 79.5,93.88 80.13,94.51 v2(80.13,95.14) 80.13,96.15 R110.1
CPU_STP_NODE1: length 5.4
  TOP w0.102: v1(138.55,119.38) 138.62,119.31 U1.45
  BOTTOM w0.102: R6.2 138.67,119.27 v1(138.55,119.38)
CRT_B: length 13.3
  TOP w0.102: U44.3 32.84,56.22 30.48,53.85 R659.2 29.82,53.41 28.09,53.41 27.46,54.04 C504.1 25.35,54.04 J9.3
CRT_B_L: length 2.8
  TOP w0.102: R642.1 30.26,54.66 R659.1 29.68,54.65 v1(29.52,54.82) 28.86,54.16 L39.2
CRT_DDCCLK: length 15.4
  TOP w0.102: U49.3 27.76,65.73 C508.1 R636.2 22.45,59.97 22.02,59.54 J9.15
CRT_DDCDATA: length 10
  TOP w0.102: U47.3 30.95,46.22 30.45,46.72 R639.2 27.55,46.72 C505.1 26.31,46.7 24.69,48.32 J9.12
CRT_G: length 14.4
  TOP w0.102: J9.2 25.62,49.08 25.75,49.22 C503.1 27.23,48.91 27.44,48.7 R788.2 27.44,47.58 27.67,47.35 31.44,47.35 31.83,47.73 31.83,49.72 U45.3
CRT_G_L: length 3
  TOP w0.102: L40.2 28.75,49.06 28.24,48.55 R788.1 28.74,48.05 v1(28.94,48.26) 29.2,47.99 R641.1
CRT_HSYNC: length 13.4
  TOP w0.102: U48.3 31.06,53.3 30.34,52.58 28.67,52.58 28.52,52.73 R638.2 27.49,52.73 C506.1 25.29,52.7 24.81,52.21 24.81,51.4 24.02,50.61 J9.13
CRT_R: length 10.6
  TOP w0.102: U46.3 31.39,41.8 R789.2 29.25,43.94 28.3,43.94 27.58,44.66 C502.1 J9.1
CRT_R_L: length 2.7
  TOP w0.102: R640.1 30.61,43.84 30.58,43.87 30.41,43.87 30.29,43.99 R789.1 30,44.13 29.53,44.6 v1(29.48,44.6) 29.41,44.67 L41.2
CRT_VSYNC: length 10.2
  TOP w0.102: U50.3 28.26,59.42 27.76,59.91 R637.2 C507.1 26.54,58.24 J9.14
FAN1_TACH: length 79.6
  TOP w0.102: R756.2 106.04,170.22 v1(105.53,169.71) ; v1(169.68,183.44) 169.68,184.33 170.16,184.81 R821.1
  IN2 w0.114: v1(105.53,169.71) 105.72,169.51 108.07,169.51 108.28,169.72 111.54,169.72 114.92,173.11 114.92,176.7 116.98,178.75 117.47,178.75 119.24,180.52 120.32,180.52 120.79,180.06 121.62,180.06 122.06,179.61 123.79,179.61 125.62,177.78 135.54,177.78 136.44,176.89 137.7,176.89 137.82,177.01 139.06,177.01 139.97,177.92 148.52,177.92 149.91,179.3 151.42,179.3 152.17,180.05 152.17,180.78 154.23,182.83 154.59,182.83 154.67,182.76 157.4,182.76 157.41,182.76 158.54,182.76 158.67,182.64 160.71,182.64 161.81,183.74 161.81,183.76 162.33,184.28 164.98,184.28 166.32,182.93 166.92,182.93 167.52,183.53 169.59,183.53 v1(169.68,183.44)
FAN1_TACH_IN: length 3.2
  TOP w0.102: R756.1 v1(107.56,170.22) 108.22,170.22 108.92,170.93 U69.6
FAN1_TACH_R: length 20.7
  TOP w0.102: R821.2 170.51,185.82 171.07,186.38 171.07,187.97 R1219.1 170.51,188.9 170.1,189.32 170.1,196.09 170.81,196.8 170.81,197.68 v1(170.79,197.68) 171.05,197.95 J18.B27
FAN2_TACH: length 78.3
  TOP w0.102: v1(106.95,168.25) 106.08,169.12 R757.2 ; R823.1 169.37,184.17 168.51,183.31 v1(168.51,183.09)
  IN2 w0.114: v1(106.95,168.25) 107.2,168.51 108.92,168.51 108.93,168.49 110.68,168.49 115.19,173 115.19,176.59 117.09,178.49 117.58,178.49 119.35,180.26 119.72,180.26 120.11,179.86 120.11,179.49 120.42,179.18 123.85,179.18 125.59,177.44 134.38,177.44 136.59,175.23 138.01,175.23 140.4,177.62 148.86,177.62 150.27,179.03 151.54,179.03 152.58,180.08 152.58,180.19 152.84,180.44 153.52,180.44 155.27,182.19 157.16,182.19 157.46,181.88 158.9,181.88 159.24,182.22 160.97,182.22 161.88,183.14 164.99,183.14 165.47,182.66 167.15,182.66 167.58,183.09 v1(168.51,183.09)
FAN2_TACH_IN: length 3.6
  TOP w0.102: R757.1 v1(108.42,169.2) 108.42,169.59 109.12,170.29 U69.7
FAN2_TACH_R: length 20.5
  TOP w0.102: R823.2 169.46,185.61 169.89,186.03 169.89,188.01 R1220.1 169.37,190.46 169.36,190.46 169.26,190.56 169.26,196.24 v1(169.28,196.24) 170.05,197.01 J18.B28
FAN3_TACH: length 77.3
  TOP w0.102: R825.1 168.23,184.77 168.14,184.77 v1(166.74,183.37) ; R758.2 v1(105.56,170.72)
  IN2 w0.114: v1(166.74,183.37) 165.5,184.61 160.08,184.61 159.95,184.48 154.7,184.48 154.44,184.22 154.44,184.16 152.91,182.62 152.38,182.62 150.67,180.91 150.67,180.54 150.92,180.3 150.92,179.82 150.66,179.57 149.8,179.57 148.53,178.3 138.3,178.3 137.27,177.27 136.43,177.27 135.61,178.09 125.7,178.09 123.91,179.88 122.87,179.88 121.68,181.07 121.26,181.07 120.98,180.79 119.04,180.79 117.27,179.02 116.87,179.02 114.58,176.74 114.58,173.15 111.55,170.11 108.08,170.11 107.74,169.78 106.5,169.78 v1(105.56,170.72)
FAN3_TACH_IN: length 3.3
  TOP w0.102: R758.1 107.15,171.51 v1(108.42,171.51) 109.1,172.2 U69.4
FAN3_TACH_R: length 20.8
  TOP w0.102: J18.B29 169.05,202.22 169.48,201.79 169.48,198 v1(169.27,197.79) 168.23,196.75 R1221.1 168.41,188.53 168.68,188.25 168.68,186.31 168.23,185.86 R825.2
FAN4_TACH: length 80.3
  TOP w0.102: R761.2 118.6,169.53 v1(118.99,169.15)
  IN3 w0.114: v1(118.99,169.15) 116.74,169.15 116.64,169.05 115.44,169.05 114.73,169.76 114.73,176.78 115.36,177.42 115.36,179.05 117.15,180.85 117.15,181.96 118.37,183.18 119.42,183.18 119.9,183.67 119.9,184.13 120.59,184.81 121.14,184.81 124.48,188.15 170.92,188.15 172.48,186.59 v1(172.48,186.37)
  BOTTOM w0.102: R827.1 173.88,187.28 173.88,186.55 173.62,186.29 172.64,186.29 172.56,186.37 v1(172.48,186.37)
FAN4_TACH_IN: length 2.8
  TOP w0.102: R761.1 116.83,169.93 v1(116.44,169.55) 116.33,169.66 U69.9
FAN4_TACH_R: length 19
  TOP w0.102: R1222.1 173.86,189.38 v1(173.81,189.44)
  BOTTOM w0.102: J18.A26 172.05,202.45 171.62,202.02 171.62,196.75 172.58,195.79 172.58,194.47 173.81,193.23 v1(173.81,189.44) 173.69,189.32 R827.2
FAN5_TACH: length 88.3
  TOP w0.102: R768.2 105.88,165.14 105.86,165.16 v1(105.47,165.16)
  IN3 w0.114: v1(173.44,186.72) 172.77,187.39 172.77,189.55 172.35,189.96 171.68,189.96 170.82,189.1 122.68,189.1 120.79,187.21 120.79,186.54 119.95,185.71 119.49,185.71 119.26,185.48 118.47,185.48 114.72,181.72 114.72,180.19 114.41,179.89 114.41,177.91 112.49,175.99 112.49,173.14 112.32,172.97 112.32,170.15 107.33,165.16 v1(105.47,165.16)
  BOTTOM w0.102: v1(173.44,186.72) 173.44,186.74 172.7,187.47 R829.1
FAN5_TACH_IN: length 2.9
  TOP w0.102: R768.1 108.4,165.14 v1(108.42,165.16) U70.6
FAN5_TACH_R: length 19.6
  TOP w0.102: R1223.1 172.85,190.22 172.64,190.44 v1(172.64,190.44)
  BOTTOM w0.102: J18.A27 171.05,199.39 171.29,199.14 171.29,195.27 172.64,193.93 v1(172.64,190.44) 172.64,190.06 172.67,190.02 R829.2
FAN6_TACH: length 85.9
  TOP w0.102: v1(104.99,163.9) 105.22,164.12 R770.2
  IN3 w0.114: v1(104.99,163.9) 105.22,164.12 106.67,164.12 113.19,170.65 113.19,175.08 113.15,175.13 113.15,175.59 115.09,177.53 115.09,179.16 116.5,180.58 116.5,181.82 117.65,182.96 117.65,183.49 118.94,184.78 119.97,184.78 122.19,187 122.19,187.11 123.58,188.49 171.3,188.49 v1(172.06,189.26)
  BOTTOM w0.102: v1(172.06,189.26) 172.09,189.23 172.09,187.59 171.97,187.47 R830.1
FAN6_TACH_IN: length 3
  TOP w0.102: R770.1 v1(107.56,164.12) 107.96,164.53 U70.7
FAN6_TACH_R: length 18.8
  BOTTOM w0.102: R830.2 R1224.1 170.51,188.78 171.04,189.31 171.04,194.79 170.03,195.8 v2(170.03,199.66) 170.05,199.64 J18.A28
FAN_MAX_CTRL: length 50.1
  TOP w0.102: U128.61 91.03,163.32 v1(90.89,163.18) ; U61.15 131.71,166.26 v1(131.11,165.65)
  IN1 w0.114: v1(131.11,165.65) 130.9,165.45 127.8,165.45 127.02,164.67 124.38,164.67 123.5,165.55 119.6,165.55 119.41,165.36 116.61,165.36 116.59,165.38 114.74,165.38 114.52,165.15 110.51,165.15 109.55,164.19 108.24,164.19 107.74,163.69 106.02,163.69 105.51,163.17 101.48,163.17 101.07,163.58 99.49,163.58 98.99,163.08 97.61,163.08 96.24,161.72 94.21,161.72 92.4,163.52 91.85,163.52 91.51,163.18 v1(90.89,163.18)
  BOTTOM w0.102: R1225.1 131.9,165.81 131.59,165.49 131.27,165.49 v1(131.11,165.65) 131.11,165.87 132.04,166.81 R1211.1
FAN_PWM: length 84.1
  TOP w0.102: R819.1 172.03,184.81 173.06,183.78 v1(173.06,183.65)
  IN3 w0.114: v1(173.06,183.65) 173.06,184.23 172.92,184.38 172.92,186.69 172.5,187.11 172.5,189.44 172.24,189.7 171.79,189.7 170.93,188.84 122.79,188.84 121.05,187.1 121.05,186.43 120.06,185.44 119.66,185.44 119.27,185.05 118.42,185.05 115.24,181.87 115.24,180.07 114.83,179.66 114.83,177.8 112.76,175.73 v1(112.76,172.79)
  BOTTOM w0.102: U133.4 112.72,169.03 113.76,170.08 113.76,171.12 R778.2 113.13,172.68 113.02,172.79 v1(112.76,172.79)
FAN_PWM_BUF: length 14.1
  TOP w0.102: v1(113.6,169.27) 113.6,171.89 114.18,172.47 114.18,173.09 114.55,173.47 U69.15
  BOTTOM w0.102: R799.2 116.43,171.75 117.93,170.24 v2(117.93,170.17) 117.93,169.99 116.94,169 115.6,169 115.15,169.45 U133.2 113.78,169.45 v1(113.6,169.27)
FAN_PWM_R: length 22.5
  TOP w0.102: R819.2 171.66,186.14 172.11,186.6 172.11,188.45 172.04,188.53 C588.1 171.53,188.65 171.53,189.39 171.34,189.57 v1(170.53,189.57)
  BOTTOM w0.102: v1(170.53,189.57) 170.53,194.12 168.38,196.26 168.38,199.54 167.62,200.31 167.62,201.54 168.05,201.97 J18.A30
FM_BMC_NODE1_RESET_L: length 148.2
  TOP w0.102: U16.2 59.99,123.22 v1(61.18,124.41) ; v1(177.67,118.17) 178.37,118.87 R1030.2 ; U14.W20 71.77,128.06 v5(71.37,127.66)
  IN1 w0.114: v1(61.18,124.41) 61.77,124.99 67.28,124.99 68.61,126.33 70.04,126.33 v5(71.37,127.66)
  IN2 w0.114: v1(177.67,118.17) 176.81,117.31 174.14,117.31 173.62,117.82 172.8,117.82 171.54,119.08 164.85,119.08 160.49,123.44 149.67,123.44 149.33,123.1 147.04,123.1 146.03,124.11 141.99,124.11 138.12,120.24 138.12,119.19 131.34,112.42 121.91,112.42 121.6,112.73 119.04,112.73 118.31,113.46 112.85,113.46 108.91,117.4 108.91,117.9 107.6,119.21 105.32,119.21 105.05,119.47 97.32,119.47 95.06,117.21 88.06,117.21 87.88,117.03 v1(83.21,117.03)
  BOTTOM w0.102: v5(71.37,127.66) 71.37,127.21 71.15,126.99 71.15,122.95 70.86,122.65 70.86,118.91 71.29,118.48 71.29,117.74 71.3,117.74 71.59,117.44 73.17,117.44 74.32,118.59 74.89,118.59 75.53,117.95 81.87,117.95 82.79,117.03 v1(83.21,117.03)
FM_CPLD_CLK_R_PG_NODE1_R: length 5.2
  TOP w0.102: R8.1 139.26,113.12 R7.1 140.26,113.1 v1(140.67,113.52) 140.67,115.14 140.84,115.31 U1.55
FM_CPLD_NODE1_BMC_PERST_L: length 119
  TOP w0.102: U102.D8 186.04,119.37 v5(185.54,119.87)
  IN2 w0.114: v1(171.61,119.67) 164.96,119.67 160.7,123.93 149.38,123.93 149.04,123.6 147.24,123.6 146.23,124.61 141.78,124.61 136.76,119.59 136.76,118.54 131.14,112.91 122.49,112.91 121.72,113.68 118.8,113.68 118.52,113.95 113.05,113.95 109.99,117.02 109.99,118.16 108.45,119.7 105.52,119.7 105.26,119.97 97.09,119.97 94.83,117.71 87.85,117.71 87.78,117.64 84.3,117.64 v1(83.25,118.69)
  IN3 w0.114: v1(171.61,119.67) 173.17,119.67 173.37,119.87 174.62,119.87 175.73,118.77 180.34,118.77 181.44,119.87 v5(185.54,119.87)
  BOTTOM w0.102: v1(83.25,118.69) 83.17,118.77 83.17,120.21 R254.1
FM_CPLD_NODE1_BMC_SRST_L: length 5.1
  TOP w0.102: U102.D10 180.04,119.37 v1(179.79,119.62) 179.57,119.4 R1030.1
FM_CPLD_NODE1_CLK_PG: length 66.2
  TOP w0.102: U102.B8 185.55,116.87 185.55,116.05 184.4,114.9 181.94,114.9 179.81,112.77 176.49,112.77 174.19,115.07 173.03,115.07 172.79,115.31 170.02,115.31 167.1,118.23 165.66,118.23 165.32,117.88 165.32,116.66 162.5,113.84 v1(159.06,113.84) ; R7.2 v1(138.48,111.83)
  IN3 w0.114: v1(138.48,111.83) 138.48,111.37 138.15,111.04 138.15,105.95 138.78,105.32 149.06,105.32 152.56,108.82 152.56,108.82 154.03,108.82 v1(159.06,113.84)
FM_CPLD_NODE1_CPU_RESET_L: length 448.6
  TOP w0.102: v1(83.7,82.36) 83.58,82.36 83.07,81.85 82.83,81.85 82.51,81.53 U2.T58 ; J3.46 123.92,65.41 124.63,64.7 127.61,64.7 127.94,65.03 v1(127.99,65.03) ; v1(92.28,111.28) 92.28,114.11 91.82,114.57 91.82,119.45 v1(92.29,119.92) ; R560.1 v1(64.66,150.27) ; v1(197.79,121.09) 198.95,119.93 203.25,119.93 203.93,119.25 v1(204.69,119.25) ; R590.1 168.85,163.17 170.03,163.17 170.17,163.3 170.39,163.3 172.54,165.45 v1(172.54,166.43) ; v1(135.99,51.74) 136.79,50.94 R621.1 ; U102.G8 v5(185.54,122.87)
  IN1 w0.114: v1(83.7,82.36) 84.48,83.13 85.59,83.13 85.92,82.8 89.38,82.8 89.76,83.18 89.76,85.47 89.91,85.62 89.93,85.62 89.95,85.64 89.95,85.66 91.17,86.88 91.17,90.16 92.69,91.69 94.47,91.69 94.47,91.69 94.6,91.69 94.6,91.69 97.14,91.69 98.15,90.68 v1(99.38,90.68) 99.38,94.2 96.38,97.2 96.38,105.37 93.12,108.63 93,108.63 92.54,109.08 92.54,111.02 v1(92.28,111.28) ; v1(64.66,150.27) 64.71,150.21 72.91,150.21 72.94,150.23 76.67,150.23 77.2,149.7 79.22,149.7 80.05,148.87 85.05,148.87 85.58,148.34 89.04,148.34 91.06,146.32 91.06,134.73 91.95,133.85 91.95,120.26 v1(92.29,119.92) ; v1(197.79,121.09) 195.16,121.09 195.13,121.06 193.03,121.06 192.72,121.37 185.34,121.37 185.05,121.66 185.05,122.44 185.48,122.87 v5(185.54,122.87) ; v1(204.69,119.25) 204.69,119.63 204.95,119.89 204.95,138.43 204.69,138.68 204.69,153.45 194.09,164.05 183.93,164.05 182.14,165.84 177.65,165.84 176.73,166.75 176.08,166.75 175.77,166.43 v1(172.54,166.43)
  IN2 w0.114: v1(99.38,90.68) 100.33,91.63 103.68,91.63 107.21,88.09 147.65,88.09 163.44,103.88 163.44,106.05 168.28,110.89 177.9,110.89 179.86,112.86 179.86,116.83 179.14,117.55 179.14,120.68 180.51,122.06 183.47,122.06 184.28,122.87 v5(185.54,122.87)
  IN3 w0.114: v5(185.54,122.87) 182.48,122.87 181.95,122.33 179.1,122.33 178.5,121.73 176.69,121.73 176.39,122.02 174.85,122.02 174.65,121.82 172.15,121.82 168.38,118.06 168.38,112.35 153.49,97.45 142.2,97.45 127.28,82.54 127.28,76.03 126.85,75.6 126.74,75.6 125.97,74.82 125.97,71.48 127.47,69.97 127.47,65.55 v1(127.99,65.03) 130.09,65.03 132.09,63.03 132.09,56.34 134.17,54.26 134.17,53.56 v1(135.99,51.74)
FM_CPLD_NODE1_CPU_RSMRST_L: length 127.8
  TOP w0.102: v1(87.49,83.61) 87.23,83.87 85.64,83.87 85.27,84.24 U2.L63 ; U102.F9 184.54,121.87 181.08,121.87 v1(180.38,121.17)
  IN2 w0.114: v1(87.49,83.61) 87.49,84.36 88.79,85.67 89.9,85.67 92.75,88.52 93.51,88.52 94.15,89.16 98.94,89.16 100.65,90.86 103.35,90.86 106.88,87.33 147.97,87.33 160.41,99.76 163.16,99.76 163.99,100.59 163.99,105.56 168.52,110.09 177.8,110.09 180.38,112.67 v1(180.38,121.17)
FM_CPLD_NODE1_DEBUG_MODE: length 7.5
  TOP w0.102: R1036.2 R1037.2 187.59,129.8 v1(187.22,129.43) 187.22,128.81 187.59,128.45 187.59,124.92 188.04,124.46 U102.J6
FM_CPLD_NODE1_JTAG_POK_L: length 6.9
  TOP w0.102: R1050.2 179.5,124.88 v1(179.8,125.19) 179.96,125.04 182.06,125.04 183.23,123.86 184.71,123.86 185.04,123.52 U102.H9
FM_CPLD_NODE1_JTAG_POK_R_L: length 4.1
  TOP w0.102: Q28.B v1(177.33,126.42) 177.37,126.42 178.37,125.43 R1050.1
FM_CPLD_NODE1_LPCRST_L: length 219.4
  TOP w0.102: v1(111.66,15.21) 111.66,15 111.04,14.38 J1.3 ; U115.18 99.9,115.93 99.21,115.24 99.21,114.22 105.33,108.1 107.51,108.1 110,105.61 110,103.33 108.6,101.93 108.6,98.42 108.93,98.09 108.93,91.52 117.65,82.8 123.13,82.8 128.8,77.14 129.66,77.14 130.09,77.57 v1(130.09,79.06) ; v1(182.89,112.02) 185.81,112.02 188.53,114.73 188.53,114.74 188.54,114.75 188.54,117.87 U102.C5
  IN1 w0.114: v1(111.66,15.21) 111.77,15.11 117.04,15.11 123.74,21.81 123.74,47.73 126.48,50.48 126.53,50.48 127.86,51.81 127.86,52.08 131.67,55.9 131.67,67.63 131.43,67.88 131.43,77.72 v1(130.09,79.06)
  IN3 w0.114: v1(130.09,79.06) 130.09,81.45 139.07,90.42 141.85,90.42 145.26,93.84 156.03,93.84 162.69,100.5 162.69,100.53 162.94,100.79 162.98,100.79 169.37,107.17 169.37,108.35 171.05,110.03 177.9,110.03 179.89,112.02 v1(182.89,112.02)
FM_CPLD_NODE1_P1V0_EN: length 61.5
  TOP w0.102: U102.B4 190.53,116.88 v1(190.53,115.69)
  TOP w0.254: PJ3.1 175.35,72.31 v1(175.34,72.33)
  IN1 w0.114: v1(190.53,115.69) 190.53,112 194.27,108.26 194.27,93.31 190.13,89.17 185.1,89.17 v1(184.65,89.62)
  BOTTOM w0.102: v1(175.34,72.33) 175.9,72.9 179.89,72.9 183.5,76.51 183.5,88.47 v1(184.65,89.62)
FM_CPLD_NODE1_P1V5_EN: length 166
  TOP w0.102: R1240.2 C850.1 R1116.1 45.97,118.55 v1(46.4,118.98) 46.44,118.94 Q40.S ; v1(166.81,115.06) 171.62,110.25 186.53,110.25 191.47,115.18 191.47,116.94 U102.B3
  IN2 w0.114: v1(166.81,115.06) 165.71,115.06 165.5,115.27 161.4,115.27 158.22,112.08 148.42,112.08 148.19,112.3 147.83,112.3 146.9,111.38 145.91,111.38 145.27,112.01 144.9,112.01 144.76,112.16 138.76,112.16 138.66,112.27 137.37,112.27 134.7,109.59 113.6,109.59 106.8,116.39 97.21,116.39 96.16,115.34 94.95,115.34 94.35,114.74 65.3,114.74 63.84,113.28 62.55,113.28 61.03,114.8 61.03,115.46 58.14,118.34 56.91,118.34 55.86,119.4 52.43,119.4 52.15,119.68 49.94,119.68 49.47,119.21 46.63,119.21 v1(46.4,118.98)
FM_CPLD_NODE1_P1V05_EN: length 179.6
  TOP w0.102: PJ6.1 34.26,128.53 v1(34.31,128.48) 34.37,128.54 R1239.1 ; U102.B5 189.47,116.94 189.47,114.63 186.11,111.28 182.58,111.28 182.5,111.36 171.81,111.36 167.35,115.82 167.12,115.82 v1(166.98,115.97)
  IN2 w0.114: v1(34.31,128.48) 34.71,128.48 38.04,125.14 38.04,122.27 40.38,119.94 41.21,119.94 41.7,119.45 43.43,119.45 43.99,120.01 48.65,120.01 48.74,120.1 48.74,120.1 49,120.35 49.36,120.35 49.7,120.01 52.2,120.01 52.54,119.66 55.97,119.66 57.03,118.61 58.26,118.61 61.3,115.57 61.3,114.91 62.66,113.54 63.73,113.54 65.19,115.01 94.24,115.01 94.84,115.61 95.87,115.61 96.92,116.66 106.91,116.66 113.07,110.5 131.03,110.5 131.42,110.12 134.41,110.12 136.85,112.56 141.55,112.56 142.12,113.13 145.77,113.13 146.48,112.42 146.85,112.42 147,112.57 148.66,112.57 149.05,112.96 150.09,112.96 151.29,114.16 158.24,114.16 160.36,116.28 164.91,116.28 165.09,116.1 166.85,116.1 v1(166.98,115.97)
FM_CPLD_NODE1_P1V5_EN_G: length 4.6
  TOP w0.102: Q40.G v1(49.18,119.92) 49.06,120.03 46.65,120.03 46.19,119.57 R1117.1
FM_CPLD_NODE1_P1V5_EN_LV:
  vias: v1(50.27,116.68)
FM_CPLD_NODE1_P1V5_SUS_EN: length 173.4
  TOP w0.102: v1(92.59,107.13) 92.14,106.68 91.07,106.68 89.29,104.91 54.03,104.91 48.77,99.64 42.79,99.64 41.92,100.51 41.56,100.51 41.54,100.5 39.92,100.5 38.92,101.5 38.92,102.25 39.12,102.46 39.12,102.46 39.82,103.15 R1106.2 39.81,103.23 C819.1 41.07,104.23 41.09,104.21 U120.6 ; U102.A6 188.04,114.93 185.61,112.5 182.69,112.5 182.13,111.94 173.73,111.94 v1(172.38,113.29)
  IN2 w0.114: v1(172.38,113.29) 172.35,113.26 162.16,113.26 157.17,108.27 145.74,108.27 144.83,107.35 144.83,106.31 143.69,105.17 133.78,105.17 131.56,107.39 112.51,107.39 107.39,112.51 107.39,113.41 106.16,114.64 102.81,114.64 102.02,113.85 101.82,113.85 97.83,109.86 95.42,109.86 94.02,108.46 94.02,108.4 93.36,107.73 93.19,107.73 v1(92.59,107.13)
FM_CPLD_NODE1_P1V05_SUS_EN: length 134.2
  TOP w0.102: v1(110.83,126.22) 110.83,127.05 110.49,127.39 106.23,127.39 105.01,128.62 105.01,129.43 C811.1 105.74,130.64 105.56,130.82 R1104.2 105.74,131.16 106.11,131.53 106.11,132.42 106.37,132.68 U119.6 ; v1(179.34,113.44) 181.38,115.48 184.16,115.48 U102.A9
  IN1 w0.114: v1(131.44,84.54) 131.44,86.36 124.24,93.55 124.24,96.38 118.79,101.83 113.17,101.83 110.01,104.99 110.01,111.27 109.34,111.93 109.34,124.73 v1(110.83,126.22)
  IN3 w0.114: v1(179.34,113.44) 176.69,110.79 169.6,110.79 153.85,95.04 142.28,95.04 131.78,84.54 v1(131.44,84.54)
FM_CPLD_NODE1_P1V8_EN: length 133.8
  TOP w0.102: U102.B2 192.47,116.94 192.47,113.75 188.71,109.99 171.09,109.99 v1(167.12,113.96) ; R1238.2 79.78,107.05 v1(79.48,107.35) 79.11,107.72 C848.1 ; C848.1 R1112.1 ; C848.1 78.78,108.36 78.65,108.49 Q38.S
  IN2 w0.114: v1(167.12,113.96) 165.37,113.96 165.31,113.89 161.66,113.89 158.12,110.36 143.55,110.36 143.22,110.68 141.31,110.68 141.01,110.38 136.95,110.38 135.17,108.6 113.08,108.6 106.28,115.4 101.8,115.4 99.79,113.39 99.79,113.38 97.55,111.15 94.18,111.15 93.09,110.05 93.09,109.89 v1(93.05,109.85)
  IN3 w0.114: v1(79.48,107.35) 80.01,106.82 83.91,106.82 87.4,110.31 92.59,110.31 v1(93.05,109.85)
FM_CPLD_NODE1_P1V8_EN_G: length 1.6
  TOP w0.102: R1113.1 76.75,107.72 v1(76.75,108.46) Q38.G
FM_CPLD_NODE1_P1V8_EN_LV: length 5.5
  TOP w0.102: Q37.4 80.12,112.29 v1(79.81,112.6) 79.52,112.88 C847.1 78.54,113.52 R1111.2 77.7,112.65 Q38.D
FM_CPLD_NODE1_P1V8_STB_EN: length 126.8
  TOP w0.102: U102.A3 191.04,115.12 186.6,110.68 v1(180.8,110.68) ; PJ4.1 v1(113.98,158.5) 113.95,158.52 PC30.1 113.06,158.53 R1232.2
  IN1 w0.114: v1(180.8,110.68) 180.8,117.11 180.38,117.53 180.38,119.45 182.14,121.2 182.14,121.62 181.85,121.91 180.21,121.91 176.73,125.38 176.73,127.71 177.05,128.03 177.05,128.62 176.68,128.99 176.68,133.54 176.1,134.12 170.83,134.12 170.29,134.66 168.35,134.66 163.87,139.14 163.87,141.8 163.48,142.19 163.48,144.6 162.73,145.34 162.73,149.99 159.82,152.9 159.82,155.07 157.46,157.44 157.46,158.78 v1(157.23,159)
  IN2 w0.114: v1(113.98,158.5) 116.97,158.5 117.47,158.99 119.56,158.99 120.95,160.38 123.1,160.38 123.42,160.71 123.78,160.71 124.01,160.48 131.74,160.48 132.91,159.31 138.09,159.31 138.43,158.97 141.79,158.97 142.79,157.96 149.5,157.96 149.51,157.98 150.57,157.98 150.69,157.85 154.39,157.85 155.43,158.9 156.46,158.9 156.56,159 v1(157.23,159)
FM_CPLD_NODE1_P1V8_STB_S_EN: length 1.4
  TOP w0.102: PU4.6 v1(114.62,157.06) 114.63,157.06 PJ4.2
FM_CPLD_NODE1_P1V8_SUS_EN: length 130.9
  TOP w0.102: R1091.1 C826.1 ; C826.1 82.23,102.85 83.13,102.85 83.13,102.85 84.29,102.85 v1(84.95,102.2) 84.95,101.38 R1231.2 ; C826.1 81.78,102.41 Q30.S ; v1(177.99,113.36) 181.46,116.83 184.51,116.83 U102.B9
  IN1 w0.114: v1(132.73,86.11) 124.96,93.88 124.96,96.28 119.12,102.12 113.26,102.12 112.12,103.26 112.12,103.26 111.86,103.52 111.86,103.88 111.86,104.46 v1(111.95,104.55)
  IN3 w0.114: v1(111.95,104.55) 111.73,104.34 108.13,104.34 107.87,104.08 106.78,104.08 105.7,103 86.46,103 85.65,102.2 v1(84.95,102.2) ; v1(132.73,86.11) 132.73,86.12 142.07,95.45 153.88,95.45 169.49,111.06 175.69,111.06 v1(177.99,113.36)
FM_CPLD_NODE1_P1V8_SUS_EN_G: length 3.4
  TOP w0.102: R1092.1 81.53,100.51 Q30.G 80.3,101.07 81.17,101.94 v1(81.18,101.94)
FM_CPLD_NODE1_P1V8_SUS_EN_LV: length 6.6
  TOP w0.102: v1(79.38,101.95) 78.89,101.46 Q30.D 78.3,101.09 78.25,101.05 78.25,99.55 R1090.2 77.78,98.54 C825.1 76.65,99.11 Q29.4
FM_CPLD_NODE1_P1V26_BMC_EN: length 123
  TOP w0.102: v1(98.95,143.73) 98.95,144.21 R1234.2 98.48,144.66 C837.1 97.44,143.71 96.96,143.22 U122.6 ; U102.A5 189.04,114.57 186.01,111.53 182.69,111.53 182.6,111.62 173.44,111.62 171.95,113.11 171.95,113.86 172.2,114.11 v1(172.2,114.67)
  IN1 w0.114: v1(150.78,124.54) 150.78,124.64 150.69,124.73 150.69,124.73 149.43,125.99 147.19,125.99 145.48,124.27 141.07,124.27 139.66,125.68 139.66,128.7 131.08,137.28 131.08,138.02 130.3,138.8 130.3,142.8 127.78,145.32 107.02,145.32 107.02,145.31 100.53,145.31 98.95,143.74 v1(98.95,143.73) ; v1(172.2,114.67) 172.42,114.89 172.42,118.22 v1(172.73,118.53)
  IN2 w0.114: v1(150.78,124.54) 150.78,124.54 150.98,124.73 161.06,124.73 165.06,120.73 171.37,120.73 172.73,119.36 v1(172.73,118.53)
FM_CPLD_NODE1_P1V538_BMC_EN: length 180.4
  TOP w0.102: U102.A4 190.04,114.85 186.22,111.03 182.47,111.03 182.39,111.11 171.58,111.11 167.18,115.51 166.76,115.51 166.51,115.75 166.51,117.04 v1(165.91,117.64) ; U121.6 41.26,125.25 40.5,124.49 C829.1 40.49,123.66 R1233.2 v1(39.47,125.09)
  IN2 w0.114: v1(39.47,125.09) 39.47,124.65 39.47,123.46 39.85,123.08 39.85,122.32 40.8,121.37 44.63,121.37 45.14,121.88 55.54,121.88 57.55,119.86 59.29,119.86 62.82,116.33 92.67,116.33 93.2,116.87 95.35,116.87 97.69,119.2 104.94,119.2 105.2,118.94 107.49,118.94 108.64,117.79 108.64,117.28 113.56,112.37 118.66,112.37 119.26,111.78 131.1,111.78 138.27,118.94 138.74,118.94 139.31,119.52 139.31,121.06 142.1,123.84 145.91,123.84 146.92,122.83 150.24,122.83 150.57,122.5 161.05,122.5 v1(165.91,117.64)
FM_CPLD_NODE1_P3V3_EN: length 207.8
  TOP w0.102: C933.1 82.82,1.69 82.81,1.69 ; v1(182.77,116.13) 183,116.37 U102.A10 ; PJ5.1 82.65,2.72 v1(82.81,2.56) 82.81,1.69 ; 82.81,1.69 R1237.2
  IN1 w0.114: v1(142.36,18.31) 141.93,18.31 136.46,12.84 131.96,12.84 131.05,11.93 128.97,11.93 v1(128.39,11.36)
  IN2 w0.114: v1(142.36,18.31) 142.74,18.68 169.46,18.68 172.51,21.74 172.51,47.88 175.37,50.74 175.37,67.2 190.72,82.55 190.72,105.18 182.72,113.18 182.72,116.09 v1(182.77,116.13) ; v1(82.81,2.56) 83.61,1.76 118.79,1.76 128.39,11.36 v1(128.39,11.36)
FM_CPLD_NODE1_P3V3_S_EN: length 1.4
  TOP w0.102: PJ5.2 81.88,4.16 v1(81.88,4.16) PU5.6
FM_CPLD_NODE1_P3V3_SUS_EN: length 119.6
  TOP w0.102: v1(93.97,109.86) C842.1 R1100.1 R1235.2 93.97,106.55 93.7,106.28 Q32.S ; U102.B10 183.89,117.21 180.15,117.21 v1(176.44,113.5)
  IN1 w0.114: v1(100.71,95.44) 100.62,95.53 99.39,95.53 96.97,97.96 96.97,107.56 96.16,108.36 95.4,108.36 93.97,109.79 v1(93.97,109.86)
  IN2 w0.114: v1(151.34,96.04) 147.82,92.52 139.43,92.52 137.83,90.92 110.13,90.92 104.83,96.21 101.72,96.21 100.95,95.44 v1(100.71,95.44)
  IN3 w0.114: v1(176.44,113.5) 176.44,113.49 174.36,111.41 169.3,111.41 153.94,96.04 v1(151.34,96.04)
FM_CPLD_NODE1_P3V3_SUS_EN_G: length 3.1
  TOP w0.102: Q32.G 95.6,106.49 96.13,107.02 v1(96.13,107.77) 96.18,107.83 R1101.1
FM_CPLD_NODE1_P3V3_SUS_EN_LV: length 14.3
  TOP w0.102: Q31.4 94.97,97.92 96.29,96.6 C841.1 v1(97.59,96.6) 97.59,98.03 96.77,98.85 96.77,102.49 95.69,103.57 Q32.D 94.47,103.4 R1099.2
FM_CPLD_NODE1_P5V_EN: length 167.1
  TOP w0.102: v1(193.78,116.67) 193.47,116.37 U102.A1 ; C846.1 R1108.1 R1236.2 72.35,163.91 71.55,163.12 Q36.S 71.55,162.02 v1(71.6,161.97)
  IN1 w0.114: v1(141.17,156.92) 141.34,156.75 144.78,156.75 146.11,155.42 153.74,155.42 159.69,149.47 159.69,145.89 160.3,145.28 160.3,144.91 160.04,144.64 160.04,141.1 160.69,140.45 160.69,140.08 160.19,139.58 160.19,137.96 163.17,134.97 169.63,128.51 169.63,128.48 170.84,127.27 170.84,117.46 v1(171.01,117.29)
  IN3 w0.114: v1(141.17,156.92) 140.57,156.92 140.48,157.01 136.36,157.01 133.97,159.4 132.59,159.4 132.28,159.71 129.57,159.71 128.67,160.61 124.6,160.61 123.79,159.8 115.42,159.8 115.17,160.05 115,160.05 114.87,160.19 110.87,160.19 110.17,159.49 103.18,159.49 103.06,159.37 92.69,159.37 92.2,158.88 91.55,158.88 90.84,159.59 86.72,159.59 82.87,163.44 82.87,163.44 82.63,163.68 79.31,163.68 77.63,165.36 73.99,165.36 73.07,164.43 72.34,164.43 71.59,163.69 71.59,161.98 v1(71.6,161.97) ; v1(171.01,117.29) 172.55,117.29 172.96,116.88 174,116.88 176.22,114.66 180.89,114.66 181.71,113.83 190.27,113.83 193.11,116.67 v1(193.78,116.67)
FM_CPLD_NODE1_P5V_EN_LV:
  vias: v1(73.93,160.59)
FM_CPLD_NODE1_P5V_NODE1_EN_G: length 2.4
  TOP w0.102: Q36.G 72.81,162.89 v1(72.59,163.11) 72.59,163.51 73.2,164.11 R1109.1
FM_CPLD_NODE1_PVCCP_EN: length 120.5
  TOP w0.102: PJ16.1 115.19,128.81 v1(114.99,128.6) ; v1(173.54,114.27) 173.62,114.19 174.25,114.19 176.25,112.19 180.22,112.19 181.73,113.69 185.63,113.69 186.56,114.63 186.56,116.89 U102.B7
  IN1 w0.114: v1(173.54,114.27) 174.17,114.91 v1(174.17,129)
  IN2 w0.114: v1(174.17,129) 171.84,131.34 160.82,131.34 160.53,131.62 136.89,131.62 136.89,131.62 136.48,131.62 136.48,131.62 135.06,131.62 128.79,137.89 128.79,139.31 127.76,140.34 127.01,140.34 124.21,143.14 113.64,143.14 111.47,140.97 111.47,129.56 113.2,127.83 114.62,127.83 114.99,128.2 v1(114.99,128.6)
FM_CPLD_NODE1_PVDDR_STB_EN: length 261.5
  TOP w0.102: v1(184.01,112.98) 184.01,112.99 184.46,113.44 185.83,113.44 187.04,114.65 U102.A7 ; PJ10.1 v1(52.21,5.41) 52.21,5.41 PC31.1 52.09,4.47 51.65,4.04 51.65,3.61 R1241.2
  IN2 w0.114: v1(184.01,112.98) 190.99,106.01 190.99,82.43 175.64,67.09 175.64,50.49 172.91,47.76 172.91,20.74 168.52,16.36 147.04,16.36 145.67,17.73 131.71,17.73 129.13,15.15 112.35,15.15 111.64,15.85 109.2,15.85 109.12,15.93 107.22,15.93 107.1,15.81 104.85,15.81 104.6,16.06 100.32,16.06 99.86,15.61 76.32,15.61 76.02,15.91 55.01,15.91 v1(54.71,15.61)
  BOTTOM w0.102: v1(52.21,5.41) 51.22,6.4 49.21,6.4 48.67,6.94 46.17,6.94 44.29,8.82 44.29,15.05 46.11,16.87 53.45,16.87 v1(54.71,15.61)
FM_CPLD_NODE1_PVTT_DDR_EN: length 160.9
  TOP w0.102: U102.B6 187.5,116.83 187.5,114.75 185.74,112.99 v1(185.45,112.99) ; U123.7 126.92,19.89 126.51,19.48 C198.1 127.46,18.06 127.46,17.58 R1242.2 127.83,17.21 127.83,16.68 128.08,16.43 130.77,16.43 131.63,17.29 v1(135.74,17.29)
  IN2 w0.114: v1(185.45,112.99) 191.25,107.19 191.25,82.32 175.91,66.97 175.91,50.2 173.18,47.47 173.18,20.63 168.62,16.08 146.93,16.08 145.72,17.29 v1(135.74,17.29)
FM_CPLD_NODE1_PWR_BTN_CPU: length 136.9
  TOP w0.102: U2.M56 81.37,83.79 v1(81.37,83.99) ; U102.E1 194.39,120.37 v1(194.75,120)
  IN2 w0.114: v1(177.41,115.63) 177.41,115.46 175.74,113.79 175.74,112.7 175.23,112.19 167.75,112.19 161.96,106.41 161.96,104.42 147.21,89.66 109.6,89.66 105.34,93.93 101.19,93.93 100.39,93.13 99.79,93.13 98.67,92.01 91.42,92.01 87.13,87.72 86.6,87.72 85.92,87.05 85.92,86.4 83.87,84.35 81.72,84.35 v1(81.37,83.99)
  IN3 w0.114: v1(194.75,120) 191.15,116.4 190.23,116.4 189.2,115.37 184.52,115.37 184.35,115.2 181.48,115.2 181.05,115.63 v1(177.41,115.63)
FM_CPLD_NODE1_PWR_BTN_L: length 25.9
  TOP w0.102: U102.J8 185.53,124.88 185.53,126.12 184.95,126.7 v1(184.95,128.15) ; U106.4 185.48,139.58 185.14,139.92 182.96,139.92 182.78,139.75 R1066.2 182.04,139.38 181.91,139.25 181.91,137.81 179.16,135.05 177.82,135.05 v1(177.82,135.05)
  IN1 w0.114: v1(177.82,135.05) 178.14,135.05 178.71,134.48 178.71,134.47 182.29,130.9 182.29,130.59 184.73,128.15 v1(184.95,128.15)
FM_CPLD_NODE1_SATA_PERST_L: length 72
  TOP w0.102: U102.C8 v5(185.54,117.87) ; v1(164.63,91.11) 164.63,84.51 164.8,84.33 v1(164.8,82.93) ; v1(154.49,72.5) 154.49,70.28 155.16,69.61 U30.53
  IN1 w0.114: v1(164.8,82.93) 164.7,83.04 161,83.04 154.09,76.13 154.09,73.33 154.49,72.92 154.49,72.92 v1(154.49,72.5) ; v5(185.54,117.87) 185.54,117.16 186.25,116.45 186.25,112.79 183.2,109.73 174.79,109.73 174.11,109.05 172.85,109.05 168.82,105.02 168.82,96.08 164.63,91.89 v1(164.63,91.11)
FM_CPLD_NODE1_SYS_PG: length 126.6
  TOP w0.102: v1(181.65,121.41) 181.69,121.37 U102.F10 ; U2.J63 84.86,84.91 85.16,85.21 86.32,85.21 86.96,85.85 87.82,85.85 88.31,86.34 88.31,90 v1(89.62,91.3) 90.6,91.3 91.03,91.73 R142.2
  IN1 w0.114: v1(181.65,121.41) 180.42,120.19 179.74,120.19 178.68,119.12 178.68,115.12 176.25,112.69 v1(175.02,112.69)
  IN2 w0.114: v1(89.62,91.3) 91.2,92.88 97.8,92.88 99.16,94.24 99.98,94.24 100.67,94.93 105.41,94.93 109.92,90.42 146.87,90.42 161.16,104.71 161.16,107.78 166.07,112.69 v1(175.02,112.69)
FM_CPLD_NODE1_USB_PERST_L: length 31.9
  TOP w0.102: U102.C9 v5(184.54,117.87) ; v1(167.24,107.46) 167.24,106.74 166.83,106.33 166.83,105.68 167.33,105.17 168.69,105.17 R274.1
  IN1 w0.114: v1(167.24,107.46) 169.09,109.32 173.09,109.32 173.77,110 183.09,110 185.99,112.9 185.99,115.89 184.54,117.33 v5(184.54,117.87)
FM_CPLD_NODE1_USB_PONRST_L: length 46.9
  TOP w0.102: v1(163.78,99.49) 163.93,99.49 166.88,96.54 172.04,96.54 R527.2 172.82,97.78 173.92,98.89 174.3,98.89 174.35,98.94 U32.14 ; U102.C10 183.87,118.37 v5(183.32,117.82)
  IN2 w0.114: v1(163.78,99.49) 165.41,101.12 165.41,106.6 168.56,109.75 177.83,109.75 181.68,113.6 181.68,116.18 v5(183.32,117.82)
FM_CPLD_NODE1_WDT: length 7.3
  TOP w0.102: U102.K3 v1(191.04,126.72) 191.04,126.72 191.04,130.32 191,130.36 R1041.1 191,131.55 190.5,132.05 Q25.C
FM_CPLD_NODE1_WDT_R: length 1.6
  TOP w0.102: Q25.B v1(191.45,135.29) 191.45,135.98 R1043.1
FM_CPLD_PCIE_SW_PERST_L: length 83.3
  TOP w0.102: R231.1 147.83,155.77 147.66,155.94 147.66,155.94 v1(147.27,156.33) ; U102.C1 196.38,118.37 v1(196.55,118.2)
  IN1 w0.114: v1(173.58,119.38) 173.11,119.85 173.11,126.8 164.17,135.73 163.38,135.73 161.06,138.05 161.06,140.45 160.82,140.7 160.82,142.78 160.91,142.87 160.91,145.05 160.11,145.85 160.11,149.43 153.13,156.4 147.34,156.4 v1(147.27,156.33)
  IN3 w0.114: v1(196.55,118.2) 195.45,117.11 193.17,117.11 191.16,115.1 184.63,115.1 184.46,114.93 177.48,114.93 174.97,117.44 174.97,117.98 v1(173.58,119.38)
FM_CPU_NODE1_JTAG_POK: length 121.9
  TOP w0.102: v1(173.62,125.23) 173.27,125.58 Q28.C ; v1(96.75,80.16) 96.75,79.74 96.45,79.43 R1049.1 ; U2.AC53 79.95,78.26 v1(80.34,78.65)
  IN1 w0.114: v1(113.6,81.17) 113.44,81.17 113.11,81.5 102.26,81.5 100.74,79.99 97.33,79.99 97.17,80.16 96.75,80.16 ; v1(80.34,78.65) 80.34,78.97 80.33,78.98 80.33,79.33 80.57,79.57 81.02,79.57 81.15,79.7 86.93,79.7 87.15,79.48 90.48,79.48 90.79,79.18 94.48,79.18 94.92,79.61 96.21,79.61 96.75,80.16 ; 96.75,80.16 v1(96.75,80.16)
  IN3 w0.114: v1(173.62,125.23) 172.6,124.21 171.47,124.21 165.2,117.94 165.2,113.04 160.02,107.86 160.02,106.84 153.3,100.12 139.1,100.12 135.86,96.88 135.86,96.2 122.59,82.93 115.36,82.93 v1(113.6,81.17)
FM_CPU_NODE1_OWDTOUT: length 143.9
  TOP w0.102: Q25.E 188.27,134.42 187.64,135.06 186.03,135.06 185.88,134.91 185.88,132.19 184.36,130.67 v1(184.36,129.14) ; v1(79.95,75.2) 79.93,75.2 79.57,75.56 U2.AH53
  IN3 w0.114: v1(184.36,129.14) 179.92,129.14 177.86,127.08 176.99,127.08 173.66,123.75 171.4,123.75 165.47,117.82 165.47,112.93 160.28,107.75 160.28,106.73 153.41,99.85 142.12,99.85 123.23,80.97 117.87,80.97 108.81,71.91 99.56,71.91 v1(98.82,72.65)
  BOTTOM w0.102: v1(79.95,75.2) 80.79,75.2 81.36,74.62 81.7,74.62 81.72,74.64 89.27,74.64 91.26,72.65 v1(98.82,72.65)
FM_CPU_NODE1_RSTRDY_L: length 147
  TOP w0.102: R138.2 v1(95.11,91.03) ; v1(80.69,83.96) 80.69,83.87 U2.M54 ; v1(188.94,130.47) 189.47,129.94 189.47,125.1 189.04,124.67 U102.J5
  IN2 w0.114: v1(80.69,83.96) 81.07,83.58 82.23,83.58 82.78,84.13 83.96,84.13 85.69,85.87 85.99,85.87 87.8,87.68 87.8,87.89 91.56,91.65 94.48,91.65 95.11,91.03 v1(95.11,91.03) 95.7,91.63 98.82,91.63 100.06,92.87 100.7,92.87 101.5,93.66 104.85,93.66 109.12,89.4 147.32,89.4 162.23,104.31 162.23,106.3 167.85,111.93 175.34,111.93 176,112.59 176,113.68 176.39,114.07 176.46,114.07 178.11,115.71 178.11,124.11 180.12,126.12 184.59,126.12 v1(188.94,130.47)
FM_CPU_NODE1_RSTWARN: length 128.5
  TOP w0.102: U2.T53 79.54,81.93 79.54,82.81 v1(79.42,82.93) ; U102.E8 185.56,120.85 183.41,120.85 183.21,120.65 177.7,120.65 175.73,118.68 175.73,118.6 175.46,118.34 R134.2 175.13,118.62 174.8,118.95 173.4,118.95 173.28,119.06 165.29,119.06 v1(162.08,115.84)
  IN3 w0.114: v1(162.08,115.84) 162.61,115.31 162.61,113.87 155.13,106.4 153.66,106.4 150.13,102.87 137.84,102.87 121.26,86.3 114.4,86.3 111.54,83.44 108.94,83.44 106.54,81.04 81.22,81.04 79.53,82.72 79.53,82.82 v1(79.42,82.93)
FM_CPU_NODE1_SLPMODE: length 140.7
  TOP w0.102: U102.K4 v1(190.04,128.03) ; U2.R56 81.47,82.66 v1(81.37,82.76)
  IN2 w0.114: v1(81.37,82.76) 81.43,82.76 81.84,83.18 82.13,83.18 82.87,83.91 84.05,83.91 85.52,85.38 85.89,85.38 88.19,87.69 88.19,87.79 91.71,91.3 94.06,91.3 94.77,90.59 95.3,90.59 95.98,91.27 98.85,91.27 100.17,92.6 100.82,92.6 101.61,93.4 104.74,93.4 109.01,89.13 147.43,89.13 162.49,104.19 162.49,106.19 167.96,111.66 175.45,111.66 178.37,114.59 178.37,122.51 181.44,125.57 184.47,125.57 186.93,128.03 v1(190.04,128.03)
FM_CPU_NODE1_SLPRDY_L: length 145.4
  TOP w0.102: R136.2 94.67,88.7 94.08,89.29 v1(94.08,90.04) ; v1(189.04,128.85) U102.K5 ; v1(82.01,82.76) 82.01,82.45 82.23,82.23 U2.R58
  IN2 w0.114: v1(189.04,128.85) 189.84,128.85 190.48,128.21 190.48,127.84 187.94,125.3 183.06,125.3 178.64,120.89 178.64,113.39 176.64,111.39 168.07,111.39 162.9,106.21 162.9,104.22 147.54,88.86 108.72,88.86 104.54,93.05 103.6,93.05 102.67,92.12 100.12,92.12 98.83,90.83 96.18,90.83 95.38,90.04 v1(94.08,90.04) 93.7,90.43 93.42,90.43 93.38,90.47 91.25,90.47 88.62,87.84 88.62,86.65 87.86,85.89 86.94,85.89 85.83,84.79 85.28,84.79 84.19,83.69 83.01,83.69 82.08,82.76 v1(82.01,82.76)
FM_CPU_NODE1_XDP_PG_RST: length 113.2
  TOP w0.102: U102.H6 v5(187.54,123.87)
  IN3 w0.114: v1(126.79,76.23) 126.79,82.74 141.99,97.95 153.29,97.95 167.89,112.55 167.89,118.26 172.12,122.5 174.61,122.5 174.63,122.52 176.79,122.52 177.08,122.23 178.09,122.23 179.79,123.92 180.15,123.92 180.63,123.44 187.11,123.44 v5(187.54,123.87)
  BOTTOM w0.102: R222.2 115.55,64.13 115.21,63.79 114.16,63.79 113.85,64.1 113.85,64.33 112.92,65.26 112.92,68.34 114.87,70.29 120.06,70.29 122.7,72.93 123.25,72.93 126.55,76.23 v1(126.79,76.23)
FM_NODE1_CORE0_1_RST_L: length 7.8
  TOP w0.102: Q27.C v1(193.9,131.3) 193.9,130.43 R1046.1 193.89,129.37 192.04,127.52 U102.K2
FM_NODE1_DDR3_DRAM_POK_L: length 7.1
  TOP w0.102: R1042.2 179.47,122.66 179.91,123.11 179.91,123.43 v1(179.97,123.48) 180.25,123.77 182.29,123.77 183.24,122.82 184.19,122.82 184.64,122.37 U102.G9
FM_NODE1_DDR3_DRAM_POK_R_L: length 3.2
  TOP w0.102: Q24.B 176.86,123.07 v1(177.26,122.66) R1042.1
FM_NODE1_DDR3_SYSPWRGD_L: length 5.6
  TOP w0.102: R1045.2 179.4,121.57 180.44,122.62 181.25,122.62 v1(181.47,122.84) 182.42,122.84 182.89,122.37 U102.G10
FM_NODE1_DDR3_SYSPWRGD_R_L: length 3.8
  TOP w0.102: Q26.B 175.44,119.68 v1(176.6,120.85) 177.33,121.57 R1045.1
FM_NODE1_DFX_GPIO_GRP05: length 158.2
  TOP w0.102: v1(68.72,86.07) 68.41,85.76 U2.H30 ; R1047.2 193.96,135.82 v1(193.96,133.42)
  IN3 w0.114: v1(68.67,90.46) 68.97,90.15 70.54,90.15 71.48,89.21 80.73,89.21 81.62,90.1 85.31,90.1 85.66,90.45 93.41,90.45 93.44,90.43 93.83,90.43 93.88,90.48 97.48,90.48 100.2,87.75 100.2,87.63 101.22,86.61 109.03,86.61 110.87,88.45 120.66,88.45 137.1,104.9 149.23,104.9 152.74,108.4 154.23,108.4 159.52,113.68 159.52,118.72 171.9,131.11 172.87,131.11 174.07,132.31 189.63,132.31 189.88,132.56 193.1,132.56 v1(193.96,133.42)
  BOTTOM w0.102: v1(68.67,90.46) 69.14,89.98 69.14,86.49 68.72,86.07 v1(68.72,86.07)
FM_NODE1_DFX_GPIO_GRP05_R: length 1.5
  TOP w0.102: R1047.1 194.85,135.89 v1(194.85,135.24) Q27.B
FM_OSC_NODE1_OSC_NC:
  vias: v1(88.11,100.09)
FNACTRL1_ADD: length 3.7
  TOP w0.102: R762.2 R763.1 116.71,170.97 v1(116.6,170.85) 116.52,170.93 U69.11
FNACTRL1_TMP_IN: length 9.3
  TOP w0.102: U68.1 119.91,166.57 v1(120.07,166.73) ; U69.12 117.13,171.56 v1(117.18,171.61)
  BOTTOM w0.102: v1(117.18,171.61) 117.21,171.61 118.46,170.36 118.46,168.87 120.07,167.27 v1(120.07,166.73)
FNACTRL2_ADD: length 4.7
  TOP w0.102: R771.2 R772.1 117.55,164.77 v1(117.07,164.29) 116.84,164.52 116.84,165.12 116.58,165.37 116.23,165.37 116.02,165.16 U70.11
FNACTRL2_T_ST: length 5.9
  TOP w0.102: v1(112.71,165.92) 113.22,166.43 113.28,166.43 113.29,166.44 113.65,166.44 113.66,166.43 U70.13
  BOTTOM w0.102: v1(112.71,165.92) 112.43,166.2 U71.2 110.37,166.2 v2(109.86,165.69)
FNACTRL2_TMP_IN: length 6
  TOP w0.102: v1(113.44,163.81) 113.44,165.29 113.94,165.8 U70.12
  BOTTOM w0.102: v1(113.44,163.81) 112,165.25 U71.1
FRU_SYS_A0: length 5.6
  TOP w0.102: R180.2 R1152.2 39.85,99.57 v1(39.35,100.08) 38.85,100.08 37.67,101.26 U134.1
FRU_SYS_A1: length 7.2
  TOP w0.102: U134.2 36.4,101.67 33.7,98.96 v1(33.14,98.96) R186.2 R1153.2
FRU_SYS_A2: length 5.2
  TOP w0.102: R1154.2 R187.2 v1(33.18,101.07) 33.18,101.07 34.72,101.07 35.13,101.48 U134.3
GFX_BUF_EN_N: length 6
  TOP w0.102: R658.2 37.26,57.16 v1(37.69,56.73) 37.79,56.63 U132.7 37.79,54.71 37.14,54.06 U132.1
H_CPU_NODE1_ERR0: length 7.2
  TOP w0.102: v1(85.49,86.7) 85.33,86.55 U2.G64
  BOTTOM w0.102: R89.1 84.04,92.4 83.94,92.3 83.94,90.09 84.27,89.75 84.27,89.59 85.49,88.37 v1(85.49,86.7)
H_CPU_NODE1_ERR0_R: length 16.4
  TOP w0.102: U2.H48 77.51,85.6 77.88,85.97 77.88,86.36 78.03,86.51 78.03,87.05 77.95,87.13 77.95,87.73 78.14,87.91 78.14,88.1 78.48,88.44 78.48,88.77 78.45,88.8 78.45,90.78 79.82,92.14 79.82,92.55 80.61,93.35 81.74,93.35 83.04,94.65 83.39,94.65 v1(83.52,94.78) 83.75,95.01 83.75,95.58 84.35,96.18 R111.1
  BOTTOM w0.102: v1(83.52,94.78) 83.52,93.84 R89.2
H_CPU_NODE1_ERR1: length 5.7
  TOP w0.102: U2.H56 81.48,85.19 v1(81.19,84.89)
  BOTTOM w0.102: R87.1 83.4,88.3 83.29,88.19 83.29,87.95 82.65,87.31 82.65,86.35 82.46,86.16 82.46,85.9 82.22,85.66 81.75,85.66 v2(81.6,85.51) 81.19,85.1 v1(81.19,84.89)
H_CPU_NODE1_ERR1_R: length 18
  TOP w0.102: R109.1 85.27,96.31 84.31,95.35 84.31,95.27 84.28,95.24 84.28,94.51 v1(83.12,93.35) 82.63,92.86 80.49,92.86 80.14,92.51 80.14,92.03 78.92,90.81 78.92,89.6 78.66,89.33 78.66,88.88 78.71,88.83 78.71,88.38 78.68,88.36 78.68,87.94 78.94,87.69 U2.D51
  BOTTOM w0.102: v1(83.12,93.35) 83.16,93.3 v2(83.16,91.08) 83.16,90.56 82.98,90.38 82.98,89.32 82.6,88.94 R87.2
H_CPU_NODE1_ERR2: length 9.9
  TOP w0.102: U2.L54 80.28,84.24 v1(80.63,84.59)
  BOTTOM w0.102: v1(80.63,84.59) 80.63,84.78 80.29,85.12 80.29,85.46 80.53,85.7 80.98,85.7 82.44,87.16 82.44,88.29 82.11,88.62 v2(82.11,90.34) 82.11,91.95 82.35,92.18 R85.1
H_CPU_NODE1_ERR2_R: length 16.8
  TOP w0.102: R105.1 86.1,96.31 85.34,95.55 85.27,95.55 v1(84.82,95.1) 84.76,95.04 84.76,93.88 83.09,92.21 81.06,92.21 79.46,90.61 79.46,88.89 78.99,88.42 U2.C51
  BOTTOM w0.102: v1(84.82,95.1) 84.63,95.29 83.25,95.29 82.35,94.38 R85.2
H_CPU_NODE1_PROCHOT_L: length 26.1
  TOP w0.102: v1(109.63,81.07) 109.2,81.07 107.9,82.37 Q42.E
  IN3 w0.114: v1(109.63,81.07) 107.59,79.03 105.75,79.03 104.06,77.34 100.99,77.34 99.37,78.95 v1(97.56,78.95)
  BOTTOM w0.102: R91.2 95.61,76.91 97.3,78.61 97.3,78.7 v1(97.56,78.95) 97.87,79.26 98.88,79.26 99.4,79.78 99.78,79.78 99.78,79.78 R115.1
H_CPU_NODE1_PROCHOT_R: length 12.4
  TOP w0.102: v1(81.84,78.66) 81.47,78.29 U2.AC56
  BOTTOM w0.102: v1(81.84,78.66) 81.84,78.33 v2(82.21,77.96) 82.53,77.64 83.44,77.64 83.93,77.15 86.13,77.15 86.72,77.74 89.25,77.74 89.54,77.45 89.54,76.97 89.7,76.8 91.13,76.8 91.24,76.91 R91.1
H_CPU_NODE1_THRM_LS_L: length 14.3
  TOP w0.102: v1(71.16,84.63) 71.52,85 U2.J37
  BOTTOM w0.102: R140.1 69.02,96.21 69.02,95.13 v2(69.12,95.03) 70.54,93.61 70.54,92.97 71.94,91.57 71.94,89.88 71.27,89.21 71.27,87.85 71.84,87.28 71.84,85.49 71.16,84.8 v1(71.16,84.63)
H_CPU_NODE1_THRMTRIP_L: length 135.1
  TOP w0.102: U2.AG59 82.62,76.56 v1(82.4,76.78) ; v1(178.21,129.94) 178.21,129.94 178.53,129.62 182.37,129.62 183.48,130.73 R93.1 182.8,132.61 R116.1
  IN3 w0.114: v1(82.4,76.78) 82.73,76.45 83.66,76.45 86.35,79.15 87.17,79.15 88.18,78.13 90.33,78.13 90.65,77.81 90.85,77.81 91.19,77.48 97.53,77.48 98.07,76.94 99.02,76.94 101.17,74.78 106.1,74.78 110.83,79.52 110.83,80.32 115.24,84.72 121.92,84.72 138.46,101.25 152.84,101.25 158.99,107.41 158.99,108.29 164.17,113.47 164.17,118.84 170.87,125.54 172,125.54 175.38,128.91 177.19,128.91 v1(178.21,129.94)
H_CPU_NODE1_VR_HOT_L: length 94.2
  TOP w0.102: U102.K9 185.04,126.16 v1(183.27,127.93) ; v1(112.75,144.13) 112.75,143.39 112.33,142.98 112.33,139.35 113.6,138.08 113.78,138.08 114.49,137.37 PR54.1 114.72,137.19 115.5,137.97 117.5,137.97 117.7,137.77 PU8.20
  IN2 w0.114: v1(183.27,127.93) 181.39,129.81 181.39,130.34 180.03,131.69 174.61,131.69 173.39,132.92 161.52,132.92 159.8,134.63 154.95,134.63 153.68,133.36 144.44,133.36 142.64,135.17 134.34,135.17 128.5,141.01 128.5,141.48 127.8,142.17 127.33,142.17 125.37,144.13 v1(112.75,144.13)
I2C_ALERT_FNACTRL1_N: length 2.7
  TOP w0.102: U69.14 116.99,172.83 v1(117.1,172.72) 117.38,173 R760.1
I2C_ALERT_FNACTRL2_N: length 3
  TOP w0.102: R767.1 117.53,166.85 v1(117.12,166.44) 116.54,166.44 115.91,167.07 U70.14
I2C_COM3_SCL: length 213.1
  TOP w0.102: v1(131.28,172.7) 131.02,172.44 127.79,172.44 127.61,172.62 U60.1 124.31,172.62 R663.2 ; R683.1 124.77,163.28 125.17,162.88 125.61,162.88 126.14,162.36 U61.8 127.76,162.36 129.68,164.28 v1(129.68,164.46) ; U67.6 114.29,176.82 113.59,176.12 v1(113.59,175.31) ; v1(105.27,173) 105.42,173 105.71,173.29 R764.2
  IN2 w0.114: v1(166.71,179.86) 165.3,179.86 164.65,179.2 161.3,179.2 160.85,178.76 158.27,178.76 157.82,179.2 152.51,179.2 151.4,178.09 150.27,178.09 148.85,176.67 140.21,176.67 137.73,174.19 134.78,174.19 134.45,174.52 133.1,174.52 v1(131.28,172.7) ; v1(113.59,175.31) 112.12,173.84 106.91,173.84 106.07,173 v1(105.27,173) 104.96,173.3 104.47,173.3 104.39,173.38 102.6,173.38 102.23,173.01 98.46,173.01 v1(97.64,172.19) 96.9,172.19 95.98,171.26 94.68,171.26 90.76,167.35 90.76,166.42 89.56,165.22 87.3,165.22 84.87,167.65 84.87,177.72 83.06,179.53 81.59,179.53 80.84,178.78 78.16,178.78 78.04,178.67 76.29,178.67 75.92,179.04 72.81,179.04 72.19,178.42 71.83,178.42 70.97,179.27 62.81,179.27 v1(62.22,178.68) ; v1(165.02,170.47) 165.06,170.44 165.06,169.6 164.8,169.34 159.62,169.34 152.43,162.15 152.43,161.53 152.29,161.39 151.63,161.39 151.14,161.88 149.87,161.88 149.44,161.45 144.44,161.45 144.25,161.64 143.53,161.64 142.54,160.66 141.27,160.66 140.55,161.37 134.12,161.37 131.63,163.85 131.22,163.85 131.14,163.93 131.11,163.93 130.58,164.46 v1(129.68,164.46)
  IN3 w0.114: v1(166.71,179.86) 166.51,179.65 165.78,179.65 165.07,178.94 165.07,173.01 165.38,172.69 165.38,170.84 165.02,170.48 v1(165.02,170.47) ; v1(116.65,174.76) 117.98,174.76 121.09,171.65 121.63,171.65 121.64,171.64 122.13,171.64 122.56,172.07 124.11,172.07 124.74,172.7 v1(131.28,172.7)
  BOTTOM w0.102: v1(113.59,175.31) 113.66,175.31 114.68,174.29 U65.22 116.18,174.29 v1(116.65,174.76) ; U66.22 163.7,171.25 164.47,170.47 v1(165.02,170.47) ; R773.2 129.66,164.49 v1(129.68,164.46) ; U64.22 130.66,174.93 130.17,174.43 130.17,173.25 130.72,172.7 v1(131.28,172.7) ; v1(62.22,178.68) 62.5,178.4 63.48,178.4 63.67,178.59 U63.22 ; U62.22 98.41,171.12 97.64,171.9 v1(97.64,172.19)
I2C_COM3_SDA: length 213.2
  TOP w0.102: v1(113.88,174.42) 113.88,174.97 114.47,175.55 U67.5 116.19,175.55 116.71,176.07 v1(116.9,176.07) 116.9,175.74 117.56,175.08 R765.2 ; R664.2 125.63,171.61 125.99,171.97 U60.2 127.57,171.97 127.74,172.14 131.1,172.14 v1(131.41,171.83) ; v1(125.44,163.85) 124.99,164.31 R681.1
  IN2 w0.114: v1(125.44,163.85) 127.57,163.85 128.62,164.9 128.8,164.9 128.8,164.9 130.67,164.9 131.27,164.3 132.34,164.3 133.59,163.05 133.59,162.94 133.85,162.69 133.95,162.69 134.84,161.8 142.24,161.8 142.9,162.45 151.91,162.45 154.81,165.35 154.81,166.17 155.07,166.43 156.13,166.43 159.48,169.78 v1(164.62,169.78) ; v1(131.41,171.83) 133.32,173.74 133.99,173.74 134.08,173.64 136.71,173.64 136.82,173.75 137.67,173.75 137.98,173.44 138.34,173.44 139.09,174.18 139.09,174.66 140.73,176.3 150.79,176.3 151.5,177 151.5,177.67 152.66,178.83 157.49,178.83 158.12,178.2 164.16,178.2 165.38,179.42 167.39,179.42 v1(167.71,179.74) ; v1(63.01,178.84) 70.03,178.84 70.96,177.9 79.6,177.9 80.11,178.41 83.66,178.41 84.48,177.59 84.48,167.52 87.14,164.85 89.71,164.85 93.68,168.82 93.68,169.19 94.75,170.26 96.17,170.26 v1(97.35,171.45) 97.53,171.45 98.47,172.39 104.75,172.39 104.92,172.56 106.54,172.56 107,173.02 110.73,173.02 110.9,172.85 111.75,172.85 113.32,174.42 v1(113.88,174.42)
  IN3 w0.114: v1(131.41,171.83) 131.27,171.97 125.24,171.97 124.44,171.17 121.58,171.17 121.47,171.28 120.92,171.28 118.5,173.7 117.2,173.7 116.58,174.32 116.46,174.32 116.21,174.58 116.21,175.37 v1(116.9,176.07) ; v1(164.62,169.78) 164.95,169.78 165.75,170.58 165.75,177.13 165.5,177.38 165.5,178.05 165.97,178.52 166.5,178.52 v1(167.71,179.74)
  BOTTOM w0.102: U63.23 63.41,179.24 v1(63.01,178.84) ; U66.23 163.62,170.6 164.44,169.78 v1(164.62,169.78) ; U64.23 130.62,174.28 130.47,174.13 130.47,173.38 130.72,173.13 131.46,173.13 131.71,172.88 131.71,172.13 v1(131.41,171.83) ; v1(113.88,174.42) 113.91,174.42 114.69,173.64 U65.23 ; R774.2 126.09,164.49 v1(125.44,163.85) 126.05,163.24 R795.2 ; v1(97.35,171.45) 97.52,171.45 98.16,170.81 98.39,170.81 98.74,170.47 U62.23
I2C_COM3_SDA_RC: length 4.5
  TOP w0.102: v1(128.59,163.8) 127.8,163.01 U61.7
  BOTTOM w0.102: C590.2 127.44,163.24 R795.1 128.04,163.24 v1(128.59,163.8)
I2C_PDB_R_SCL: length 28.9
  TOP w0.102: J18.B10 190.05,200.47 186.28,196.7 182.06,196.7 179.04,193.68 v1(179.04,193.42) 179.84,192.62 R841.2
  BOTTOM w0.102: v1(179.04,193.42) 179.04,189.36 178.82,189.14 C610.1
I2C_PDB_R_SDA: length 26.2
  TOP w0.102: R844.2 178.32,189.74 v1(177.81,190.25) 177.79,190.26 177.79,193.7 181.09,197 185.87,197 189.37,200.5 189.37,202.71 189.05,203.03 J18.B11
  BOTTOM w0.102: C613.1 v1(177.81,190.25)
I2C_PDB_SCL: length 76.3
  TOP w0.102: R841.1 179.84,186.81 v1(179.49,186.47) ; v1(122.63,164.37) 122.85,164.37 123.7,163.52 R683.2
  IN3 w0.114: v1(179.49,186.47) 179.91,186.05 179.91,181.43 168.04,169.56 168.04,169.25 161.74,162.95 157.39,162.95 157.02,163.32 152.7,163.32 152.34,162.97 152.34,162.95 144.72,162.95 144.39,163.27 142.32,163.27 141.44,162.4 139.74,162.4 137.44,164.7 134.25,164.7 134.06,164.52 132.22,164.52 131.99,164.29 130.78,164.29 130.14,164.92 129.3,164.92 128.62,164.24 128.37,164.24 128.28,164.15 127.61,164.15 127.09,164.67 123.6,164.67 123.3,164.37 v1(122.63,164.37)
I2C_PDB_SDA: length 75.1
  TOP w0.102: R681.2 v1(123.16,164.84) ; v1(178.15,187.05) 178.15,187.56 R844.1
  IN3 w0.114: v1(123.16,164.84) 123.36,165.05 127.23,165.05 127.76,164.52 128.12,164.52 128.82,165.21 128.82,165.21 128.95,165.34 128.95,165.35 130.52,165.35 130.67,165.21 132.08,165.21 132.39,165.52 135.44,165.52 135.58,165.67 138.07,165.67 139.98,163.76 139.98,163.11 140.32,162.77 141.29,162.77 142.16,163.64 144.65,163.64 144.97,163.31 152.16,163.31 152.68,163.83 157.04,163.83 157.56,163.31 161.59,163.31 167.13,168.85 167.13,169.17 167.73,169.77 167.73,170.8 178.72,181.79 178.72,183.32 177.43,184.61 177.43,186.32 v1(178.15,187.05)
I2C_PSU1_R_SCL: length 20.9
  TOP w0.102: R820.2 67.14,186.16 67.69,186.71 67.69,187.94 67.14,188.49 C589.1 67.14,192.64 65.97,193.8 65.97,196.41 v1(65.97,196.41) 65.97,196.42 65.97,198.84 65.05,199.77 J35.B42
