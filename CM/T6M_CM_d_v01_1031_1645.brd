# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Nets (continued)
P1V05_NODE1: C35.2 C36.1 C39.1 C43.1 C44.1 C45.1 C46.1 C47.1 C48.1 C49.1 C50.1 C51.1 C52.1 C53.1 C54.1 C55.1 C56.1 C57.1 C58.1 C59.1 C96.1 C97.1 C98.1 C99.1 C100.1 C101.1 C102.1 C103.1 C104.1 C105.1 C106.1 C107.1 C121.1 C122.1 C123.1 C124.1 C125.1 C126.1 C127.1 C128.1 C129.1 C130.1 C368.1 C369.1 C370.1 C371.2 C372.2 C373.2 C374.2 C375.2 C376.2 L4.1 L5.1 L6.1 L7.1 PC61.1 PC63.1 PC64.1 PC66.1 PC67.1 PC68.1 PC97.2 PJ8.1 PL6.2 PR30.1 PR45.1 PR50.1 R3.1 R74.1 R76.1 R103.1 R113.2 R114.2 R115.2 R116.2 R119.2 R127.2 R137.2 R200.2 R221.1 R224.2 R228.2 R1043.2 R1049.2 R1122.2 R1215.2 U2.AA31(VCC_5) U2.AA34(VCC_6) U2.AA38(VCC_7) U2.AA41(VCC_8) U2.AC18(VCCANTB_1P05_21) U2.AC20(VCCANTB_1P05_1) U2.AC21(VCCANTB_1P05_2) U2.AC23(VCCANTB_1P05_3) U2.AC25(VCCANTB_1P05_4) U2.AC26(VCCANTB_1P05_5) U2.AC31(VCC_9) U2.AC34(VCCRAMCPU0XSI01P05_1) U2.AC36(VCCFHVCPU0SI01P05) U2.AD18(VCCANTB_1P05_22) U2.AD20(VCCANTB_1P05_23) U2.AD28(VCCDHPLL1P05) U2.AD29(VCC_10) U2.AD32(VCC_11) U2.AF31(VCC_12) U2.AF36(VCCFHVCPU1SI01P05) U2.AG29(VCC_13) U2.AG32(VCC_14) U2.AG34(VCCRAMCPU0XSI01P05_2) U2.AG36(VCC_15) U2.AJ31(VCC_16) U2.AJ34(VCC_17) U2.AJ38(VCC_18) U2.AJ41(VCC_19) U2.AJ44(VCC_20) U2.AL18(VCCANTB_1P05_24) U2.AL20(VCCANTB_1P05_25) U2.AL21(VCCANTB_1P05_6) U2.AL23(VCCANTB_1P05_7) U2.AL25(VCCANTB_1P05_8) U2.AL26(VCCANTB_1P05_9) U2.AL28(VCCANTB_1P05_10) U2.AL29(VCC_21) U2.AL32(VCC_22) U2.AL36(VCC_23) U2.AL39(VCC_24) U2.AL42(VCC_25) U2.AL47(VCCFHVSOC1P05_1) U2.AL49(VCCFHVSOC1P05_2) U2.AM31(VCC_26) U2.AM34(VCC_27) U2.AM38(VCC_28) U2.AM41(VCC_29) U2.AP20(VCCANTB_1P05_26) U2.AP21(VCCANTB_1P05_11) U2.AP23(VCCANTB_1P05_12) U2.AP25(VCCANTB_1P05_13) U2.AP26(VCCANTB_1P05_14) U2.AP28(VCCANTB_1P05_15) U2.AP29(VCC_30) U2.AP32(VCC_31) U2.AP36(VCCA_DDR3_1P05_1) U2.AP38(VCCA_DDR3_1P05_2) U2.AP39(VCCA_DDR3_1P05_3) U2.AP41(VCCA_DDR3_1P05_4) U2.AP42(VCCA_DDR3_1P05_5) U2.AP44(VCCA_DDR3_1P05_6) U2.AP46(VCCA_DDR3_1P05_7) U2.AR19(VCCANTB_1P05_27) U2.AR48(VCCA_DDR3_1P05_8) U2.AR50(VCCA_DDR3_1P05_9) U2.AT31(VCC_32) U2.AT34(VCC_33) U2.AU23(VCCANTB_1P05_16) U2.AU25(VCCANTB_1P05_17) U2.AU26(VCCANTB_1P05_18) U2.AU28(VCCANTB_1P05_19) U2.AU29(VCC_34) U2.AU32(VCC_35) U2.AU36(VCCADLL_DDR3_1P05_3) U2.AU38(VCCADLL_DDR3_1P05_4) U2.AU39(VCCADLL_DDR3_1P05_5) U2.AU41(VCCADLL_DDR3_1P05_6) U2.AU42(VCCADLL_DDR3_1P05_7) U2.AU44(VCCADLL_DDR3_1P05_8) U2.AU46(VCCADLL_DDR3_1P05_9) U2.AU47(VCCADLL_DDR3_1P05_10) U2.AW21(VCCANTB_1P05_28) U2.AW23(VCCANTB_1P05_20) U2.AW46(VCCADLL_DDR3_1P05_1) U2.AW47(VCCADLL_DDR3_1P05_2) U2.AY21(VCCANTB_1P05_29) U2.AY23(VCCANTB_1P05_30) U2.W32(VCC_1) U2.W36(VCC_2) U2.W39(VCC_3) U2.W42(VCC_4) U32.9(VDD10_1) U32.12(VDD10_2) U32.28(VDD10_3) U32.37(VDD10_4) U32.43(VDD10_5) U32.46(VDD10_6) U32.54(VDD10_7) U32.60(VDD10_8) U32.63(VDD10_9)
P1V5_NODE1: C849.2 Q39.1 Q39.2 Q39.3 R2.1 R36.1 R148.1 R149.1 R150.1 R1118.2 U2.AA28(TESTHI_1P5_01) U2.AF28(VCCATS1P5) U2.AJ28(TESTHI_1P5_05) U2.AM28(TESTHI_1P5_03) U2.AT21(VCCARP0_1P5) U2.AT28(VCCREFRP0_1P5)
P1V5_NODE1_AA21: R148.2 U2.AA21(TESTHI_1P5_00)
P1V5_NODE1_AJ21: R150.2 U2.AJ21(TESTHI_1P5_04)
P1V5_NODE1_AM21: R149.2 U2.AM21(TESTHI_1P5_02)
P1V05_NODE1_COMP: PC69.2 PU6.5(COMP)
P1V5_NODE1_DDR3_VREF0_D: C143.1 J2.1(VREF_DQ) R217.1
P1V5_NODE1_DDR3_VREF_A_A: C142.1 C194.1 J2.84(VREF_CA) R202.2 R203.1
P1V05_NODE1_EN: PC62.1 PJ6.2 PR23.2 PU6.14(EN)
P1V05_NODE1_MODE: PR26.1 PU6.15(MODE)
P1V05_NODE1_TRIP: PR28.1 PU6.6(TRIP)
P1V05_NODE1_VREF: PC65.2 PU6.1(VREF)
P1V05_NODE1_VREFIN: PR25.2 PU6.2(REFIN)
P1V05_NODE1_VSNS: PC69.1 PC70.1 PR29.2 PU6.4(VSNS)
P1V5_SFRPLL_NODE1: C93.1 C94.1 L8.2 U2.BA34(VCCSFRPLL_DDR3_1P5_1) U2.BB34(VCCSFRPLL_DDR3_1P5_2)
P1V05_STB_NODE1_XDP_A: C182.2 J3.43 R224.1
P1V05_STB_NODE1_XDP_B: C197.2 J3.44 R221.2
P1V5_SUS_NODE1: C95.1 C820.1 C821.1 C822.1 C823.2 L8.1 Q39.5 R1088.2 U120.1(VOUT1) U120.2(VOUT2) U120.3(VOUT3)
P1V05_SUS_NODE1: C812.1 C813.1 C814.1 J21.1 R158.2 R159.2 R164.2 R165.2 R171.2 R172.2 U2.P48(VCCSUS1P05_1) U2.T47(VCCSUS1P05_2) U2.T48(VCCSUS1P05_3) U119.1(VOUT1) U119.2(VOUT2) U119.3(VOUT3)
P1V05_SUS_NODE1_ADJ: C815.1 R1085.1 R1086.2 U119.4(ADJ)
P1V5_SUS_NODE1_ADJ: C823.1 R1088.1 R1089.2 U120.4(ADJ)
P1V05_SUS_NODE1_ADJ_S: C815.2 J21.2 R1085.2
P1V05_VCCACLK_DDR3_NODE1: C80.1 L7.2 U2.AW32(VCCACLK_DDR3_1P05_1) U2.BA32(VCCACLK_DDR3_1P05_2)
P1V05_VCCPLL_DDR3_NODE1: C62.1 L5.2 U2.AY38(VCCPLL_DDR3_1P05_1) U2.BA38(VCCPLL_DDR3_1P05_2)
P1V05_VCCPLLCPU0SIO_NODE1: C60.1 C61.1 L4.2 U2.AC49(VCCPLLCPU0SI01P05)
P1V05_VCCPLLCPU1SIO_NODE1: C78.1 C79.1 L6.2 U2.AD47(VCCPLLCPU1SI01P05)
P1V8_NODE1: C37.1 C38.1 C91.1 C92.1 C329.1 C828.1 C836.1 C847.2 L9.1 L17.2 L18.2 L30.1 L31.1 L32.1 L33.1 PC22.1 Q12.2(E) Q37.1 Q37.2 Q37.3 R47.2 R51.2 R53.2 R1114.2 U2.AG28(VCCAGPIO1P8_6) U2.L32(VCCAGPIO1P8_1) U2.N32(VCCAGPIO1P8_2) U2.P32(VCCAGPIO1P8_3) U2.T32(VCCAGPIO1P8_4) U2.V32(VCCAGPIO1P8_5) U121.7(VIN1) U121.8(VIN2) U121.9(VIN3) U122.7(VIN1) U122.8(VIN2) U122.9(VIN3) U130.7(VIN1) U130.8(VIN2) U130.9(VIN3)
P1V8_SATA_AVDD_NODE1: C347.1 C348.1 C349.2 C350.1 L31.2 U30.41(AVDDT) U30.42(AVDD)
P1V8_SATA_VAA1_NODE1: C359.1 C360.1 C361.2 C362.1 L33.2 U30.34(VAA1)
P1V8_SATA_VAA2_0_NODE1: C343.1 C344.1 C345.2 C346.1 L30.2 U30.31(VAA2_0)
P1V8_SATA_VAA2_1_NODE1: C355.1 C356.1 C357.2 C358.1 L32.2 U30.25(VAA2_1)
P1V8_STB_NODE1: C810.1 C818.1 PC37.1 PC38.1 PC39.1 PC42.2 PC130.1 PL4.2 PR15.2 PU4.16(VO) Q29.5 Q37.5 U119.7(VIN1) U119.8(VIN2) U119.9(VIN3) U120.7(VIN1) U120.8(VIN2) U120.9(VIN3)
P1V8_STB_NODE1_FB: PC42.1 PR15.1 PR16.1 PU4.1(VFB)
P1V8_STB_NODE1_SS: PC41.2 PU4.3(SS)
P1V8_STB_NODE1_VREG5: PC40.1 PR13.1 PU4.2(VREG5)
P1V8_SUS_NODE1: C74.1 C75.1 C76.1 C77.1 C825.2 Q29.1 Q29.2 Q29.3 R1093.2 U2.L41(VCCSUS1P8_1) U2.N41(VCCSUS1P8_2) U2.P41(VCCSUS1P8_3)
P1V8_VCCASFRHPLL_NODE1: C111.1 C112.1 L9.2 U2.AD23(VCCASFRHPLL1P8_1) U2.AD25(VCCASFRHPLL1P8_2)
P1V9_LAN1: C401.1 C402.1 C403.1 C404.1 C405.1 C406.1 C407.1 C408.1 C409.1 C410.1 C411.1 C412.1 C425.1 C426.1 C427.1 C428.1 C429.2 C430.1 C431.1 C432.1 C433.1 C510.1 C511.1 C512.1 C513.1 C514.1 Q15.2(COLLECTOR) Q15.4(EMITTER2) U35.19(VDD1P9) U35.22(AVDD1P9_7) U35.44(AVDD1P9_6) U35.47(AVDD1P9_5) U35.51(AVDD1P9_4) U35.56(AVDD1P9_3) U35.61(AVDD1P9_2) U35.63(AVDD1P9_1) U137.3(TRD1) U137.4(TRD2) U137.9(TRD3) U137.10(TRD4)
P1V9_LAN2: C449.1 C450.1 C451.1 C452.1 C453.1 C454.1 C455.1 C456.1 C457.1 C458.1 C459.1 C460.1 C468.2 C469.1 C470.1 C471.1 C472.1 C473.1 C474.1 C475.1 C476.1 C520.1 C521.1 C522.1 C523.1 C524.1 Q16.2(COLLECTOR) Q16.4(EMITTER2) U37.19(VDD1P9) U37.22(AVDD1P9_7) U37.44(AVDD1P9_6) U37.47(AVDD1P9_5) U37.51(AVDD1P9_4) U37.56(AVDD1P9_3) U37.61(AVDD1P9_2) U37.63(AVDD1P9_1) U138.3(TRD1) U138.4(TRD2) U138.9(TRD3) U138.10(TRD4)
P1V26_BMC_NODE1: C286.1 C287.1 C288.1 C289.1 C290.1 C291.1 C292.1 C293.1 C294.1 C838.1 C839.1 C840.1 J23.2 L19.2 U14.F14(IV12D_1) U14.F15(IV12D_2) U14.K6(IV12D_3) U14.K17(IV12D_4) U14.L6(IV12D_5) U14.L17(IV12D_6) U14.P6(IV12D_7) U14.P17(IV12D_8) U14.R6(IV12D_9) U14.R17(IV12D_10) U14.U12(IV12D_11) U14.U13(IV12D_12) U14.Y18(MPLLDV12) U122.1(VOUT1) U122.2(VOUT2) U122.3(VOUT3)
P1V26_BMC_NODE1_ADJ: R1097.2 R1098.1 U122.4(ADJ)
P1V26_STB_NODE1_ADJ_S: J23.1 R1097.1
P1V538_BMC_NODE1: C226.1 C229.1 C230.1 C231.1 C232.1 C233.1 C234.1 C235.1 C236.1 C271.1 C272.1 C273.2 C274.1 C275.2 C830.1 C831.1 C832.1 C882.1 C892.1 C893.1 C894.1 J22.2 R259.2 R261.1 U14.U10(MVDD_1) U14.U11(MVDD_2) U14.U14(MVDD_3) U14.U15(MVDD_4) U15.A1(VDDQ0) U15.A8(VDDQ1) U15.B2(VDD0) U15.C1(VDDQ2) U15.C9(VDDQ3) U15.D2(VDDQ4) U15.D9(VDD1) U15.E9(VDDQ5) U15.F1(VDDQ6) U15.G7(VDD2) U15.H2(VDDQ7) U15.H9(VDDQ8) U15.K2(VDD3) U15.K8(VDD4) U15.N1(VDD5) U15.N9(VDD6) U15.R1(VDD7) U15.R9(VDD8) U121.1(VOUT1) U121.2(VOUT2) U121.3(VOUT3) U125.75(VTT1) U125.82(VTT2) U125.109(VTT3) U125.115(VTT4)
P1V538_BMC_NODE1_ADJ: C833.1 PR17.2 R1095.1 U121.4(ADJ)
P1V538_STB_NODE1_ADJ_S: C833.2 J22.1 R1095.2
P3V0_BAT_NODE1_R: R147.2 U3.2(A)
P3V3_CLK_NODE1: C1.1 C2.1 C3.1 C4.1 C5.1 C196.1 L2.2 R5.1 R6.1 R8.2 R11.2 R12.2 R13.2 R14.2 R19.2 R20.2 R21.2 R22.2 U1.3(VDD25_3.3) U1.7(VDDPCI_3.3) U1.14(VDD14_3.3) U1.15(VDD48_3.3) U1.20(VDD27)
P3V3_CLK_NODE1_R: L2.1 R1.2
P3V3_NODE1: C40.1 C41.1 C42.1 C134.2 C136.1 C140.1 C191.1 C225.2 C242.1 C243.1 C244.1 C248.1 C249.1 C250.1 C251.1 C252.1 C253.1 C254.1 C255.1 C256.1 C279.1 C280.1 C281.1 C282.1 C334.1 C335.1 C351.1 C352.1 C353.1 C354.1 C367.1 C377.1 C378.2 C379.2 C380.2 C381.2 C382.2 C390.1 C393.1 C394.1 C395.1 C396.1 C397.1 C398.1 C413.1 C414.1 C415.1 C416.1 C434.1 C439.1 C440.1 C441.1 C442.1 C443.1 C444.1 C445.1 C446.1 C447.1 C448.1 C484.1 C530.1 C537.1 C538.1 C539.1 C543.1 C550.1 C555.1 C566.2 C567.2 C568.2 C569.2 C570.2 C571.2 C572.2 C573.2 C574.1 C575.1 C576.1 C577.1 C578.1 C579.2 C580.1 C581.1 C582.1 C583.1 C584.1 C585.1 C586.1 C598.1 C599.1 C616.1 C617.1 C618.1 C619.1 C620.1 C621.1 C766.1 C776.1 C865.1 C866.1 C867.1 C868.1 C869.1 C870.1 C871.1 C881.1 C885.1 C888.1 C900.1 C901.1 C902.1 C903.1 C904.1 C905.1 C906.1 C907.1 C908.1 C909.1 C913.1 C918.1 C1119.2 C1120.2 C1121.1 C1122.1 D31.A D32.A D33.A D34.A D35.A D36.A D37.A D38.A J1.4 J2.199(VDDSPD) J5.1 J6.1 J18.B12(RSVD2) J26.4 J27.4 L13.2 L14.2 L15.2 L16.2 L20.1 L34.1 OSC6.4(VDD) PC48.1 PC49.1 PC50.1 PC53.2 PC131.1 PL17.2 PR20.2 PR23.1 PR24.1 PR25.1 PR52.2 PR54.2 PR79.1 PU5.16(VO) Q15.3(EMITTER) Q16.3(EMITTER) R1.1 R48.1 R68.1 R70.1 R86.1 R90.1 R94.1 R105.2 R109.2 R111.2 R122.1 R124.1 R126.1 R129.1 R131.1 R133.1 R140.2 R145.2 R146.2 R151.2 R152.2 R153.2 R157.2 R169.2 R177.1 R180.1 R186.1 R187.1 R196.1 R197.1 R198.1 R275.1 R280.1 R281.1 R283.1 R297.1 R298.1 R299.1 R300.1 R301.2 R302.1 R303.2 R304.1 R305.2 R309.2 R310.2 R314.2 R316.1 R317.1 R318.1 R319.1 R320.1 R321.1 R322.1 R323.1 R324.1 R325.1 R326.1 R327.1 R328.1 R329.1 R330.1 R331.1 R332.1 R333.1 R334.1 R335.1 R336.1 R337.1 R338.1 R339.1 R340.1 R341.1 R342.1 R343.1 R344.1 R345.1 R346.1 R501.2 R502.1 R509.1 R511.1 R514.1 R516.2 R517.1 R525.1 R527.1 R528.1 R529.1 R531.2 R532.2 R533.1 R534.1 R536.1 R537.1 R538.1 R539.1 R540.1 R541.1 R542.1 R544.1 R546.1 R548.1 R550.1 R551.1 R553.2 R555.2 R564.1 R566.1 R567.1 R568.1 R569.1 R570.1 R571.1 R572.1 R574.1 R576.1 R578.1 R580.1 R581.1 R583.2 R585.2 R594.1 R596.1 R597.1 R616.1 R617.1 R619.1 R620.1 R626.1 R631.1 R632.1 R633.1 R649.1 R650.1 R651.1 R652.1 R653.1 R663.1 R664.1 R665.1 R666.1 R667.1 R668.1 R669.1 R671.1 R672.1 R673.2 R674.1 R677.1 R680.2 R685.1 R686.1 R701.1 R702.1 R704.1 R706.1 R708.1 R734.1 R735.2 R737.2 R738.2 R739.2 R743.1 R759.2 R760.2 R762.1 R766.2 R767.2 R769.1 R771.1 R776.1 R778.1 R779.2 R780.2 R781.2 R782.2 R784.2 R785.2 R786.2 R787.2 R790.2 R791.2 R793.2 R799.1 R812.2 R814.1 R816.2 R1056.2 R1057.1 R1065.2 R1075.1 R1076.1 R1077.2 R1078.2 R1138.1 R1139.1 R1150.1 R1193.2 R1194.2 R1195.2 R1196.2 R1201.2 R1202.2 R1203.2 R1204.2 R1211.2 R1213.1 R1214.1 R1216.2 R1217.2 R1248.1 R1252.2 R1261.2 R1262.1 R1288.2 R1289.2 R1290.2 R1291.2 R1298.1 R1299.1 R1301.1 R1302.1 R1304.1 R1305.1 R1307.1 R1308.1 R1309.1 R1310.1 R1311.1 R1329.2 R1330.2 U2.AF23(VCCAGPIO3P3_6) U2.M37(VCCAGPIO3P3_1) U2.P37(VCCAGPIO3P3_2) U2.R37(VCCAGPIO3P3_3) U2.T36(VCCAGPIO3P3_4) U2.V36(VCCAGPIO3P3_5) U4.8(VCC) U5.8(VCC) U9.16(VDD) U13.8(VCC) U14.F8(R2VDD_1) U14.F9(R2VDD_2) U14.F10(R1VDD_1) U14.F11(R1VDD_2) U14.F12(PV33D_1) U14.F13(PV33D_2) U14.H6(PV33D_3) U14.H17(PV33D_4) U14.J6(PV33D_5) U14.J17(PV33D_6) U14.M6(PV33D_7) U14.M17(PV33D_8) U14.N6(PV33D_9) U14.N17(PV33D_10) U14.U8(PV33D_11) U14.U9(PV33D_12) U14.W18(USB2AV33) U16.5(VCC) U30.9(VDDIO_1) U30.57(VDDIO_2) U30.73(VDDIO_3) U31.8(VCC) U32.15(VDD33_1) U32.29(VDD33_2) U32.40(VDD33_3) U32.49(VDD33_4) U32.57(VDD33_5) U32.66(VDD33_6) U33.8(VCC) U35.1(AVDD3P3/VDD3P3) U35.10(VDD3P3_2) U35.32(VDD3P3_1) U36.8(VCC) U37.1(AVDD3P3/VDD3P3) U37.10(VDD3P3_2) U37.32(VDD3P3_1) U38.8(VCC) U51.26(VCC) U52.26(VCC) U55.26(VCC) U56.26(VCC) U57.26(VCC) U59.26(VCC) U60.16(VCC) U61.12(VDD) U62.24(VDD) U63.24(VDD) U64.24(VDD) U65.24(VDD) U66.24(VDD) U67.8(VCC) U68.5(VDD) U69.3(VCC) U70.3(VCC) U71.5(VDD) U73.12(VDD) U84.5(VCC) U85.5(VCC) U86.5(VCC) U87.5(VCC) U88.5(VCC) U89.5(VCC) U115.6(VCCO(BANK0)) U115.12(VCC#12) U115.30(VCCO(BANK1)) U115.36(VCC#36) U125.5(VAUX) U125.8(VDDR1) U125.20(VDDR2) U125.35(VDDR3) U125.39(VDDR4) U125.48(VDDR5) U125.55(VDDR6) U125.99(VDDR7) U125.124(VDDR8) U128.9(VCCIOB1_9) U128.13(VCCINT_13) U128.31(VCCIOB1_31) U128.45(VCCIOB1_45) U128.59(VCCIOB2_59) U128.63(VCCINT_63) U128.80(VCCIOB2_80) U128.94(VCCIOB2_94) U129.9(VCCIOB1_9) U129.13(VCCINT_13) U129.31(VCCIOB1_31) U129.45(VCCIOB1_45) U129.59(VCCIOB2_59) U129.63(VCCINT_63) U129.80(VCCIOB2_80) U129.94(VCCIOB2_94) U131.5(VCC) U133.5(VCC) U134.8(VCC) U135.5(VCC) U136.5(VCC) U145.5(VCC) U146.5(VCC)
P3V3_NODE1_FB: PC53.1 PR20.1 PR21.1 PU5.1(VFB)
P3V3_NODE1_SS: PC52.2 PU5.3(SS)
P3V3_NODE1_VREG5: PC51.1 PR18.1 PU5.2(VREG5)
P3V3_RTC_NODE1: C33.1 C34.1 D6.1 R143.2 R163.2 R175.2 U2.M44(VCCRTC3P3_1) U2.P44(VCCRTC3P3_2) U2.R44(VCCRTC3P3_3) U2.T44(VCCRTC3P3_4) U3.3(C)
P3V3_STB_NODE1: C179.1 C565.1 C782.1 C783.1 C784.1 C785.1 C786.1 C787.1 C788.1 C789.1 C790.1 C791.1 C792.1 C793.1 C795.1 C799.1 C853.2 C856.1 J20.4 OSC5.4(VDD) PC16.1 PC17.1 PC18.1 PC21.2 PC133.1 PL2.2 PR7.2 PR31.1 PU2.16(VO) Q31.5 R220.1 R223.2 R226.1 R800.2 R801.2 R802.2 R803.2 R1031.1 R1032.1 R1034.1 R1035.1 R1036.1 R1041.2 R1046.2 R1051.1 R1053.2 R1059.2 R1060.2 R1062.2 R1084.1 R1087.1 R1091.2 R1092.2 R1094.1 R1096.2 R1100.2 R1101.2 R1108.2 R1109.2 R1112.2 R1113.2 R1116.2 R1117.2 R1121.2 R1123.1 R1126.1 R1131.2 R1140.1 R1141.1 R1142.1 R1143.1 R1144.1 R1145.1 R1146.1 R1147.1 R1148.1 R1149.1 R1218.1 U3.1(B) U10.1(VCC) U58.5(VCC) U102.D4(VCCIO2_2) U102.D6(VCCIO2_1) U102.E4(VCCIO1_0) U102.E7(VCCINT_1) U102.F4(VCCINT_0) U102.F7(VCCIO2_0) U102.G4(VCCIO1_1) U102.G6(VCCIO1_2) U106.5(VCC) U123.10(VIN)
P3V3_STB_NODE1_EN: PJ2.2 PU2.6(EN)
P3V3_STB_NODE1_FB: PC21.1 PR7.1 PR8.1 PU2.1(VFB)
P3V3_STB_NODE1_SS: PC20.2 PU2.3(SS)
P3V3_STB_NODE1_VREG5: PC19.1 PR5.1 PU2.2(VREG5)
P3V3_SUS_NODE1: C108.1 C109.1 C110.1 C841.2 Q31.1 Q31.2 Q31.3 R75.1 R77.1 R112.1 R136.1 R138.1 R144.2 R195.1 R1023.2 R1102.2 U2.L42(VCCSUS3P3_1) U2.N42(VCCSUS3P3_2) U2.P42(VCCSUS3P3_3) U2.T42(VCCSUS3P3_4)
P3V3_USB_NODE1: C383.1 C384.2 C385.1 C386.2 L34.2 U32.6(AVDD33_1) U32.32(AVDD33_2)
P3V_COIN_CELL: BT1.1 R147.1
P5V_CRT: C509.2 FS2.1 J9.9(P5V) R634.1 R635.1 U44.2 U45.2 U46.2 U47.2 U48.2 U49.2 U50.2
P5V_NODE1: C135.2 C481.1 C491.1 C493.1 C497.1 C535.1 C536.1 C556.1 C559.1 C845.2 FS3.1 FS4.1 J1.8 J8.2 L36.2 L38.2 Q35.1 Q35.2 Q35.3 R614.1 R615.1 R629.1 R689.2 R690.2 R691.2 R692.2 R693.2 R694.2 R695.2 R696.2 R697.2 R698.2 R699.2 R700.2 R703.2 R705.2 R707.2 R709.2 R710.2 R711.2 R712.2 R713.2 R714.2 R715.2 R716.2 R717.2 R720.2 R721.2 R722.2 R723.2 R724.2 R725.2 R726.2 R727.2 R728.2 R729.2 R730.2 R731.2 R732.2 R733.2 R736.2 R740.2 R741.2 R742.2 R744.2 R745.2 R746.2 R747.2 R748.2 R749.2 R777.1 R1005.1 R1009.1 R1011.1 R1015.1 R1017.1 R1020.1 R1110.2 R1132.1 R1134.1 R1136.1 R1263.1 R1264.1 R1282.1 R1283.1 R1284.1 R1322.1 R1323.1 R1325.1 U43.4(VCC#4) U43.35(VCC#35) U132.8(VCC)
P5V_STB_NODE1: C180.1 C809.1 C817.1 C827.1 C835.1 C883.1 PC5.1 PC6.1 PC7.1 PC10.2 PC14.1 PC35.1 PC46.1 PC59.2 PC76.2 PC132.1 PJ9.2 PL12.2 PR3.2 PR41.1 PR48.2 PU1.16(VO) PU2.15(VCC) PU4.15(VCC) PU5.15(VCC) PU6.9(V5) PU7.15(V5IN) PU8.14(ICCMAXA) PU8.18(OCSETA) PU8.29(ISENAN) PU8.30(ISENAP) Q35.5 R628.1 R1090.1 R1111.1 R1115.1 U11.5(VCC) U119.10(VDD) U120.10(VDD) U121.10(VDD) U122.10(VDD) U130.10(VDD)
P5V_STB_NODE1_EN: PC25.1 PJ1.1 R1082.1 R1083.1
P5V_STB_NODE1_EN_P: PJ1.2 PU1.6(EN)
P5V_STB_NODE1_FB: PC10.1 PR3.1 PR4.1 PU1.1(VFB)
P5V_STB_NODE1_SS: PC9.2 PU1.3(SS)
P5V_STB_NODE1_VREG5: PC8.1 PR1.1 PU1.2(VREG5)
P12V_AUX: C771.1 C772.1 C773.1 C774.1 C775.1 PC1.1 PC2.1 PC3.1 PC11.1 PC12.1 PC13.1 PC32.1 PC33.1 PC34.1 PC43.1 PC44.1 PC45.1 PR22.2 PR32.2 PR49.2 PU1.13(VIN_1) PU1.14(VIN_2) PU1.15(VCC) PU2.13(VIN_1) PU2.14(VIN_2) PU4.13(VIN_1) PU4.14(VIN_2) PU5.13(VIN_1) PU5.14(VIN_2) Q22.1 Q22.2 Q22.3 R655.2 R657.2 R1026.2 R1039.2 R1082.2 R1099.1 R1107.1 R1129.1 R1130.1 R1249.1
P12V_AUX_EN: C778.1 R1006.1 R1022.1 U92.D(DRAIN) U93.D(DRAIN) U100.3(ON) U109.D(DRAIN)
P12V_DBG: D28.1(A) D29.1(A) J19.3(12V#3) J19.4(12V#4) R1070.2 R1071.1
P12V_NODE1_PWRGD_EN: C781.1 R1026.1 R1028.1 U101.3(VCC)
P12V_PDB: C767.1 C768.1 C769.1 C770.1 C777.1 D20.3(CATHODE) D28.2(C) D29.2(C) J35.A78(GND31) J35.A79(GND32) J35.A80(HSIP15+) J35.A81(HSIP15-) J35.A82(GND33) J35.B79(HSOP15-) J35.B80(GND67) J35.B82(RSVD4) R1006.2 R1007.1 R1012.2 R1019.1 R1071.2 U100.1(VCC)
VCC5_CRTXX: C498.1 CD1.1 L38.1
A_CPU0_NODE1_THERMDA: C137.1 U2.AD39(CPU0_THERMDA) U9.1(DP1)
A_CPU0_NODE1_THERMDC: C137.2 U2.AC38(CPU0_THERMDC) U9.2(DN1)
A_CPU1_NODE1_THERMDA: C138.1 U2.AG39(CPU1_THERMDA) U9.3(DP2/DN3)
A_CPU1_NODE1_THERMDC: C138.2 U2.AF38(CPU1_THERMDC) U9.4(DN2/DP3)
A_CPU_NODE1_AE64_PU: R103.2 U2.AE64(TESTHI_1P05)
A_CPU_NODE1_HV_GPIO_RCOMP: R98.1 U2.M38(HV_GPIO_RCOMP)
A_CPU_NODE1_LV_GPIO_RCOMP: R101.1 U2.AC47(LV_GPIO_RCOMP)
A_CPU_NODE1_MV_GPIO_RCOMP: R100.1 U2.P34(MV_GPIO_RCOMP)
A_CPU_NODE1_NTB_CROSSLK_MODE: R104.2 U2.B41(TESTLO_00)
A_CPU_NODE1_RTC_EXTPAD: C23.1 U2.L65(RTC_EXTPAD)
A_CPU_NODE1_SOC_THERMREFNPAD: R120.1 R200.1 U2.R22(SOC_THERMREFNPAD)
A_NODE1_RP0_RCOMP: R36.2 U2.AT23(RP0_RCOMP)
A_SOC_NODE1_THERMDA: C139.1 U2.R21(SOC_THERMDA) U9.10(DP4/DN5)
A_SOC_NODE1_THERMDC: C139.2 U2.P21(SOC_THERMDC) U9.9(DN4/DP5)
ATTENTION_LED_N: R146.1 U65.10(P0_6) U131.1(1A)
ATTENTION_LED_R: D18.1(R) U131.6(1Y)
BMC_DEBUG_RXD: PJ18.2 U14.G1(RXD5)
BMC_DEBUG_TXD: PJ19.1 U14.H5(TXD5)
BMC_NODE1_ADCAV33: C257.1 C258.1 L14.1 U14.P3(ADCAV33)
BMC_NODE1_ADCREXT: R313.2 U14.P2(ADCREXT)
BMC_NODE1_CLK_24M: R312.2 U14.AB22(CLKIN)
BMC_NODE1_CLK_24M_R: OSC3.3(OUT) R312.1
BMC_NODE1_DACAV33: C262.1 C263.1 C264.1 R314.1 U14.P1(DACAV33) U14.T3(DACDV33)
BMC_NODE1_DACRSET: R315.2 U14.R1(DACRSET)
BMC_NODE1_DDR3_ZQ: R260.1 U15.L8(ZQ_ZQO)
BMC_NODE1_DDR_BA0: U14.W14(MBA0) U15.M2(BA0)
BMC_NODE1_DDR_BA1: U14.AA14(MBA1) U15.N8(BA1)
BMC_NODE1_DDR_BA2: U14.Y14(MBA2) U15.M3(BA2)
BMC_NODE1_DDR_CAS_L: U14.AB13(MCAS#) U15.K3(CAS_N)
BMC_NODE1_DDR_CKE: U14.Y12(MCKE) U15.K9(CKE_CKEO)
BMC_NODE1_DDR_CLK_DN: U14.AA12(MCK#) U15.K7(CK_N)
BMC_NODE1_DDR_CLK_DP: U14.AB12(MCK) U15.J7(CK)
BMC_NODE1_DDR_CS_L: U14.AA13(MCS#) U15.L2(CS_N_CSO_N)
BMC_NODE1_DDR_D0: U14.W12(MDQ0) U15.H7(DQL7)
BMC_NODE1_DDR_D1: U14.V12(MDQ1) U15.H3(DQL4)
BMC_NODE1_DDR_D2: U14.AB11(MDQ2) U15.F8(DQL3)
BMC_NODE1_DDR_D3: U14.AA11(MDQ3) U15.F7(DQL1)
BMC_NODE1_DDR_D4: U14.Y11(MDQ4) U15.F2(DQL2)
BMC_NODE1_DDR_D5: U14.W11(MDQ5) U15.G2(DQL6)
BMC_NODE1_DDR_D6: U14.V11(MDQ6) U15.H8(DQL5)
BMC_NODE1_DDR_D7: U14.Y10(MDQ7) U15.E3(DQL0)
BMC_NODE1_DDR_D8: U14.V10(MDQ8) U15.D7(DQU0)
BMC_NODE1_DDR_D9: U14.AB9(MDQ9) U15.B8(DQU6)
BMC_NODE1_DDR_D10: U14.AA9(MDQ10) U15.A7(DQU4)
BMC_NODE1_DDR_D11: U14.Y9(MDQ11) U15.C3(DQU1)
BMC_NODE1_DDR_D12: U14.W9(MDQ12) U15.C2(DQU3)
BMC_NODE1_DDR_D13: U14.V9(MDQ13) U15.C8(DQU2)
BMC_NODE1_DDR_D14: U14.Y8(MDQ14) U15.A3(DQU7)
BMC_NODE1_DDR_D15: U14.W8(MDQ15) U15.A2(DQU5)
BMC_NODE1_DDR_DM0: U14.W10(MDM0) U15.E7(DML)
BMC_NODE1_DDR_DM1: U14.V8(MDM1) U15.D3(DMU)
BMC_NODE1_DDR_DQS0_DN: U14.AA10(MDQS0#) U15.G3(DQSL_N)
BMC_NODE1_DDR_DQS0_DP: U14.AB10(MDQS0) U15.F3(DQSL)
BMC_NODE1_DDR_DQS1_DN: U14.AB8(MDQS1#) U15.B7(DQSU_N)
BMC_NODE1_DDR_DQS1_DP: U14.AA8(MDQS1) U15.C7(DQSU)
BMC_NODE1_DDR_IOZ: R257.2 U14.V16(MIOZ)
BMC_NODE1_DDR_MA0: U14.AB14(MA0) U15.N3(A0)
BMC_NODE1_DDR_MA1: U14.W15(MA1) U15.P7(A01)
BMC_NODE1_DDR_MA2: U14.V15(MA2) U15.P3(A02)
BMC_NODE1_DDR_MA3: U14.Y16(MA3) U15.N2(A03)
BMC_NODE1_DDR_MA4: U14.AB15(MA4) U15.P8(A04)
BMC_NODE1_DDR_MA5: U14.W16(MA5) U15.P2(A05)
BMC_NODE1_DDR_MA6: U14.AA15(MA6) U15.R8(A06)
BMC_NODE1_DDR_MA7: U14.AB18(MA7) U15.R2(A07)
BMC_NODE1_DDR_MA8: U14.AB16(MA8) U15.T8(A08)
BMC_NODE1_DDR_MA9: U14.AA17(MA9) U15.R3(A09)
BMC_NODE1_DDR_MA10: U14.Y15(MA10) U15.L7(A10_AP)
BMC_NODE1_DDR_MA11: U14.AA16(MA11) U15.R7(A11)
BMC_NODE1_DDR_MA12: U14.W17(MA12) U15.N7(A12)
BMC_NODE1_DDR_MA13: U14.Y17(MA13) U15.T3(A13)
BMC_NODE1_DDR_MA14: U14.AB17(MA14) U15.T7(A14)
BMC_NODE1_DDR_ODT: U14.V14(MODT) U15.K1(ODT_ODTO)
BMC_NODE1_DDR_RAS_L: U14.W13(MRAS#) U15.J3(RAS_N)
BMC_NODE1_DDR_RST_L: R259.1 U15.T2(RESET_N) U16.4(Y)
BMC_NODE1_DDR_WE_L: U14.Y13(MWE#) U15.L3(WE_N)
BMC_NODE1_GFX_BLUE: C501.1 L39.1 R290.1 U14.R4(DACB)
BMC_NODE1_GFX_GREEN: C500.1 L40.1 R291.1 U14.R3(DACG)
BMC_NODE1_GFX_HSYNC: R670.2 U132.5(A2)
BMC_NODE1_GFX_HSYNC_R: R670.1 U14.T4(VGAHS_GPIOJ4)
BMC_NODE1_GFX_RED: C499.1 L41.1 R292.1 U14.R2(DACR)
BMC_NODE1_GFX_VSYNC: R675.2 U132.2(A1)
BMC_NODE1_GFX_VSYNC_R: R675.1 U14.U2(VGAVS_GPIOJ5)
BMC_NODE1_HPLLAV33: C268.1 C269.1 C270.1 L16.1 U14.V17(HPLLAV33)
BMC_NODE1_JTAG_TCK: R304.2 U14.F2(TCK)
BMC_NODE1_JTAG_TDI: R300.2 U14.F1(TDI)
BMC_NODE1_JTAG_TMS: R302.2 U14.G2(TMS)
BMC_NODE1_JTAG_TRST: R298.2 U14.E1(NTRST)
BMC_NODE1_MPLLAV33: C265.1 C266.1 C267.1 L15.1 U14.AB19(MPLLAV33)
BMC_NODE1_OSC1_EN: OSC3.1(OE) R311.1
BMC_NODE1_OSC1_VDD: C246.1 C247.2 L13.1 OSC3.4(VDD) R311.2
BMC_NODE1_USBVREF: R294.1 U14.AA20(USB2VRES)
BMC_NODE1_V1PLLAV12: C295.1 C296.1 C297.1 L19.1 U14.W19(V1PLLAV12) U14.Y20(V2PLLAV12)
BMC_NODE1_VCC_1V8_PCIE: C276.1 C277.1 C278.1 L17.1 U14.G20(PEDV18_1) U14.H21(PEDV18_2) U14.H22(PEDV18_3)
BMC_NODE1_VCC_1V8_PCIEA: C283.1 C284.1 C285.1 L18.1 U14.C21(PEAV18) U14.F20(PEPLLAV18)
BMC_ROMA0: R316.2 U14.R20(ROMA0)
BMC_ROMA1: R317.2 U14.R21(ROMA1)
BMC_ROMA2: R318.2 U14.R22(ROMA2)
BMC_ROMA3: R319.2 U14.P18(ROMA3)
BMC_ROMA4: R320.2 U14.P19(ROMA4)
BMC_ROMA5: R321.2 U14.P20(ROMA5)
BMC_ROMA6: R322.2 U14.P21(ROMA6)
BMC_ROMA7: R323.2 U14.P22(ROMA7)
BMC_ROMA8: R324.2 U14.M19(ROMA8)
BMC_ROMA9: R325.2 U14.M20(ROMA9)
BMC_ROMA10: R326.2 U14.M21(ROMA10)
BMC_ROMA11: R327.2 U14.M22(ROMA11)
BMC_ROMA12: R328.2 U14.L18(ROMA12)
BMC_ROMA13: R329.2 U14.L19(ROMA13)
BMC_ROMA14: R330.2 U14.L20(ROMA14)
BMC_ROMA15: R331.2 U14.L21(ROMA15)
BMC_ROMA16: R332.2 U14.T18(ROMA16)
BMC_ROMA17: R333.2 U14.N18(ROMA17)
BMC_ROMA18: R334.2 U14.N19(ROMA18)
BMC_ROMA19: R335.2 U14.M18(ROMA19)
BMC_ROMA20: R336.2 U14.N22(ROMA20)
BMC_ROMA21: R337.2 U14.N20(ROMA21)
BMC_ROMA22: R338.2 U14.L22(ROMA22_GPIOS6)
BMC_ROMA23: R339.2 U14.K18(ROMA23_GPIOS7)
BMC_ROMD0: R340.2 U14.T22(ROMD0)
BMC_ROMD1: R341.2 U14.T21(ROMD1)
BMC_ROMD2: R342.2 U14.T20(ROMD2)
BMC_ROMD3: R343.2 U14.U22(ROMD3)
BMC_ROMD4: R344.2 U14.U21(ROMD4_GPIOS0)
BOT_85OHM: J29.2 J29.3
CLK_14M_CPU_NODE1: R10.2 U2.P46(HPET_CLK14IN)
CLK_14M_CPU_NODE1_R: R10.1 R22.1 R26.2 U1.13(14M_2X/FSLC)
CLK_25M_SATA_NODE1: R9.2 U30.35(XTLIN_OSC)
CLK_25M_SATA_NODE1_R: R9.1 U1.4(25M)
CLK_33K_CPLD23: R1055.2 U128.64(IO42_B2/GCLK3) U129.64(IO42_B2/GCLK3)
CLK_33K_CPU_NODE1_SUSCLK: R139.1 R1052.2 U102.E2(GCLK0_IO_39)
CLK_33K_CPU_NODE1_SUSCLK_R: OSC5.3(OUT) R1052.1
CLK_33K_CPU_NODE1_SUSCLK_RR: R139.2 U2.T52(SUSCLK)
CLK_33M_PORT80: R188.2 U115.43(CLK0/I)
CLK_48M_SIO: R135.2 R815.1
CLK_100M_BMC_NODE1_DN: U1.43(SRC#7_LPRS) U14.G21(PEREFCLKN)
CLK_100M_BMC_NODE1_DP: U1.44(SRC7_LPRS) U14.G22(PEREFCLKP)
CLK_100M_CPU_NODE1_DN: U1.50(CPU1#_LPRS) U2.V20(HPLL_CLKREFN)
CLK_100M_CPU_NODE1_DP: U1.51(CPU1_LPRS) U2.V21(HPLL_CLKREFP)
CLK_100M_DDR3_NODE1_DN: U1.53(CPU0#_LPRS) U2.BF45(DDR3_CLKREFN)
CLK_100M_DDR3_NODE1_DP: U1.54(CPU0_LPRS) U2.BG45(DDR3_CLKREFP)
CLK_100M_NIC1_NODE1_DN: U1.36(SRC3#_LPRS) U35.25(PECLKN)
CLK_100M_NIC1_NODE1_DP: U1.37(SRC3_LPRS) U35.26(PECLKP)
CLK_100M_NIC2_NODE1_DN: U1.32(SRC4#_LPRS) U37.25(PECLKN)
CLK_100M_NIC2_NODE1_DP: U1.33(SRC4_LPRS) U37.26(PECLKP)
CLK_100M_PCIE_RP0_NODE1_DN: U1.41(SRC2#_LPRS) U2.BF4(RP0_CLKINN)
CLK_100M_PCIE_RP0_NODE1_DP: U1.42(SRC2_LPRS) U2.BE5(RP0_CLKINP)
CLK_100M_PCIE_SW_NODE1_C_DN: C193.2 U125.93(REFCLK_N)
CLK_100M_PCIE_SW_NODE1_C_DP: C192.2 U125.91(REFCLK_P)
CLK_100M_PCIE_SW_NODE1_DN: C193.1 U1.24(DOT96#_LPRS/SRC5#_LPRS)
CLK_100M_PCIE_SW_NODE1_DP: C192.1 U1.23(DOT96_LPRS/SRC5_LPRS)
CLK_100M_SATA_NODE1_DN: U1.30(SATA#_LPRS) U30.46(CLKN)
CLK_100M_SATA_NODE1_DP: U1.31(SATA_LPRS) U30.45(CLKP)
CLK_100M_USB_NODE1_DN: U1.38(SRC6#_LPRS) U32.5(PECLKN)
CLK_100M_USB_NODE1_DP: U1.39(SRC6_LPRS) U32.4(PECLKP)
CLK_100M_XDP_NODE1_DN: J3.42 U1.46(CPU_ITP#/SRC1#_LPRS)
CLK_100M_XDP_NODE1_DP: J3.40 U1.47(CPU_ITP/SRC1_LPRS)
CLK_FSLB_NODE1: R14.1 R16.2 U1.9(FSLB/PCI2_2X)
CLKREQA_NODE1_N: R19.1 R23.2 U1.10(CLKREQA#/PCI3_2X)
CLKREQB_NODE1_N: R13.1 R15.2 U1.19(CLKREQB#)
CLKREQC_NODE1_N: R21.1 R25.2 R135.1 U1.17(CLKREQC#/48M)
CLP_ITP_EN_NODE1: R11.1 R17.2 R188.1 U1.8(VITP_EN/PCI_F1_2X)
CM_CABLE_DET_N: R779.1 U73.16(GPIO7)
CM_PWR_CTL_IN: J35.B78(HSOP15+) R1281.1
CM_PWR_CTL_IN_R: C794.1 R1251.1 R1281.2 U109.G(GATE)
CM_STATUS_LED_N: R145.1 U65.11(P0_7) U102.C7(IO_28) U131.3(2A)
CM_STATUS_LED_R: D19.1(R) U131.4(2Y)
CMC_CPLD_RSV1: U61.16(GPIO7) U128.62(IO41_B2/GCLK2)
CMC_CPU_RST_N: U61.11(GPIO6) U129.61(IO8_B2)
COM3_WAKEUP: R680.1 R792.2 U61.13(WAKEUP)
COM4_EN_N: R521.1 R1217.1 U103.D(DRAIN) U135.1(OE#) U136.1(OE#)
CONSOLE_SELECT_N: J34.1 R195.2 U2.P50(GPIOSUS3)
CPLD1_RSV1: R627.2 U102.K8(IO_79)
CPLD1_RSV2: R660.2 U102.K7(IO_78)
CPLD1_RSV3: R661.2 U102.K6(IO_77)
CPLD2_RSV1: R662.2 U128.49(IO32_B1)
CPLD2_RSV2: R676.2 U128.50(IO33_B1)
CPLD2_RSV3: R678.2 U128.51(IO34_B1)
CPLD3_RSV1: R679.2 U129.49(IO32_B1)
CPLD3_RSV2: R684.2 U129.50(IO33_B1)
CPLD3_RSV3: R775.2 U129.51(IO34_B1)
CPLD123_RSV1: R627.1 R662.1 R679.1 R1181.1
CPLD123_RSV2: R660.1 R676.1 R684.1 R1183.1
CPLD123_RSV3: R661.1 R678.1 R775.1 R1185.1
CPLD_CPU_THRMTRIP_N: Q41.C(3) R1131.1 U102.H5(IO_58)
CPLD_EXT_RST_N: U102.F8(GCLK2_IO_47) U129.30(IO19_B1)
CPLD_FAN_MAX_CTRL: U68.2(CONV/IN) U69.13(F\L\S\P\D\/T_ST) U128.78(IO21_B2)
CPLD_ROW_EN: U2.K50(GPIOCORE1) U102.J3(IO_64)
CPLD_ROW_LATCH: U2.K48(GPIOCORE2) U102.J4(IO_65)
CPLD_THRMTRIP_LOG_N: U63.19(P1_6) U102.H8(IO_61)
CPLD_UART_DTR_P3_N: R807.1 R1170.2 R1171.1 U129.1(IO40_B2)
CPLD_UART_DTR_P3_R_N: R1170.1 U57.12(DIN3)
CPLD_UART_DTR_P4_N: R811.1 R1176.2 R1177.1 U128.1(IO40_B2)
CPLD_UART_DTR_P4_R_N: R1176.1 U59.12(DIN3)
CPLD_UART_RI_P3_LS_N: R1061.1 U57.18(ROUT2) U141.S(SOURCE)
CPLD_UART_RI_P3_N: R521.2 R806.1 R1061.2 R1261.1 U103.G(GATE) U129.98(IO37_B2) U141.D(DRAIN)
CPLD_UART_RI_P4_LS_N: R1064.1 U59.18(ROUT2) U142.S(SOURCE)
CPLD_UART_RI_P4_N: R810.1 R1064.2 R1252.1 U128.98(IO37_B2) U142.D(DRAIN)
CPLD_UART_RTS_P3_N: R794.1 R1169.2 R1172.1 U129.97(IO36_B2)
CPLD_UART_RTS_P3_R_N: R1169.1 U57.14(DIN1)
CPLD_UART_RTS_P4_N: R809.1 R1175.2 R1178.1 U128.97(IO36_B2)
CPLD_UART_RTS_P4_R_N: R1175.1 U59.14(DIN1)
CPLD_UART_RX_P3: R1167.2 R1168.1 U129.99(IO38_B2)
CPLD_UART_RX_P3_R: R1167.1 U57.19(ROUT1)
CPLD_UART_RX_P4: R1173.2 R1174.1 U128.99(IO38_B2)
CPLD_UART_RX_P4_R: R1173.1 U59.19(ROUT1)
CPLD_UART_TX_P3: U57.13(DIN2) U129.100(IO39_B2)
CPLD_UART_TX_P4: U59.13(DIN2) U128.100(IO39_B2)
CPLD_WDT1: R623.1 U128.43(IO35_B1/DEV_OE) U129.43(IO35_B1/DEV_OE)
CPLD_WDT1_R: R623.2 U61.14(GPIO5)
CPLD_WDT2: R622.1 R755.1 U128.44(IO36_B1/DEV_CLRN) U129.44(IO36_B1/DEV_CLRN)
CPLD_WDT2_R: R622.2 R793.1 U73.11(GPIO6)
CPLD_WDT3: R1179.2 R1180.1 U128.12(IO37_B1/GCLK0) U129.12(IO37_B1/GCLK0)
CPLD_WDT3_R: R1179.1 R1195.1 U43.112(PD3/GP63)
CPU_NODE1_PROCHOT_N: Q42.C(3) R1216.1 U2.E57(GPIOCORE13)
CPU_RSV_1: R110.2 U128.14(IO38_B1/GCLK1) U129.14(IO38_B1/GCLK1)
CPU_RSV_1_R: R110.1 U2.H52(GPIOCORE4)
CPU_STP_NODE1: R6.2 U1.45(CPU_STOP#_3.3)
CRT_B: C504.1 J9.3(V_IO_B) R659.2 U44.3
CRT_B_L: L39.2 R642.1 R659.1
CRT_DDCCLK: C508.1 J9.15(DDC_SCL) R636.2 U49.3
CRT_DDCDATA: C505.1 J9.12(DDC_SDA) R639.2 U47.3
CRT_G: C503.1 J9.2(V_IO_G) R788.2 U45.3
CRT_G_L: L40.2 R641.1 R788.1
CRT_HSYNC: C506.1 J9.13(IO_HSYNC) R638.2 U48.3
CRT_R: C502.1 J9.1(V_IO_R) R789.2 U46.3
CRT_R_L: L41.2 R640.1 R789.1
CRT_VSYNC: C507.1 J9.14(IO_VSYNC) R637.2 U50.3
FAN1_TACH: R756.2 R821.1
FAN1_TACH_IN: R756.1 U69.6(TACH1)
FAN1_TACH_R: J18.B27(HSOP3+) R821.2 R1219.1
FAN2_TACH: R757.2 R823.1
FAN2_TACH_IN: R757.1 U69.7(TACH2)
FAN2_TACH_R: J18.B28(HSOP3-) R823.2 R1220.1
FAN3_TACH: R758.2 R825.1
FAN3_TACH_IN: R758.1 U69.4(TACH3)
FAN3_TACH_R: J18.B29(GND43) R825.2 R1221.1
FAN4_TACH: R761.2 R827.1
FAN4_TACH_IN: R761.1 U69.9(TACH4)
FAN4_TACH_R: J18.A26(HSIP2-) R827.2 R1222.1
FAN5_TACH: R768.2 R829.1
FAN5_TACH_IN: R768.1 U70.6(TACH1)
FAN5_TACH_R: J18.A27(GND8) R829.2 R1223.1
FAN6_TACH: R770.2 R830.1
FAN6_TACH_IN: R770.1 U70.7(TACH2)
FAN6_TACH_R: J18.A28(GND9) R830.2 R1224.1
FAN_MAX_CTRL: R1211.1 R1225.1 U61.15(GPIO4) U128.61(IO8_B2)
FAN_PWM: R778.2 R819.1 U133.4(Y)
FAN_PWM_BUF: R799.2 U69.15(PWM1) U133.2(A)
FAN_PWM_R: C588.1 J18.A30(HSIP3-) R819.2
FM_BMC_NODE1_RESET_L: R1030.2 U14.W20(SRST#) U16.2(A)
FM_CPLD_CLK_R_PG_NODE1_R: R7.1 R8.1 U1.55(CLKPWRGD/PD#_3.3)
FM_CPLD_NODE1_BMC_PERST_L: R254.1 U102.D8(IO_35)
FM_CPLD_NODE1_BMC_SRST_L: R1030.1 U102.D10(IO_32)
FM_CPLD_NODE1_CLK_PG: R7.2 U102.B8(IO_19)
FM_CPLD_NODE1_CPU_RESET_L: J3.46 R560.1 R590.1 R621.1 U2.T58(RESET#) U102.G8(IO_53)
FM_CPLD_NODE1_CPU_RSMRST_L: U2.L63(RSMRST#) U102.F9(IO_48)
FM_CPLD_NODE1_DEBUG_MODE: R1036.2 R1037.2 U102.J6(IO_67)
FM_CPLD_NODE1_JTAG_POK_L: R1050.2 U102.H9(IO_62)
FM_CPLD_NODE1_JTAG_POK_R_L: Q28.B(1) R1050.1
FM_CPLD_NODE1_LPCRST_L: J1.3 U102.C5(IO_26) U115.18(CLK1/I)
FM_CPLD_NODE1_P1V0_EN: PJ3.1 U102.B4(IO_15)
FM_CPLD_NODE1_P1V5_EN: C850.1 Q40.S R1116.1 R1240.2 U102.B3(IO_14)
FM_CPLD_NODE1_P1V05_EN: PJ6.1 R1239.1 U102.B5(IO_16)
FM_CPLD_NODE1_P1V5_EN_G: Q40.G R1117.1
FM_CPLD_NODE1_P1V5_EN_LV: C849.1 Q39.4 Q40.D R1115.2
FM_CPLD_NODE1_P1V5_SUS_EN: C819.1 R1106.2 U102.A6(IO_07) U120.6(EN)
FM_CPLD_NODE1_P1V05_SUS_EN: C811.1 R1104.2 U102.A9(IO_10) U119.6(EN)
FM_CPLD_NODE1_P1V8_EN: C848.1 Q38.S R1112.1 R1238.2 U102.B2(IO_13)
FM_CPLD_NODE1_P1V8_EN_G: Q38.G R1113.1
FM_CPLD_NODE1_P1V8_EN_LV: C847.1 Q37.4 Q38.D R1111.2
FM_CPLD_NODE1_P1V8_STB_EN: PC30.1 PJ4.1 R1232.2 U102.A3(IO_04)
FM_CPLD_NODE1_P1V8_STB_S_EN: PJ4.2 PU4.6(EN)
FM_CPLD_NODE1_P1V8_SUS_EN: C826.1 Q30.S R1091.1 R1231.2 U102.B9(IO_20)
FM_CPLD_NODE1_P1V8_SUS_EN_G: Q30.G R1092.1
FM_CPLD_NODE1_P1V8_SUS_EN_LV: C825.1 Q29.4 Q30.D R1090.2
FM_CPLD_NODE1_P1V26_BMC_EN: C837.1 R1234.2 U102.A5(IO_06) U122.6(EN)
FM_CPLD_NODE1_P1V538_BMC_EN: C829.1 R1233.2 U102.A4(IO_05) U121.6(EN)
FM_CPLD_NODE1_P3V3_EN: C933.1 PJ5.1 R1237.2 U102.A10(IO_02)
FM_CPLD_NODE1_P3V3_S_EN: PJ5.2 PU5.6(EN)
FM_CPLD_NODE1_P3V3_SUS_EN: C842.1 Q32.S R1100.1 R1235.2 U102.B10(IO_12)
FM_CPLD_NODE1_P3V3_SUS_EN_G: Q32.G R1101.1
FM_CPLD_NODE1_P3V3_SUS_EN_LV: C841.1 Q31.4 Q32.D R1099.2
FM_CPLD_NODE1_P5V_EN: C846.1 Q36.S R1108.1 R1236.2 U102.A1(IO_01)
FM_CPLD_NODE1_P5V_EN_LV: C845.1 Q35.4 Q36.D R1107.2
FM_CPLD_NODE1_P5V_NODE1_EN_G: Q36.G R1109.1
FM_CPLD_NODE1_PVCCP_EN: PJ16.1 U102.B7(IO_18)
FM_CPLD_NODE1_PVDDR_STB_EN: PC31.1 PJ10.1 R1241.2 U102.A7(IO_08)
FM_CPLD_NODE1_PVTT_DDR_EN: C198.1 R1242.2 U102.B6(IO_17) U123.7(EN)
FM_CPLD_NODE1_PWR_BTN_CPU: U2.M56(GPIOSUS2) U102.E1(GCLK1_IO_37)
FM_CPLD_NODE1_PWR_BTN_L: R1066.2 U102.J8(IO_69) U106.4(Y)
FM_CPLD_NODE1_SATA_PERST_L: U30.53(PERST#) U102.C8(IO_29)
FM_CPLD_NODE1_SYS_PG: R142.2 U2.J63(PWROK) U102.F10(IO_44)
FM_CPLD_NODE1_USB_PERST_L: R274.1 U102.C9(IO_30)
FM_CPLD_NODE1_USB_PONRST_L: R527.2 U32.14(PONRSTB) U102.C10(IO_22)
FM_CPLD_NODE1_WDT: Q25.C(3) R1041.1 U102.K3(IO_74)
FM_CPLD_NODE1_WDT_R: Q25.B(1) R1043.1
FM_CPLD_PCIE_SW_PERST_L: R231.1 U102.C1(IO_21)
FM_CPU_NODE1_JTAG_POK: Q28.C(3) R1049.1 U2.AC53(JTA_POWEROK)
FM_CPU_NODE1_OWDTOUT: Q25.E(2) U2.AH53(OWDTOUT)
FM_CPU_NODE1_RSTRDY_L: R138.2 U2.M54(RSTRDY#) U102.J5(IO_66)
FM_CPU_NODE1_RSTWARN: R134.2 U2.T53(RSTWARN) U102.E8(IO_41)
FM_CPU_NODE1_SLPMODE: U2.R56(SLPMODE) U102.K4(IO_75)
FM_CPU_NODE1_SLPRDY_L: R136.2 U2.R58(SLPRDY#) U102.K5(IO_76)
FM_CPU_NODE1_XDP_PG_RST: R222.2 U102.H6(IO_59)
FM_NODE1_CORE0_1_RST_L: Q27.C(3) R1046.1 U102.K2(IO_73)
FM_NODE1_DDR3_DRAM_POK_L: R1042.2 U102.G9(IO_54)
FM_NODE1_DDR3_DRAM_POK_R_L: Q24.B(1) R1042.1
FM_NODE1_DDR3_SYSPWRGD_L: R1045.2 U102.G10(IO_50)
FM_NODE1_DDR3_SYSPWRGD_R_L: Q26.B(1) R1045.1
FM_NODE1_DFX_GPIO_GRP05: R1047.2 U2.H30(DFX_GPIO_GRP0_5)
FM_NODE1_DFX_GPIO_GRP05_R: Q27.B(1) R1047.1
FM_OSC_NODE1_OSC_NC: OSC5.1(NC/I\N\H\) R1051.2
FNACTRL1_ADD: R762.2 R763.1 U69.11(ADDR)
FNACTRL1_TMP_IN: U68.1(OUT) U69.12(TMP_IN)
FNACTRL2_ADD: R771.2 R772.1 U70.11(ADDR)
FNACTRL2_T_ST: U70.13(F\L\S\P\D\/T_ST) U71.2(CONV/IN)
FNACTRL2_TMP_IN: U70.12(TMP_IN) U71.1(OUT)
FRU_SYS_A0: R180.2 R1152.2 U134.1(A0)
FRU_SYS_A1: R186.2 R1153.2 U134.2(A1)
FRU_SYS_A2: R187.2 R1154.2 U134.3(A2)
GFX_BUF_EN_N: R658.2 U132.1(1OE_N) U132.7(2OE_N)
H_CPU_NODE1_ERR0: R89.1 U2.G64(GPIOCORE15)
H_CPU_NODE1_ERR0_R: R89.2 R111.1 U2.H48(ERR0)
H_CPU_NODE1_ERR1: R87.1 U2.H56(GPIOCORE16)
H_CPU_NODE1_ERR1_R: R87.2 R109.1 U2.D51(ERR1)
H_CPU_NODE1_ERR2: R85.1 U2.L54(GPIOCORE17)
H_CPU_NODE1_ERR2_R: R85.2 R105.1 U2.C51(ERR2)
H_CPU_NODE1_PROCHOT_L: Q42.E(2) R91.2 R115.1
H_CPU_NODE1_PROCHOT_R: R91.1 U2.AC56(CPU_PROCHOT#)
H_CPU_NODE1_THRM_LS_L: R140.1 U2.J37(THRM#)
H_CPU_NODE1_THRMTRIP_L: R93.1 R116.1 U2.AG59(THRMTRIP#)
H_CPU_NODE1_VR_HOT_L: PR54.1 PU8.20(VRHOT) U102.K9(DEV_CLR_N_IO_0)
I2C_ALERT_FNACTRL1_N: R760.1 U69.14(S\A\L\T\)
I2C_ALERT_FNACTRL2_N: R767.1 U70.14(S\A\L\T\)
I2C_COM3_SCL: R663.2 R683.1 R764.2 R773.2 U60.1(SCL0) U61.8(SCL) U62.22(SCL) U63.22(SCL) U64.22(SCL) U65.22(SCL) U66.22(SCL) U67.6(SCL)
I2C_COM3_SDA: R664.2 R681.1 R765.2 R774.2 R795.2 U60.2(SDA0) U62.23(SDA) U63.23(SDA) U64.23(SDA) U65.23(SDA) U66.23(SDA) U67.5(SDA)
I2C_COM3_SDA_RC: C590.2 R795.1 U61.7(SDA)
I2C_PDB_R_SCL: C610.1 J18.B10(3.3VAUX) R841.2
I2C_PDB_R_SDA: C613.1 J18.B11(WAKE_N) R844.2
I2C_PDB_SCL: R683.2 R841.1
I2C_PDB_SDA: R681.2 R844.1
I2C_PSU1_R_SCL: C589.1 J35.B42(HSOP6-) R820.2
I2C_PSU1_R_SDA: C587.1 J35.B43(GND49) R818.2
I2C_PSU1_SCL: R643.1 R820.1 U116.D(DRAIN)
I2C_PSU1_SCL_MOS: R643.2 R665.2 U60.3(SCL1) U116.S(SOURCE)
I2C_PSU1_SDA: R644.1 R818.1 U117.D(DRAIN)
I2C_PSU1_SDA_MOS: R644.2 R666.2 U60.4(SDA1) U117.S(SOURCE)
I2C_PSU2_R_SCL: C593.1 J35.B10(3.3VAUX) R824.2
I2C_PSU2_R_SDA: C591.1 J35.B11(WAKE_N) R822.2
I2C_PSU2_SCL: R646.1 R824.1 U126.D(DRAIN)
I2C_PSU2_SCL_MOS: R646.2 R667.2 U60.6(SCL2) U126.S(SOURCE)
I2C_PSU2_SDA: R645.1 R822.1 U118.D(DRAIN)
I2C_PSU2_SDA_MOS: R645.2 R668.2 U60.7(SDA2) U118.S(SOURCE)
I2C_PSU3_R_SCL: C597.1 J18.A32(RSVD6) R828.2
I2C_PSU3_R_SDA: C595.1 J18.A33(RSVD7) R826.2
I2C_PSU3_SCL: R648.1 R828.1 U139.D(DRAIN)
I2C_PSU3_SCL_MOS: R648.2 R669.2 U60.10(SCL3) U139.S(SOURCE)
I2C_PSU3_SDA: R647.1 R826.1 U127.D(DRAIN)
I2C_PSU3_SDA_MOS: R647.2 R671.2 U60.11(SDA3) U127.S(SOURCE)
I2C_SCL_FANCTRL1_R: R764.1 U69.1(SCL)
I2C_SCL_FANCTRL2_R: R773.1 U70.1(SCL)
I2C_SDA_FANCTRL1_R: R765.1 U69.16(SDA)
I2C_SDA_FANCTRL2_R: R774.1 U70.16(SDA)
I2C_SDC_SCL: R781.1 U73.8(SCL)
I2C_SDC_SDA: R780.1 U73.7(SDA)
I2C_VIDREAR_5V_SCL: D7.3 Q17.D(DRAIN) R635.2 R636.1
I2C_VIDREAR_5V_SDA: D8.3 Q18.D(DRAIN) R634.2 R639.1
IN3_85OHM: J25.2 J25.3
IRQ_CPU_NODE1_SERIAL: R66.1 R70.2 R95.1 R179.1
IRQ_CPU_NODE1_SERIAL_R: R66.2 U2.J46(LPC_SERIRQ)
IRQ_CPU_NODE1_SERIAL_SIO: R95.2 U43.39(SERIRQ)
IRQ_LVC3_CPU_NODE1_WAKE_L: R144.1 R255.1 R263.2 R513.2 R520.1 U2.T56(WAKE#) U35.16(P\E\_\W\A\K\E\) U37.16(P\E\_\W\A\K\E\) U102.K10(IO_72)
IRQ_LVC3_CPU_NODE1_WAKE_R_L: R255.2 U14.J22(PEWAKE#)
IRQ_LVC3_SATA_NODE1_WAKE_L: R513.1 U30.52(WAKE#)
ISENSE_PVCCP_NODE1_ISEN1N: PC98.2 PC101.2 PL8.1B PR56.2 PR59.2 PU8.4(ISEN1N)
ISENSE_PVCCP_NODE1_ISEN1P: PL8.2B PR55.2
JTAG_CPLD1_TCK: J20.1 R1033.2 R1287.2 U102.H3(TCK)
JTAG_CPLD1_TDI: J20.9 R1035.2 R1285.2 U102.H2(TDI)
JTAG_CPLD1_TDO: J20.3 R1286.2 U102.J2(TDO)
JTAG_CPLD1_TMS: J20.5 R1034.2 R1272.2 U102.J1(TMS)
JTAG_CPLD2_TCK: J26.1 R1074.2 R1119.2 U128.24(TCK)
JTAG_CPLD2_TDI: J26.9 R1076.2 R1081.2 U128.23(TDI)
JTAG_CPLD2_TDO: J26.3 R1080.2 U128.25(TDO)
JTAG_CPLD2_TMS: J26.5 R1075.2 R1079.2 U128.22(TMS)
JTAG_CPLD3_TCK: J27.1 R1200.2 R1212.2 U129.24(TCK)
JTAG_CPLD3_TDI: J27.9 R1198.2 R1214.2 U129.23(TDI)
JTAG_CPLD3_TDO: J27.3 R1199.2 U129.25(TDO)
JTAG_CPLD3_TMS: J27.5 R1197.2 R1213.2 U129.22(TMS)
LAN1_AUX_PWR: R541.2 U35.39(AUX_PWR/JTAG_TCK)
LAN1_CTRL_P1V9: Q15.1(BASE) R564.2 R565.1 U35.64(CTRL19)
LAN1_CTRL_P1V9_R: C429.1 R565.2
LAN1_DIS_REG10: R551.2 R552.2 U35.59(DIS_REG10)
LAN1_DISABLE_N: R596.2 U2.B55(GPIOCORE11) U35.28(D\E\V\_\O\F\F\)
LAN1_LED_ACT_N: C517.1 U35.30(LED1)
LAN1_LED_LINK_100_N: C518.1 U35.31(LED0)
LAN1_LED_LINK_1000_N: C519.1 U35.33(LED2)
LAN1_MDI0_DN: U35.57(MDI_MINUS[0]) U137.2(TRD1_N)
LAN1_MDI0_DP: U35.58(MDI_PLUS[0]) U137.1(TRD1_P)
LAN1_MDI1_DN: U35.54(MDI_MINUS[1]) U137.6(TRD2_N)
LAN1_MDI1_DP: U35.55(MDI_PLUS[1]) U137.5(TRD2_P)
LAN1_MDI2_DN: U35.52(MDI_MINUS[2]) U137.8(TRD3_N)
LAN1_MDI2_DP: U35.53(MDI_PLUS[2]) U137.7(TRD3_P)
LAN1_MDI3_DN: U35.49(MDI_MINUS[3]) U137.12(TRD4_N)
LAN1_MDI3_DP: U35.50(MDI_PLUS[3]) U137.11(TRD4_P)
LAN1_NC_SI_CLK_IN: R554.2 U35.2(NC_SI_CLK_IN)
LAN1_NC_SI_CRS_DV: R557.2 U35.3(NC_SI_CRS_DV)
LAN1_NC_SI_RXD0: R548.2 U35.6(NC_SI_RXD0)
LAN1_NC_SI_RXD1: R550.2 U35.5(NC_SI_RXD1)
LAN1_NC_SI_TDX0: R544.2 U35.9(NC_SI_TXD0)
LAN1_NC_SI_TDX1: R546.2 U35.8(NC_SI_TXD1)
LAN1_NC_SI_TX_EN: R556.2 U35.7(NC_SI_TX_EN)
LAN1_NVM_CS_N_R: R543.2 U36.1(C\S\)
LAN1_NVM_HOLD_N: R553.1 U36.7(H\O\L\D\)
LAN1_NVM_SI_R: R547.2 U36.5(SI)
LAN1_NVM_SK_R: R545.2 U36.6(SCK)
LAN1_NVM_SO_R: R549.2 U36.2(SO)
LAN1_NVM_WP_N: R555.1 U36.3(W\P\)
LAN1_P1_N: J35.A73(HSIP13-) U137.23(P1_N)
LAN1_P1_P: J35.A72(HSIP13+) U137.24(P1_P)
LAN1_P1_R: R1273.2 U137.22(P1)
LAN1_P2_N: J35.A76(HSIP14) U137.19(P2_N)
LAN1_P2_P: J35.A75(GND30) U137.20(P2_P)
LAN1_P2_R: R1274.2 U137.21(P2)
LAN1_P3_N: J35.B73(GND64) U137.17(P3_N)
LAN1_P3_P: J35.B72(GND63) U137.18(P3_P)
LAN1_P3_R: R1275.2 U137.16(P3)
LAN1_P4_N: J35.B76(GND65) U137.13(P4_N)
LAN1_P4_P: J35.B75(HSOP14-) U137.14(P4_P)
LAN1_P4_R: R1276.2 U137.15(P4)
LAN1_RST: R559.2 U35.48(RSET)
LAN1_TEST_EN: R558.2 U35.29(TEST_EN)
LAN1_XTAL_IN: C399.1 U35.43(XTAL1) Y4.1
LAN1_XTAL_OUT: C400.1 U35.42(XTAL2) Y4.2
LAN2_AUX_PWR: R571.2 U37.39(AUX_PWR/JTAG_TCK)
LAN2_CTRL_P1V9: Q16.1(BASE) R594.2 R595.1 U37.64(CTRL19)
LAN2_CTRL_P1V9_R: C468.1 R595.2
LAN2_DIS_REG10: R581.2 R582.2 U37.59(DIS_REG10)
LAN2_DISABLE_N: R597.2 U2.D57(GPIOCORE10) U37.28(D\E\V\_\O\F\F\)
LAN2_LED_ACT_N: C527.1 U37.30(LED1)
LAN2_LED_LINK_100_N: C528.1 U37.31(LED0)
LAN2_LED_LINK_1000_N: C529.1 U37.33(LED2)
LAN2_MDI0_DN: U37.57(MDI_MINUS[0]) U138.2(TRD1_N)
LAN2_MDI0_DP: U37.58(MDI_PLUS[0]) U138.1(TRD1_P)
LAN2_MDI1_DN: U37.54(MDI_MINUS[1]) U138.6(TRD2_N)
LAN2_MDI1_DP: U37.55(MDI_PLUS[1]) U138.5(TRD2_P)
LAN2_MDI2_DN: U37.52(MDI_MINUS[2]) U138.8(TRD3_N)
LAN2_MDI2_DP: U37.53(MDI_PLUS[2]) U138.7(TRD3_P)
LAN2_MDI3_DN: U37.49(MDI_MINUS[3]) U138.12(TRD4_N)
LAN2_MDI3_DP: U37.50(MDI_PLUS[3]) U138.11(TRD4_P)
LAN2_NC_SI_CLK_IN: R584.2 U37.2(NC_SI_CLK_IN)
LAN2_NC_SI_CRS_DV: R587.2 U37.3(NC_SI_CRS_DV)
LAN2_NC_SI_RXD0: R578.2 U37.6(NC_SI_RXD0)
LAN2_NC_SI_RXD1: R580.2 U37.5(NC_SI_RXD1)
LAN2_NC_SI_TDX0: R574.2 U37.9(NC_SI_TXD0)
LAN2_NC_SI_TDX1: R576.2 U37.8(NC_SI_TXD1)
LAN2_NC_SI_TX_EN: R586.2 U37.7(NC_SI_TX_EN)
LAN2_NVM_CS_N_R: R573.2 U38.1(C\S\)
LAN2_NVM_HOLD_N: R583.1 U38.7(H\O\L\D\)
LAN2_NVM_SI_R: R577.2 U38.5(SI)
LAN2_NVM_SK_R: R575.2 U38.6(SCK)
LAN2_NVM_SO_R: R579.2 U38.2(SO)
LAN2_NVM_WP_N: R585.1 U38.3(W\P\)
LAN2_P1_N: J18.B3(RSVD1) U138.23(P1_N)
LAN2_P1_P: J18.B2(12V_4) U138.24(P1_P)
LAN2_P1_R: R1277.2 U138.22(P1)
LAN2_P2_N: J18.B6(SMDATA) U138.19(P2_N)
LAN2_P2_P: J18.B5(SMCLK) U138.20(P2_P)
LAN2_P2_R: R1278.2 U138.21(P2)
LAN2_P3_N: J18.A4(GND1) U138.17(P3_N)
LAN2_P3_P: J18.A3(12V_2) U138.18(P3_P)
LAN2_P3_R: R1279.2 U138.16(P3)
LAN2_P4_N: J18.A7(JTAG4) U138.13(P4_N)
LAN2_P4_P: J18.A6(JTAG3) U138.14(P4_P)
LAN2_P4_R: R1280.2 U138.15(P4)
LAN2_RST: R589.2 U37.48(RSET)
LAN2_TEST_EN: R588.2 U37.29(TEST_EN)
LAN2_XTAL_IN: C437.1 U37.43(XTAL1) Y5.1
LAN2_XTAL_OUT: C438.1 U37.42(XTAL2) Y5.2
LED_CPU_NODE1_CPLD: D21.C U102.J10(IO_63)
LED_CPU_NODE1_CPLD_D: D21.A R1032.2
LED_PWR_GD: D19.3(G) R817.2
LED_PWR_NODE1_L: R817.1 R1031.2 U102.H10(IO_56)
LED_SATA_NODE1_GPIO0: D5.C U30.54(GPIO0)
LED_SATA_NODE1_R: D5.A R501.1
LPC_CLK_AST: R258.2 U14.B20(LCLK)
LPC_CPU_NODE1_CLK0_DS: R169.1 R170.1 U2.R63(LPCCLK0_DS)
LPC_CPU_NODE1_CLKOUT0: R73.2 R193.1
LPC_CPU_NODE1_CLKOUT1: R72.2 R625.1
LPC_CPU_NODE1_CLKRUN_L: R68.2 U2.C42(LPC_CLKRUN#)
LPC_CPU_NODE1_FRAME_L: R65.1 R181.1 R194.1 U115.20(B0)
LPC_CPU_NODE1_FRAME_L_R: R65.2 U2.D44(LPC_FRAME#)
LPC_CPU_NODE1_FRAME_SIO_L: R181.2 U43.40(LFRAME#)
LPC_CPU_NODE1_LAD0: R63.1 R182.1 R190.1 U115.42(CLK3/I)
LPC_CPU_NODE1_LAD0_R: R63.2 U2.G42(LPC_AD0)
LPC_CPU_NODE1_LAD0_SIO: R182.2 U43.41(LAD0)
LPC_CPU_NODE1_LAD1: R62.1 R183.1 R191.1 U115.19(CLK2/I)
LPC_CPU_NODE1_LAD1_R: R62.2 U2.G41(LPC_AD1)
LPC_CPU_NODE1_LAD1_SIO: R183.2 U43.42(LAD1)
LPC_CPU_NODE1_LAD2: R61.1 R184.1 R192.1 U115.4(A7)
LPC_CPU_NODE1_LAD2_R: R61.2 U2.H42(LPC_AD2)
LPC_CPU_NODE1_LAD2_SIO: R184.2 U43.43(LAD2)
LPC_CPU_NODE1_LAD3: R60.1 R185.1 R189.1 U115.3(A6)
LPC_CPU_NODE1_LAD3_R: R60.2 U2.H41(LPC_AD3)
LPC_CPU_NODE1_LAD3_SIO: R185.2 U43.44(LAD3)
LPC_CPU_NODE1_R_CLKOUT0: R73.1 U2.B44(LPC_CLKOUT0)
LPC_CPU_NODE1_R_CLKOUT1: R72.1 U2.C45(LPC_CLKOUT1)
LPC_CPU_TPM_LAD0: J1.5 R190.2
LPC_CPU_TPM_LAD1: J1.7 R191.2
LPC_CPU_TPM_LAD2: J1.9 R192.2
LPC_CPU_TPM_LAD3: J1.11 R189.2
M1_DQ_NODE1_DQ0: J2.5(DQ0) U2.BG13(DDR3_DQ0)
M1_DQ_NODE1_DQ1: J2.7(DQ1) U2.BF21(DDR3_DQ1)
M1_DQ_NODE1_DQ2: J2.13(DQ2) U2.BG15(DDR3_DQ2)
M1_DQ_NODE1_DQ3: J2.15(DQ3) U2.BH19(DDR3_DQ3)
M1_DQ_NODE1_DQ4: J2.4(DQ4) U2.BG19(DDR3_DQ4)
M1_DQ_NODE1_DQ5: J2.6(DQ5) U2.BG21(DDR3_DQ5)
M1_DQ_NODE1_DQ6: J2.16(DQ6) U2.BD13(DDR3_DQ6)
M1_DQ_NODE1_DQ7: J2.18(DQ7) U2.BF13(DDR3_DQ7)
M1_DQ_NODE1_DQ8: J2.19(DQ8) U2.BM13(DDR3_DQ8)
M1_DQ_NODE1_DQ9: J2.21(DQ9) U2.BL19(DDR3_DQ9)
M1_DQ_NODE1_DQ10: J2.31(DQ10) U2.BN14(DDR3_DQ10)
M1_DQ_NODE1_DQ11: J2.33(DQ11) U2.BM18(DDR3_DQ11)
M1_DQ_NODE1_DQ12: J2.22(DQ12) U2.BP13(DDR3_DQ12)
M1_DQ_NODE1_DQ13: J2.24(DQ13) U2.BN19(DDR3_DQ13)
M1_DQ_NODE1_DQ14: J2.34(DQ14) U2.BL14(DDR3_DQ14)
M1_DQ_NODE1_DQ15: J2.36(DQ15) U2.BL17(DDR3_DQ15)
M1_DQ_NODE1_DQ16: J2.37(DQ16) U2.BH25(DDR3_DQ16)
M1_DQ_NODE1_DQ17: J2.39(DQ17) U2.BA25(DDR3_DQ17)
M1_DQ_NODE1_DQ18: J2.49(DQ18) U2.BG25(DDR3_DQ18)
M1_DQ_NODE1_DQ19: J2.51(DQ19) U2.BB26(DDR3_DQ19)
M1_DQ_NODE1_DQ20: J2.40(DQ20) U2.BH26(DDR3_DQ20)
M1_DQ_NODE1_DQ21: J2.42(DQ21) U2.BB25(DDR3_DQ21)
M1_DQ_NODE1_DQ22: J2.48(DQ22) U2.BA29(DDR3_DQ22)
M1_DQ_NODE1_DQ23: J2.50(DQ23) U2.BG29(DDR3_DQ23)
M1_DQ_NODE1_DQ24: J2.55(DQ24) U2.BM22(DDR3_DQ24)
M1_DQ_NODE1_DQ25: J2.57(DQ25) U2.BN28(DDR3_DQ25)
M1_DQ_NODE1_DQ26: J2.63(DQ26) U2.BN23(DDR3_DQ26)
M1_DQ_NODE1_DQ27: J2.65(DQ27) U2.BM27(DDR3_DQ27)
M1_DQ_NODE1_DQ28: J2.54(DQ28) U2.BP22(DDR3_DQ28)
M1_DQ_NODE1_DQ29: J2.56(DQ29) U2.BL28(DDR3_DQ29)
M1_DQ_NODE1_DQ30: J2.66(DQ30) U2.BL23(DDR3_DQ30)
M1_DQ_NODE1_DQ31: J2.68(DQ31) U2.BL26(DDR3_DQ31)
M1_DQ_NODE1_DQ32: J2.133(DQ32) U2.BM52(DDR3_DQ32)
M1_DQ_NODE1_DQ33: J2.135(DQ33) U2.BM58(DDR3_DQ33)
M1_DQ_NODE1_DQ34: J2.145(DQ34) U2.BN53(DDR3_DQ34)
M1_DQ_NODE1_DQ35: J2.147(DQ35) U2.BN57(DDR3_DQ35)
M1_DQ_NODE1_DQ36: J2.134(DQ36) U2.BL57(DDR3_DQ36)
M1_DQ_NODE1_DQ37: J2.136(DQ37) U2.BL59(DDR3_DQ37)
M1_DQ_NODE1_DQ38: J2.142(DQ38) U2.BL53(DDR3_DQ38)
M1_DQ_NODE1_DQ39: J2.144(DQ39) U2.BM54(DDR3_DQ39)
M1_DQ_NODE1_DQ40: J2.151(DQ40) U2.BH58(DDR3_DQ40)
M1_DQ_NODE1_DQ41: J2.153(DQ41) U2.BB59(DDR3_DQ41)
M1_DQ_NODE1_DQ42: J2.159(DQ42) U2.BG58(DDR3_DQ42)
M1_DQ_NODE1_DQ43: J2.161(DQ43) U2.BD60(DDR3_DQ43)
M1_DQ_NODE1_DQ44: J2.148(DQ44) U2.BB57(DDR3_DQ44)
M1_DQ_NODE1_DQ45: J2.150(DQ45) U2.BB60(DDR3_DQ45)
M1_DQ_NODE1_DQ46: J2.160(DQ46) U2.BH57(DDR3_DQ46)
M1_DQ_NODE1_DQ47: J2.162(DQ47) U2.BE57(DDR3_DQ47)
M1_DQ_NODE1_DQ48: J2.165(DQ48) U2.BD65(DDR3_DQ48)
M1_DQ_NODE1_DQ49: J2.167(DQ49) U2.AY65(DDR3_DQ49)
M1_DQ_NODE1_DQ50: J2.177(DQ50) U2.BE64(DDR3_DQ50)
M1_DQ_NODE1_DQ51: J2.179(DQ51) U2.AW62(DDR3_DQ51)
M1_DQ_NODE1_DQ52: J2.166(DQ52) U2.AY63(DDR3_DQ52)
M1_DQ_NODE1_DQ53: J2.168(DQ53) U2.AW64(DDR3_DQ53)
M1_DQ_NODE1_DQ54: J2.174(DQ54) U2.BD63(DDR3_DQ54)
M1_DQ_NODE1_DQ55: J2.176(DQ55) U2.BC64(DDR3_DQ55)
M1_DQ_NODE1_DQ56: J2.183(DQ56) U2.AT63(DDR3_DQ56)
M1_DQ_NODE1_DQ57: J2.185(DQ57) U2.AT64(DDR3_DQ57)
M1_DQ_NODE1_DQ58: J2.191(DQ58) U2.AR65(DDR3_DQ58)
M1_DQ_NODE1_DQ59: J2.193(DQ59) U2.AN65(DDR3_DQ59)
M1_DQ_NODE1_DQ60: J2.180(DQ60) U2.AL63(DDR3_DQ60)
M1_DQ_NODE1_DQ61: J2.182(DQ61) U2.AR63(DDR3_DQ61)
M1_DQ_NODE1_DQ62: J2.192(DQ62) U2.AL62(DDR3_DQ62)
M1_DQ_NODE1_DQ63: J2.194(DQ63) U2.AL65(DDR3_DQ63)
M_DDR3_NODE1_BS0: J2.119(BA0) U2.BL43(DDR3_BS0)
M_DDR3_NODE1_BS1: J2.108(BA1) U2.BL41(DDR3_BS1)
M_DDR3_NODE1_BS2: J2.91(BA2) U2.BN32(DDR3_BS2)
M_DDR3_NODE1_CAS_L: J2.125(CAS#) U2.BN46(DDR3_CAS#)
M_DDR3_NODE1_CK0N: J2.113(CK0#) U2.BD42(DDR3_CK#0)
M_DDR3_NODE1_CK0P: J2.111(CK0) U2.BD41(DDR3_CK0)
M_DDR3_NODE1_CK1N: J2.114(CK1#) U2.BG42(DDR3_CK#1)
M_DDR3_NODE1_CK1P: J2.112(CK1) U2.BG41(DDR3_CK1)
M_DDR3_NODE1_CKE0: J2.87(CKE0) U2.BL46(DDR3_CKE0)
M_DDR3_NODE1_CKE1: J2.89(CKE1) U2.BK45(DDR3_CKE1)
M_DDR3_NODE1_CMDPU: R28.2 U2.BH34(DDR3_CMDPU)
M_DDR3_NODE1_CS0_L: J2.127(S0#) U2.BN44(DDR3_CS#0)
M_DDR3_NODE1_CS1_L: J2.129(S1#) U2.BP46(DDR3_CS#1)
M_DDR3_NODE1_DQPU: R29.1 U2.BG34(DDR3_DQPU)
M_DDR3_NODE1_DQS0N: J2.10(DQS0#) U2.BH17(DDR3_DQS#0)
M_DDR3_NODE1_DQS0P: J2.12(DQS0) U2.BG17(DDR3_DQS0)
M_DDR3_NODE1_DQS1N: J2.25(DQS1#) U2.BM16(DDR3_DQS#1)
M_DDR3_NODE1_DQS1P: J2.27(DQS1) U2.BN17(DDR3_DQS1)
M_DDR3_NODE1_DQS2N: J2.43(DQS2#) U2.BD26(DDR3_DQS#2)
M_DDR3_NODE1_DQS2P: J2.45(DQS2) U2.BE26(DDR3_DQS2)
M_DDR3_NODE1_DQS3N: J2.60(DQS3#) U2.BM25(DDR3_DQS#3)
M_DDR3_NODE1_DQS3P: J2.62(DQS3) U2.BN26(DDR3_DQS3)
M_DDR3_NODE1_DQS4N: J2.139(DQS4#) U2.BN55(DDR3_DQS#4)
M_DDR3_NODE1_DQS4P: J2.141(DQS4) U2.BL55(DDR3_DQS4)
M_DDR3_NODE1_DQS5N: J2.154(DQS5#) U2.BF62(DDR3_DQS#5)
M_DDR3_NODE1_DQS5P: J2.156(DQS5) U2.BH62(DDR3_DQS5)
M_DDR3_NODE1_DQS6N: J2.171(DQS6#) U2.BB65(DDR3_DQS#6)
M_DDR3_NODE1_DQS6P: J2.173(DQS6) U2.BB63(DDR3_DQS6)
M_DDR3_NODE1_DQS7N: J2.186(DQS7#) U2.AP64(DDR3_DQS#7)
M_DDR3_NODE1_DQS7P: J2.188(DQS7) U2.AN63(DDR3_DQS7)
M_DDR3_NODE1_DQSECCN: J2.75(DQS8#) U2.BG49(DDR3_DQSECC#)
M_DDR3_NODE1_DQSECCP: J2.77(DQS8) U2.BE49(DDR3_DQSECC)
M_DDR3_NODE1_ECC0: J2.69(CB0) U2.BG50(DDR3_ECC0)
M_DDR3_NODE1_ECC1: J2.71(CB1) U2.BB49(DDR3_ECC1)
M_DDR3_NODE1_ECC2: J2.81(CB2) U2.BK51(DDR3_ECC2)
M_DDR3_NODE1_ECC3: J2.83(CB3) U2.BD50(DDR3_ECC3)
M_DDR3_NODE1_ECC4: J2.72(CB4) U2.BD49(DDR3_ECC4)
M_DDR3_NODE1_ECC5: J2.74(CB5) U2.BA50(DDR3_ECC5)
M_DDR3_NODE1_ECC6: J2.80(CB6) U2.BH49(DDR3_ECC6)
M_DDR3_NODE1_ECC7: J2.82(CB7) U2.BK49(DDR3_ECC7)
M_DDR3_NODE1_MA0: J2.107(A0) U2.BK40(DDR3_MA0)
M_DDR3_NODE1_MA1: J2.105(A1) U2.BL39(DDR3_MA1)
M_DDR3_NODE1_MA2: J2.106(A2) U2.BP40(DDR3_MA2)
M_DDR3_NODE1_MA3: J2.103(A3) U2.BL37(DDR3_MA3)
M_DDR3_NODE1_MA4: J2.104(A4) U2.BN39(DDR3_MA4)
M_DDR3_NODE1_MA5: J2.99(A5) U2.BN37(DDR3_MA5)
M_DDR3_NODE1_MA6: J2.100(A6) U2.BP37(DDR3_MA6)
M_DDR3_NODE1_MA7: J2.98(A7) U2.BL35(DDR3_MA7)
M_DDR3_NODE1_MA8: J2.97(A8) U2.BN35(DDR3_MA8)
M_DDR3_NODE1_MA9: J2.92(A9) U2.BM34(DDR3_MA9)
M_DDR3_NODE1_MA10: J2.117(A10) U2.BN41(DDR3_MA10)
M_DDR3_NODE1_MA11: J2.96(A11) U2.BL34(DDR3_MA11)
M_DDR3_NODE1_MA12: J2.95(A12) U2.BL32(DDR3_MA12)
M_DDR3_NODE1_MA13: J2.130(A13) U2.BN48(DDR3_MA13)
M_DDR3_NODE1_MA14: J2.90(A14) U2.BM31(DDR3_MA14)
M_DDR3_NODE1_MA15: J2.88(A15) U2.BP31(DDR3_MA15)
M_DDR3_NODE1_MON1N: R32.2 R33.2 U2.BG38(DDR3_MON1N)
M_DDR3_NODE1_MON1P: R32.1 R33.1 U2.BG37(DDR3_MON1P)
M_DDR3_NODE1_MON2N: R34.2 R35.2 U2.BF38(DDR3_MON2N)
M_DDR3_NODE1_MON2P: R34.1 R35.1 U2.BF37(DDR3_MON2P)
M_DDR3_NODE1_ODT0: J2.126(ODT0) U2.BL48(DDR3_ODT0)
M_DDR3_NODE1_ODT1: J2.128(ODT1) U2.BP49(DDR3_ODT1)
M_DDR3_NODE1_ODTPU: R30.1 U2.BH32(DDR3_ODTPU)
M_DDR3_NODE1_RAS_L: J2.122(RAS#) U2.BP43(DDR3_RAS#)
M_DDR3_NODE1_WE_L: J2.121(WE#) U2.BL44(DDR3_WE#)
M_NODE1_DIMM_RST_L: J2.30(RESET#) U2.BC38(DDR3_DRAMRST#)
MATE_N: C604.1 J36.2 R835.2 R1007.2 U93.G(GATE)
MATE_R_N: J35.B81(PRSNT2_N-4) R835.1
NODE1_BIOS_MB_REV_ID0: R86.2 R88.2 U2.N48(GPIOCORE20)
NODE1_BIOS_MB_REV_ID1: R90.2 R92.2 U2.L52(GPIOCORE19)
NODE1_BIOS_MB_REV_ID2: R94.2 R96.2 U2.H59(GPIOCORE18)
NODE1_USB_TESTMODE: R503.2 U30.20(TESTMODE)
OSC1_48MHZ: OSC4.3(OUT) R618.1
P2E_CPU_BMC_NODE1_RX_C_DN: C203.2 U14.E21(PETXN)
P2E_CPU_BMC_NODE1_RX_C_DP: C202.2 U14.E22(PETXP)
P2E_CPU_BMC_NODE1_RX_DN: C203.1 U125.88(RXN01)
P2E_CPU_BMC_NODE1_RX_DP: C202.1 U125.87(RXP01)
P2E_CPU_BMC_NODE1_TX_C_DN: C188.1 U125.83(TXN01)
P2E_CPU_BMC_NODE1_TX_C_DP: C187.1 U125.84(TXP01)
P2E_CPU_BMC_NODE1_TX_DN: C188.2 U14.F22(PERXN)
P2E_CPU_BMC_NODE1_TX_DP: C187.2 U14.F21(PERXP)
P2E_CPU_NIC1_NODE1_RX_DN: C392.1 U2.BJ4(RP0_PERN2)
P2E_CPU_NIC1_NODE1_RX_DP: C391.1 U2.BH3(RP0_PERP2)
P2E_CPU_NIC1_NODE1_TX_C_DN: C20.1 U2.BK9(RP0_PETN2)
P2E_CPU_NIC1_NODE1_TX_C_DP: C19.1 U2.BH8(RP0_PETP2)
P2E_CPU_NIC1_NODE1_TX_DN: C20.2 U35.23(PE_RN)
P2E_CPU_NIC1_NODE1_TX_DP: C19.2 U35.24(PE_RP)
P2E_CPU_NIC2_NODE1_RX_DN: C436.1 U2.BD4(RP0_PERN4)
P2E_CPU_NIC2_NODE1_RX_DP: C435.1 U2.BD2(RP0_PERP4)
P2E_CPU_NIC2_NODE1_TX_C_DN: C18.1 U2.BD8(RP0_PETN4)
P2E_CPU_NIC2_NODE1_TX_C_DP: C17.1 U2.BD10(RP0_PETP4)
P2E_CPU_NIC2_NODE1_TX_DN: C18.2 U37.23(PE_RN)
P2E_CPU_NIC2_NODE1_TX_DP: C17.2 U37.24(PE_RP)
P2E_CPU_PCIE_SW_NODE1_RX_C_DN: C186.1 U125.74(TXN00)
P2E_CPU_PCIE_SW_NODE1_RX_C_DP: C185.1 U125.73(TXP00)
P2E_CPU_PCIE_SW_NODE1_RX_DN: C186.2 U2.AY5(RP0_PERN6)
P2E_CPU_PCIE_SW_NODE1_RX_DP: C185.2 U2.BB5(RP0_PERP6)
P2E_CPU_PCIE_SW_NODE1_TX_C_DN: C16.1 U2.AY9(RP0_PETN6)
P2E_CPU_PCIE_SW_NODE1_TX_C_DP: C15.1 U2.AY11(RP0_PETP6)
P2E_CPU_PCIE_SW_NODE1_TX_DN: C16.2 U125.69(RXN00)
P2E_CPU_PCIE_SW_NODE1_TX_DP: C15.2 U125.70(RXP00)
P2E_CPU_SATA_NODE1_RX_C_DN: C332.2 U30.39(PTXN)
P2E_CPU_SATA_NODE1_RX_C_DP: C333.2 U30.40(PTXP)
P2E_CPU_SATA_NODE1_RX_DN: C332.1 U2.BM9(RP0_PERN0)
P2E_CPU_SATA_NODE1_RX_DP: C333.1 U2.BN10(RP0_PERP0)
P2E_CPU_SATA_NODE1_TX_C_DN: C22.1 U2.BB19(RP0_PETN0)
P2E_CPU_SATA_NODE1_TX_C_DP: C21.1 U2.BD19(RP0_PETP0)
P2E_CPU_SATA_NODE1_TX_DN: C22.2 U30.43(PRXN)
P2E_CPU_SATA_NODE1_TX_DP: C21.2 U30.44(PRXP)
P2E_CPU_USB_NODE1_RX_C_DN: C364.2 U32.8(PETXN)
P2E_CPU_USB_NODE1_RX_C_DP: C363.2 U32.7(PETXP)
P2E_CPU_USB_NODE1_RX_DN: C364.1 U125.103(RXN02)
P2E_CPU_USB_NODE1_RX_DP: C363.1 U125.104(RXP02)
P2E_CPU_USB_NODE1_TX_C_DN: C190.1 U125.108(TXN02)
P2E_CPU_USB_NODE1_TX_C_DP: C189.1 U125.107(TXP02)
P2E_CPU_USB_NODE1_TX_DN: C190.2 U32.11(PERXN)
P2E_CPU_USB_NODE1_TX_DP: C189.2 U32.10(PERXP)
PCA9535_INT_N: R677.2 U61.6(GPIO3) U63.1(I\N\T\)
PCA_CPLD_WDT2: R755.2 R1196.1 U65.14(P1_1)
PCH_I2C_ALERT_N: R561.1 R591.1
PCI_STP_NODE1: R5.2 U1.35(PCI_STOP#_3.3)
PCIE_LAN1_RX_C_DN: C392.2 U35.20(PE_TN)
PCIE_LAN1_RX_C_DP: C391.2 U35.21(PE_TP)
PCIE_LAN2_RX_C_DN: C436.2 U37.20(PE_TN)
PCIE_LAN2_RX_C_DP: C435.2 U37.21(PE_TP)
PCIE_SW_EEPROM_CLK: R301.1 U13.6(SCL) U125.40(EECLK)
PCIE_SW_EEPROM_DAT: R303.1 U13.5(SDA) U125.41(EEPD)
PCIE_SW_GPIO5: R308.2 U125.26(GPIO5)
PCIE_SW_GPIO6: R306.2 U125.27(GPIO6)
PCIE_SW_GPIO7: R307.2 U125.28(GPIO7)
PCIE_SW_I2C_SCL: R232.2 R309.1 U125.13(SCL_I)
PCIE_SW_I2C_SDA: R233.2 R310.1 U125.16(SDA_I)
