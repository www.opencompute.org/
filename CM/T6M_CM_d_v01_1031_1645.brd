# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Library data of the parts (continued)
C258 C262 C268 C270-C272 C517-C519 C527-C529 C557 C558 C560 C561 = CAP_NP: signal model: DEFAULT_CAPACITOR_470pF_2_1
C289-C291 C333 C385 C386 C535 C912-C919 = CAP_NP: signal model: DEFAULT_CAPACITOR_220pF_2_1
C329-C331 C505-C508 C588 C600 C602 C604 C605 C607 C608 C611 C614 C622-C765 C794 = CAP_NP: signal model: DEFAULT_CAPACITOR_100pF_2_1
C350 C362 C540 C541 PC62 PC70 = CAP_NP: signal model: DEFAULT_CAPACITOR_1000pF_2_1
C497 C498 = CAP_NP: signal model: DEFAULT_CAPACITOR_100000pF_2_1; room: VIDEO
C499-C504 = CAP_NP: signal model: DEFAULT_CAPACITOR_3.3pF_2_1; room: VIDEO
C779 = CAP_NP: signal model: DEFAULT_CAPACITOR_2200pF_2_1
C780 C841 = CAP_NP: signal model: DEFAULT_CAPACITOR_47000pF_2_1
C814 C822 C832 = CAP_NP: room: VR_P1V05_PCH; signal model: DEFAULT_CAPACITOR_4.7e+07pF_2_1
C815 C823 C833 C851 = CAP_NP: signal model: DEFAULT_CAPACITOR_1200pF_2_1
C825 = CAP_NP: signal model: DEFAULT_CAPACITOR_470000pF_2_1
CD1 = DIODE: room: VIDEO
CE2 CE3 PC63 PC64 PC79 PC80 = CAPACITOR_POL: signal model: DEFAULT_CAPACITOR_3.3e+08pF_2_1
D5 D15-D17 D21-D25 D31-D38 = LED_0
D6 = DIODE
D7 D8 = DIODE_4: signal model: DIODE_4_SOT23_123XB_IC__BAT54LT_BAT54LT1G
D9 D10 = PTZ15B: signal model: DIODE_4_SOT23_123XB
D18 D19 = WP59SURKSGC
D20 = BZX84C137F
D28 D29 = SCHOTTKY_0
FS2 = FUSE: room: VIDEO
FS3 FS4 = FUSE
H1-H4 H6-H9 = HOLE_N
H5 = GND_HOLE
H10 = HOLE
J1 = HEADER_2X7_2
J2 = SCONN204_AS0A621HASN7H
J3 = 2R30P_FS_DIP
J4 J25 J29 J30 = PICOPROBE_B
J5 J6 = HEADER1X4_1
J7 = SATA-7P-RA
J8 = CONN2_ASP13867601
J9 = CONN15_070922FR015S223CU
J14 J15 = USB
J18 J35 = PCI_EXPRESS_X16_CONN_1
J19 = CON_ATXP_4
J20 J26 J27 = HEADER2X5S
J21-J24 J28 PJ1-PJ12 PJ14-PJ19 = JUMPER-2_1
J32 J34 J36 = DIP_2PIN
L1-L3 L8 L17 L20 L30-L34 L36 L37 L53 = L
L4-L7 L9 L10 = L: signal model: DEFAULT_INDUCTOR_10000nH_2_1
L13-L16 = L: signal model: PLW_3216_L_PLW3216S_DISCRETE_DL_DLW31SN900SQ2L
L18 L19 = L: signal model: L_L0603_DISCRETE
L38 = L: room: VIDEO
L39-L41 = L: signal model: L_L0603_DISCRETE_BLM18BB750SN1D_BLM18BB750SN1D; room: VIDEO
L42-L45 = PLW_3216: signal model: PLW_3216_L_PLW3216S_DISCRETE_DL_DLW31SN900SQ2L
OSC3 = OSC-4_4
OSC4 = OSC-4
OSC5 OSC6 = OSC_20MHZ
PC8 = CAP_NP: room: VR_0P9; signal model: DEFAULT_CAPACITOR_1e+07pF_2_1
PC9 = CAP_NP: signal model: DEFAULT_CAPACITOR_3300pF_2_1
PC13 PC42 PC113 = CAP_NP: signal model: DEFAULT_CAPACITOR_22pF_2_1
PC19 = CAP_NP: room: VR_0P9; signal model: DEFAULT_CAPACITOR_100000pF_2_1
PC40 PC51 = CAP_NP: room: VR_0P9; signal model: DEFAULT_CAPACITOR_2.2e+07pF_2_1
PC43 PC48 = CAP_NP: signal model: DEFAULT_CAPACITOR_3.3e+08pF_2_1
PC65 = CAP_NP: signal model: DEFAULT_CAPACITOR_100000pF_2_1; room: VR_0P9
PC71 = CAP_NP: signal model: DEFAULT_CAPACITOR_1500pF_2_1
PC90 PC97 = CAP_NP: signal model: DEFAULT_CAPACITOR_3.9e+08pF_2_1
PC99 = CAPACITOR_POL: signal model: DEFAULT_CAPACITOR_1e+07pF_2_1
PC100 = CAPACITOR_POL: signal model: DEFAULT_CAPACITOR_220000pF_2_1
PC108 = CAP_NP: signal model: DEFAULT_CAPACITOR_68pF_2_1
PL2 PL7 = L: signal model: DEFAULT_INDUCTOR_2200nH_2_1
PL4 PL17 = L: signal model: DEFAULT_INDUCTOR_3300nH_2_1
PL6 = L: signal model: DEFAULT_INDUCTOR_1500nH_2_1
PL8 = MPL135_2
PL12 = L: signal model: DEFAULT_INDUCTOR_4700nH_2_1
PQ1 PQ2 = FDML7610AS
PR1 PR41 = R: signal model: DEFAULT_RESISTOR_2.2OHM_2_1
PR2 = R: signal model: DEFAULT_RESISTOR_19600OHM_2_1
PR3 = R: signal model: DEFAULT_RESISTOR_121000OHM_2_1
PR4 PR16 PR65 R1012 = R: signal model: DEFAULT_RESISTOR_22100OHM_2_1
PR5 PR8-PR10 PR13 PR17 PR18 PR27 PR33 PR36 PR40 PR44 PR49 PR51-PR53 PR59 PR69 PR74 PR77 R90 R96-R103 R107-R109 R112 R127 R138 R153 R165 R177 R196-R199 R202-R204 R215 R218 R228 R229 R231 R234 R304 R312 R503 R505 R525 R527-R529 R533 R534 R544 R546 R548 R550 R553-R557 R574 R576 R578 R580 R583-R587 R614-R617 R620 R626 R650 R652 R654 R655 R657 R663-R669 R671 R672 R674 R677 R680 R689-R691 R698-R700 R703 R705 R707 R709-R717 R720-R733 R736 R740-R742 R744-R749 R762 R763 R769 R771 R772 R777 R778 R799 R800 R802 R814 R816 R1003-R1011 R1013 R1015-R1018 R1020 R1024 R1034-R1036 R1039 R1051 R1056 R1057 R1059-R1061 R1064 R1065 R1068 R1075-R1078 R1083 R1090 R1099 R1103 R1107 R1111 R1115 R1121 R1124 R1125 R1132-R1150 R1193-R1195 R1201-R1204 R1213 R1214 R1217 R1243-R1245 R1263 R1264 R1322 R1323 R1325 = R: signal model: DEFAULT_RESISTOR_10000OHM_2_1
PR6 PR22 PR24 PR25 PR32 PR46 PR48 PR67 R3 R8 R13 R14 R42 R44 R50 R57 R62-R70 R72 R73 R75-R80 R92 R106 R110 R141 R142 R144 R170 R207-R211 R213 R214 R219 R220 R263-R274 R290 R292 R313 R314 R471 R472 R513 R520 R521 R543 R547 R549 R560-R563 R565 R573 R577 R579 R590-R593 R595 R621-R623 R627 R629 R630 R643-R648 R660-R662 R676 R678 R679 R681 R683 R684 R764 R765 R773-R775 R804 R1019 R1025 R1030 R1037 R1066 R1067 R1079-R1081 R1119 R1120 R1129 R1130 R1197-R1200 R1246 R1247 R1249 R1324 R1327 = R: signal model: DEFAULT_RESISTOR_0.001OHM_2_1
PR7 = R: signal model: DEFAULT_RESISTOR_73200OHM_2_1
PR14 PR19 = R: signal model: DEFAULT_RESISTOR_20500OHM_2_1
PR15 = R: signal model: DEFAULT_RESISTOR_30100OHM_2_1
PR20 = R: signal model: DEFAULT_RESISTOR_15000OHM_2_1
PR21 PR28 PR30 PR34 PR35 PR45 PR50 PR71 R18-R20 R24-R26 R28 R32-R35 R48 R300 R302 R311 R323 R326 R331 R332 R337 R338 R682 R687 R688 R718 R719 R750-R754 R756-R758 R761 R768 R770 R783 R792 R808 R813 R817 R832 R834 R837 R840 R843 R847 R1027 R1038 R1069-R1073 R1151-R1154 R1226-R1229 = R: signal model: DEFAULT_RESISTOR_100OHM_2_1
PR23 PR31 PR57 PR60 R1 R2 R15-R17 R21-R23 R27 R29-R31 R52 R53 R94 R105 R180 R186 R187 R221 R223-R227 R259 R298 R315-R322 R324 R325 R327-R330 R333-R336 R339-R346 R502 R509-R512 R514-R518 R536 R538-R542 R566 R567 R569-R572 R631-R635 R653 R673 R685 R686 R701 R702 R704 R706 R708 R734 R735 R737-R739 R743 R755 R759 R760 R766 R767 R779-R782 R784-R787 R790 R791 R793 R812 R1023 R1031 R1053 R1062 R1084 R1087 R1094 R1096 R1123 R1126 R1196 R1211 R1218-R1225 R1248 R1261 R1282-R1284 R1298 R1299 R1301 R1302 R1304 R1305 R1307-R1309 = R: signal model: DEFAULT_RESISTOR_4700OHM_2_1
PR26 PR54 PR79 R43 R81-R84 R111 R139 R145 R146 R166 R222 R232 R233 R261 R262 R497 R532 R537 R551 R552 R568 R581 R582 R596 R597 R619 R624 R649 R651 R656 R1033 R1040-R1047 R1049 R1050 R1074 R1093 R1098 R1102 R1106 R1110 R1114 R1118 R1122 R1131 R1155 R1157 R1159 R1161 R1163 R1164 R1167 R1169 R1170 R1173 R1175 R1176 R1179 R1181 R1183 R1185 R1187 R1189 R1190 R1205 R1207 R1208 R1212 R1215 R1216 R1230-R1242 R1297 R1300 R1303 R1306 = R: signal model: DEFAULT_RESISTOR_1000OHM_2_1
PR29 R140 R143 R1021 = R: signal model: DEFAULT_RESISTOR_10OHM_2_1
PR37 PR78 = R: signal model: DEFAULT_RESISTOR_53600OHM_2_1
PR38 = R: signal model: DEFAULT_RESISTOR_1100OHM_2_1
PR42 PR62 R167 R794 R801 R803 R806 R807 R809-R811 R845 R848-R858 R1029 = R: signal model: DEFAULT_RESISTOR_100000OHM_2_1
PR43 = R: signal model: DEFAULT_RESISTOR_4.7OHM_2_1
PR55 = R: signal model: DEFAULT_RESISTOR_1650OHM_2_1
PR56 PR75 = THERMISTOR
PR58 = R: signal model: DEFAULT_RESISTOR_1210OHM_2_1
PR61 R37-R40 R169 = R: signal model: DEFAULT_RESISTOR_20000OHM_2_1
PR63 = R: signal model: DEFAULT_RESISTOR_28000OHM_2_1
PR64 = R: signal model: DEFAULT_RESISTOR_48700OHM_2_1
PR66 PR70 = R: signal model: DEFAULT_RESISTOR_200000OHM_2_1
PR68 = R: signal model: DEFAULT_RESISTOR_274000OHM_2_1
PR72 = R: signal model: DEFAULT_RESISTOR_3240OHM_2_1
PR73 = R: signal model: DEFAULT_RESISTOR_316OHM_2_1
PR76 = R: signal model: DEFAULT_RESISTOR_5230OHM_2_1
PR103 = R: signal model: DEFAULT_RESISTOR_15800OHM_2_1
PU1 PU2 PU4 PU5 = TPS54326RGTR
PU6 = TPS51219RTER
PU7 = TPS51518RUKR
PU8 = RT8167BGQW
Q12 Q44-Q46 = 2N2907
Q15 Q16 = PNP_SOT223
Q17 Q18 U116-U118 U126 U127 U139 = FDV301N_0
Q22 = MOSFET_NCH_1D3S
Q24-Q28 Q41 Q42 = NPN_0: signal model: NPN_0_SOT23_BECXA_IC__PMBT390_PMBT390
Q29 Q31 Q35 Q37 Q39 = SI7886DP
Q30 Q32 Q36 Q38 Q40 = 2N7002A7
Q43 = BSS123
R4-R7 R9 R11 R12 R71 R291 R506-R508 R519 R522-R524 R530 R818-R831 R833 R835 R836 R838 R839 R841 R842 R844 R846 R859-R906 R908-R1002 R1271 R1281 = R: signal model: DEFAULT_RESISTOR_33OHM_2_1
R10 R135 = R: signal model: R_R0402_DISCRETE_33_33
R36 = R: signal model: DEFAULT_RESISTOR_681OHM_2_1
R41 = R: signal model: DEFAULT_RESISTOR_7500OHM_2_1
R45 R46 = R: signal model: DEFAULT_RESISTOR_2200OHM_2_1
R47 R49 R56 R58 R91 = R: signal model: DEFAULT_RESISTOR_49.9OHM_2_1
R51 R54 R55 R74 = R: signal model: DEFAULT_RESISTOR_51OHM_2_1
R59 R618 R815 = R: signal model: R_R0402_DISCRETE_0_0
R60 = R: signal model: DEFAULT_RESISTOR_110OHM_2_1
R61 = R: signal model: DEFAULT_RESISTOR
R85 R87 R89 = R: signal model: DEFAULT_RESISTOR_499OHM_2_1
R86 = R: signal model: DEFAULT_RESISTOR_12100OHM_2_1
R88 = R: signal model: DEFAULT_RESISTOR_274OHM_2_1
R93 R95 R181-R185 R188 R293 R625 R692-R697 = R: signal model: R_R0402_DISCRETE
R104 = R: signal model: DEFAULT_RESISTOR_22.6OHM_2_1
R113 R114 = R: signal model: DEFAULT_RESISTOR_60.4OHM_2_1
R115 = R: signal model: DEFAULT_RESISTOR_24.9OHM_2_1
R116 R796-R798 R805 R1048 R1058 = R: signal model: DEFAULT_RESISTOR_510OHM_2_1
R117-R126 R128-R134 R136 R147-R152 R154-R164 R171-R175 R178 R179 R1014 = R: signal model: DEFAULT_RESISTOR_8200OHM_2_1
R137 = R: signal model: DEFAULT_RESISTOR_432OHM_2_1
R168 = R: signal model: DEFAULT_RESISTOR_330000OHM_2_1
R176 = R: signal model: DEFAULT_RESISTOR_47OHM_2_1
R189-R195 R628 R776 R1251 R1262 R1265-R1270 R1272 R1285-R1296 R1310-R1321 R1329-R1334 = R
R200 = R: signal model: DEFAULT_RESISTOR_8060OHM_2_1
R205 R558 R588 = R: signal model: DEFAULT_RESISTOR_1020OHM_2_1
R206 R216 R217 R559 R564 R589 R594 = R: signal model: DEFAULT_RESISTOR_4990OHM_2_1
R212 R545 R575 = R: signal model: DEFAULT_RESISTOR_22.1OHM_2_1
R253-R258 R501 R1032 = R: signal model: DEFAULT_RESISTOR_330OHM_2_1
R260 = R: signal model: DEFAULT_RESISTOR_240OHM_2_1
R275-R281 R283-R289 R295-R297 R299 R301 R303 R305-R310 = R: signal model: DEFAULT_RESISTOR_5100OHM_2_1
R294 R1253-R1260 = R: signal model: DEFAULT_RESISTOR_150OHM_2_1
R504 = R: signal model: DEFAULT_RESISTOR_6040OHM_2_1
R526 = R: signal model: DEFAULT_RESISTOR_1600OHM_2_1
R531 = R: signal model: DEFAULT_RESISTOR_47000OHM_2_1
R636-R639 = R: signal model: DEFAULT_RESISTOR_0.001OHM_2_1; room: VIDEO
R640-R642 = R: signal model: DEFAULT_RESISTOR_150OHM_2_1; room: VIDEO
R658 = R: room: VIDEO; signal model: DEFAULT_RESISTOR_10000OHM_2_1
R659 = R: room: VIDEO; signal model: DEFAULT_RESISTOR_49900OHM_2_1
R670 R675 = R: signal model: DEFAULT_RESISTOR_33OHM_2_1; room: VIDEO
R788 R789 = R: room: VIDEO; signal model: DEFAULT_RESISTOR_0.001OHM_2_1
R795 R1273-R1280 = R: signal model: DEFAULT_RESISTOR_75OHM_2_1
R907 = R: signal model: R_R0402
R1022 = R: signal model: DEFAULT_RESISTOR_16500OHM_2_1
R1026 = R: signal model: DEFAULT_RESISTOR_12400OHM_2_1
R1028 = R: signal model: DEFAULT_RESISTOR_5110OHM_2_1
R1052 R1055 = R: signal model: DEFAULT_RESISTOR_33.2OHM_2_1
R1054 R1063 = R: signal model: DEFAULT_RESISTOR_200OHM_2_1
R1082 = R: signal model: DEFAULT_RESISTOR_43200OHM_2_1
R1085 R1088 = R: signal model: DEFAULT_RESISTOR_2940OHM_2_1
R1086 R1095 = R: signal model: DEFAULT_RESISTOR_9310OHM_2_1
R1089 = R: signal model: DEFAULT_RESISTOR_3300OHM_2_1
R1091 R1092 R1100 R1101 R1104 R1105 R1108 R1109 R1112 R1113 R1116 R1117 = R: signal model: DEFAULT_RESISTOR_4020OHM_2_1
R1097 = R: signal model: DEFAULT_RESISTOR_576OHM_2_1
R1127 R1128 R1250 R1252 R1326 R1328 = R: signal model: DEFAULT_RESISTOR_2000OHM_2_1
R1156 R1158 R1160 R1162 R1165 R1166 R1168 R1171 R1172 R1174 R1177 R1178 R1180 R1182 R1184 R1186 R1188 R1191 R1192 R1206 R1209 R1210 = R: signal model: DEFAULT_RESISTOR_1500OHM_2_1
S1 S3 = SW_PUSHBUTTON_4
TP1-TP12 = TP: alternate symbols: (TOP:TP30;BOTTOM:TP26)
U1 = 9VRS4339BKLFT
U2 = CENTERTON
U3 = DIODE_SK1
U4 U5 = W25X80
U9 = EMC14287APTR
U10 = ISL90727
U11 = LMV321AS5X
U13 U67 U134 = AT24C32
U14 = AST1300A1GP
U15 = K4B1G1646E-HCF8
U16 U58 U84-U89 U106 U133 U145 U146 = SN74LVC1G07
U30 = 88SE9130B1NAA2C000
U31 U33 = AT25160_1
U32 = UPD720201K8701BACA
U35 U37 = 82574L
U36 U38 = MX25L2005MC
U43 = IT8783
U44-U50 = DIODE_SK3: room: VIDEO
U51 U52 U55 U56 = MAX3243CPWR: signal model: MAX3243CPWR_TSSOP28
U53 U54 = IP4220CZ6
U57 U59 = MAX3243CPWR
U60 = PCA9516APW
U61 U73 = SC18IM700IPW
U62-U66 = PCA9535CPW
U68 U71 = TMP05ARTZ-500RL7
U69 U70 = ADT7470ARQZ
U92-U99 U103-U105 U107-U111 U114 U140-U144 = MOSFET_N
U100 = ADM11782ARMZR7
U101 = MAX809M
U102 = EPM240F100C5N
U115 = LC4032-75T48C
U119-U122 U130 = RT9059GQW
U123 = TPS51200
U124 = FDMS3600AS
U125 = PI7C9X20303SLFDE
U128 U129 = EPM240
U131 = 74LVC2G14
U132 = 74HC2G125DP: signal model: 74HC2G125DP_TSSOP8_3XA_IC__74HC_74HC2G125DP
U135 U136 = SN74CBTLV1G125
U137 U138 = NA0069RLF: signal model: NA0069RLF_TRF24
Y1 = 7V25000011
Y2-Y5 = CRYSTAL

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
BATTERY_BAT029K
  rect 1.626x1.626 hole 1.118: 1(0,0)
  round 1.524 hole 1.016: 2(-20,0)
BGA96XA
  round 0.368 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
BGA100
  round 0.49 smd: A1(-4.5,4.5) A2(-3.5,4.5) A3(-2.5,4.5) A4(-1.5,4.5) A5(-0.5,4.5) A6(0.5,4.5) A7(1.5,4.5) A8(2.5,4.5) A9(3.5,4.5) A10(4.5,4.5) B1(-4.5,3.5) B2(-3.5,3.5) B3(-2.5,3.5) B4(-1.5,3.5) B5(-0.5,3.5) B6(0.5,3.5) B7(1.5,3.5) B8(2.5,3.5) B9(3.5,3.5) B10(4.5,3.5) C1(-4.5,2.5) C2(-3.5,2.5) C3(-2.5,2.5) C4(-1.5,2.5) C5(-0.5,2.5) C6(0.5,2.5) C7(1.5,2.5) C8(2.5,2.5) C9(3.5,2.5) C10(4.5,2.5) D1(-4.5,1.5) D2(-3.5,1.5) D3(-2.5,1.5) D4(-1.5,1.5) D5(-0.5,1.5) D6(0.5,1.5) D7(1.5,1.5) D8(2.5,1.5) D9(3.5,1.5) D10(4.5,1.5) E1(-4.5,0.5) E2(-3.5,0.5) E3(-2.5,0.5) E4(-1.5,0.5) E5(-0.5,0.5) E6(0.5,0.5) E7(1.5,0.5) E8(2.5,0.5) E9(3.5,0.5) E10(4.5,0.5) F1(-4.5,-0.5) F2(-3.5,-0.5) F3(-2.5,-0.5) F4(-1.5,-0.5) F5(-0.5,-0.5) F6(0.5,-0.5) F7(1.5,-0.5) F8(2.5,-0.5) F9(3.5,-0.5) F10(4.5,-0.5) G1(-4.5,-1.5) G2(-3.5,-1.5) G3(-2.5,-1.5) G4(-1.5,-1.5) G5(-0.5,-1.5) G6(0.5,-1.5) G7(1.5,-1.5) G8(2.5,-1.5) G9(3.5,-1.5) G10(4.5,-1.5) H1(-4.5,-2.5) H2(-3.5,-2.5) H3(-2.5,-2.5) H4(-1.5,-2.5) H5(-0.5,-2.5) H6(0.5,-2.5) H7(1.5,-2.5) H8(2.5,-2.5) H9(3.5,-2.5) H10(4.5,-2.5) J1(-4.5,-3.5) J2(-3.5,-3.5) J3(-2.5,-3.5) J4(-1.5,-3.5) J5(-0.5,-3.5) J6(0.5,-3.5) J7(1.5,-3.5) J8(2.5,-3.5) J9(3.5,-3.5) J10(4.5,-3.5) K1(-4.5,-4.5) K2(-3.5,-4.5) K3(-2.5,-4.5) K4(-1.5,-4.5) K5(-0.5,-4.5) K6(0.5,-4.5) K7(1.5,-4.5) K8(2.5,-4.5) K9(3.5,-4.5) K10(4.5,-4.5)
BGA408
  round 0.368 smd: A1(-8.4,8.4) A2(-7.6,8.4) A3(-6.8,8.4) A4(-6,8.4) A5(-5.2,8.4) A6(-4.4,8.4) A7(-3.6,8.4) A8(-2.8,8.4) A9(-2,8.4) A10(-1.2,8.4) A11(-0.4,8.4) A12(0.4,8.4) A13(1.2,8.4) A14(2,8.4) A15(2.8,8.4) A16(3.6,8.4) A17(4.4,8.4) A18(5.2,8.4) A19(6,8.4) A20(6.8,8.4) A21(7.6,8.4) A22(8.4,8.4) AA1(-8.4,-7.6) AA2(-7.6,-7.6) AA3(-6.8,-7.6) AA4(-6,-7.6) AA5(-5.2,-7.6) AA6(-4.4,-7.6) AA7(-3.6,-7.6) AA8(-2.8,-7.6) AA9(-2,-7.6) AA10(-1.2,-7.6) AA11(-0.4,-7.6) AA12(0.4,-7.6) AA13(1.2,-7.6) AA14(2,-7.6) AA15(2.8,-7.6) AA16(3.6,-7.6) AA17(4.4,-7.6) AA18(5.2,-7.6) AA19(6,-7.6) AA20(6.8,-7.6) AA21(7.6,-7.6) AA22(8.4,-7.6) AB1(-8.4,-8.4) AB2(-7.6,-8.4) AB3(-6.8,-8.4) AB4(-6,-8.4) AB5(-5.2,-8.4) AB6(-4.4,-8.4) AB7(-3.6,-8.4) AB8(-2.8,-8.4) AB9(-2,-8.4) AB10(-1.2,-8.4) AB11(-0.4,-8.4) AB12(0.4,-8.4) AB13(1.2,-8.4) AB14(2,-8.4) AB15(2.8,-8.4) AB16(3.6,-8.4) AB17(4.4,-8.4) AB18(5.2,-8.4) AB19(6,-8.4) AB20(6.8,-8.4) AB21(7.6,-8.4) AB22(8.4,-8.4) B1(-8.4,7.6) B2(-7.6,7.6) B3(-6.8,7.6) B4(-6,7.6) B5(-5.2,7.6) B6(-4.4,7.6) B7(-3.6,7.6) B8(-2.8,7.6) B9(-2,7.6) B10(-1.2,7.6) B11(-0.4,7.6) B12(0.4,7.6) B13(1.2,7.6) B14(2,7.6) B15(2.8,7.6) B16(3.6,7.6) B17(4.4,7.6) B18(5.2,7.6) B19(6,7.6) B20(6.8,7.6) B21(7.6,7.6) B22(8.4,7.6) C1(-8.4,6.8) C2(-7.6,6.8) C3(-6.8,6.8) C4(-6,6.8) C5(-5.2,6.8) C6(-4.4,6.8) C7(-3.6,6.8) C8(-2.8,6.8) C9(-2,6.8) C10(-1.2,6.8) C11(-0.4,6.8) C12(0.4,6.8) C13(1.2,6.8) C14(2,6.8) C15(2.8,6.8) C16(3.6,6.8) C17(4.4,6.8) C18(5.2,6.8) C19(6,6.8) C20(6.8,6.8) C21(7.6,6.8) C22(8.4,6.8) D1(-8.4,6) D2(-7.6,6) D3(-6.8,6) D4(-6,6) D5(-5.2,6) D6(-4.4,6) D7(-3.6,6) D8(-2.8,6) D9(-2,6) D10(-1.2,6) D11(-0.4,6) D12(0.4,6) D13(1.2,6) D14(2,6) D15(2.8,6) D16(3.6,6) D17(4.4,6) D18(5.2,6) D19(6,6) D20(6.8,6) D21(7.6,6) D22(8.4,6) E1(-8.4,5.2) E2(-7.6,5.2) E3(-6.8,5.2) E4(-6,5.2) E5(-5.2,5.2) E6(-4.4,5.2) E7(-3.6,5.2) E8(-2.8,5.2) E9(-2,5.2) E10(-1.2,5.2) E11(-0.4,5.2) E12(0.4,5.2) E13(1.2,5.2) E14(2,5.2) E15(2.8,5.2) E16(3.6,5.2) E17(4.4,5.2) E18(5.2,5.2) E19(6,5.2) E20(6.8,5.2) E21(7.6,5.2) E22(8.4,5.2) F1(-8.4,4.4) F2(-7.6,4.4) F3(-6.8,4.4) F4(-6,4.4) F5(-5.2,4.4) F8(-2.8,4.4) F9(-2,4.4) F10(-1.2,4.4) F11(-0.4,4.4) F12(0.4,4.4) F13(1.2,4.4) F14(2,4.4) F15(2.8,4.4) F18(5.2,4.4) F19(6,4.4) F20(6.8,4.4) F21(7.6,4.4) F22(8.4,4.4) G1(-8.4,3.6) G2(-7.6,3.6) G3(-6.8,3.6) G4(-6,3.6) G5(-5.2,3.6) G18(5.2,3.6) G19(6,3.6) G20(6.8,3.6) G21(7.6,3.6) G22(8.4,3.6) H1(-8.4,2.8) H2(-7.6,2.8) H3(-6.8,2.8) H4(-6,2.8) H5(-5.2,2.8) H6(-4.4,2.8) H17(4.4,2.8) H18(5.2,2.8) H19(6,2.8) H20(6.8,2.8) H21(7.6,2.8) H22(8.4,2.8) J1(-8.4,2) J2(-7.6,2) J3(-6.8,2) J4(-6,2) J5(-5.2,2) J6(-4.4,2) J9(-2,2) J10(-1.2,2) J11(-0.4,2) J12(0.4,2) J13(1.2,2) J14(2,2) J17(4.4,2) J18(5.2,2) J19(6,2) J20(6.8,2) J21(7.6,2) J22(8.4,2) K1(-8.4,1.2) K2(-7.6,1.2) K3(-6.8,1.2) K4(-6,1.2) K5(-5.2,1.2) K6(-4.4,1.2) K9(-2,1.2) K10(-1.2,1.2) K11(-0.4,1.2) K12(0.4,1.2) K13(1.2,1.2) K14(2,1.2) K17(4.4,1.2) K18(5.2,1.2) K19(6,1.2) K20(6.8,1.2) K21(7.6,1.2) K22(8.4,1.2) L1(-8.4,0.4) L2(-7.6,0.4) L3(-6.8,0.4) L4(-6,0.4) L5(-5.2,0.4) L6(-4.4,0.4) L9(-2,0.4) L10(-1.2,0.4) L11(-0.4,0.4) L12(0.4,0.4) L13(1.2,0.4) L14(2,0.4) L17(4.4,0.4) L18(5.2,0.4) L19(6,0.4) L20(6.8,0.4) L21(7.6,0.4) L22(8.4,0.4) M1(-8.4,-0.4) M2(-7.6,-0.4) M3(-6.8,-0.4) M4(-6,-0.4) M5(-5.2,-0.4) M6(-4.4,-0.4) M9(-2,-0.4) M10(-1.2,-0.4) M11(-0.4,-0.4) M12(0.4,-0.4) M13(1.2,-0.4) M14(2,-0.4) M17(4.4,-0.4) M18(5.2,-0.4) M19(6,-0.4) M20(6.8,-0.4) M21(7.6,-0.4) M22(8.4,-0.4) N1(-8.4,-1.2) N2(-7.6,-1.2) N3(-6.8,-1.2) N4(-6,-1.2) N5(-5.2,-1.2) N6(-4.4,-1.2) N9(-2,-1.2) N10(-1.2,-1.2) N11(-0.4,-1.2) N12(0.4,-1.2) N13(1.2,-1.2) N14(2,-1.2) N17(4.4,-1.2) N18(5.2,-1.2) N19(6,-1.2) N20(6.8,-1.2) N21(7.6,-1.2) N22(8.4,-1.2) P1(-8.4,-2) P2(-7.6,-2) P3(-6.8,-2) P4(-6,-2) P5(-5.2,-2) P6(-4.4,-2) P9(-2,-2) P10(-1.2,-2) P11(-0.4,-2) P12(0.4,-2) P13(1.2,-2) P14(2,-2) P17(4.4,-2) P18(5.2,-2) P19(6,-2) P20(6.8,-2) P21(7.6,-2) P22(8.4,-2) R1(-8.4,-2.8) R2(-7.6,-2.8) R3(-6.8,-2.8) R4(-6,-2.8) R5(-5.2,-2.8) R6(-4.4,-2.8) R17(4.4,-2.8) R18(5.2,-2.8) R19(6,-2.8) R20(6.8,-2.8) R21(7.6,-2.8) R22(8.4,-2.8) T1(-8.4,-3.6) T2(-7.6,-3.6) T3(-6.8,-3.6) T4(-6,-3.6) T5(-5.2,-3.6) T18(5.2,-3.6) T19(6,-3.6) T20(6.8,-3.6) T21(7.6,-3.6) T22(8.4,-3.6) U1(-8.4,-4.4) U2(-7.6,-4.4) U3(-6.8,-4.4) U4(-6,-4.4) U5(-5.2,-4.4) U8(-2.8,-4.4) U9(-2,-4.4) U10(-1.2,-4.4) U11(-0.4,-4.4) U12(0.4,-4.4) U13(1.2,-4.4) U14(2,-4.4) U15(2.8,-4.4) U18(5.2,-4.4) U19(6,-4.4) U20(6.8,-4.4) U21(7.6,-4.4) U22(8.4,-4.4) V1(-8.4,-5.2) V2(-7.6,-5.2) V3(-6.8,-5.2) V4(-6,-5.2) V5(-5.2,-5.2) V6(-4.4,-5.2) V7(-3.6,-5.2) V8(-2.8,-5.2) V9(-2,-5.2) V10(-1.2,-5.2) V11(-0.4,-5.2) V12(0.4,-5.2) V13(1.2,-5.2) V14(2,-5.2) V15(2.8,-5.2) V16(3.6,-5.2) V17(4.4,-5.2) V18(5.2,-5.2) V19(6,-5.2) V20(6.8,-5.2) V21(7.6,-5.2) V22(8.4,-5.2) W1(-8.4,-6) W2(-7.6,-6) W3(-6.8,-6) W4(-6,-6) W5(-5.2,-6) W6(-4.4,-6) W7(-3.6,-6) W8(-2.8,-6) W9(-2,-6) W10(-1.2,-6) W11(-0.4,-6) W12(0.4,-6) W13(1.2,-6) W14(2,-6) W15(2.8,-6) W16(3.6,-6) W17(4.4,-6) W18(5.2,-6) W19(6,-6) W20(6.8,-6) W21(7.6,-6) W22(8.4,-6) Y1(-8.4,-6.8) Y2(-7.6,-6.8) Y3(-6.8,-6.8) Y4(-6,-6.8) Y5(-5.2,-6.8) Y6(-4.4,-6.8) Y7(-3.6,-6.8) Y8(-2.8,-6.8) Y9(-2,-6.8) Y10(-1.2,-6.8) Y11(-0.4,-6.8) Y12(0.4,-6.8) Y13(1.2,-6.8) Y14(2,-6.8) Y15(2.8,-6.8) Y16(3.6,-6.8) Y17(4.4,-6.8) Y18(5.2,-6.8) Y19(6,-6.8) Y20(6.8,-6.8) Y21(7.6,-6.8) Y22(8.4,-6.8)
BGA1283
  round 0.406 smd: A5(-14.485,13.111) A6(-13.673,13.111) A61(13.673,13.111) A62(14.485,13.111) A64(15.298,13.111) A66(16.111,13.111) BJ1(-16.111,-10.673) BJ66(16.111,-10.673) BK1(-16.111,-11.485) BK3(-15.298,-11.485) BK5(-14.485,-11.485) BK62(14.485,-11.485) BK64(15.298,-11.485) BK66(16.111,-11.485) BM1(-16.111,-12.298) BM3(-15.298,-12.298) BM5(-14.485,-12.298) BM62(14.485,-12.298) BM64(15.298,-12.298) BM66(16.111,-12.298) BP1(-16.111,-13.111) BP3(-15.298,-13.111) BP5(-14.485,-13.111) BP6(-13.673,-13.111) BP61(13.673,-13.111) BP62(14.485,-13.111) BP64(15.298,-13.111) BP66(16.111,-13.111) C3(-15.298,12.298) C5(-14.485,12.298) C62(14.485,12.298) C64(15.298,12.298) C66(16.111,12.298) E1(-16.111,11.485) E3(-15.298,11.485) E5(-14.485,11.485) E62(14.485,11.485) E64(15.298,11.485) E66(16.111,11.485) F1(-16.111,10.673) F66(16.111,10.673)
  oval 0.279x0.343 smd: A8(-12.86,13.111) A59(12.86,13.111) BP8(-12.86,-13.111) BP59(12.86,-13.111)
  oval 0.254x0.343 smd: A9(-12.173,13.249) A12(-10.548,13.249) A15(-9.109,13.249) A18(-7.671,13.249) A21(-6.045,13.249) A24(-4.606,13.249) A27(-3.168,13.249) A30(-1.542,13.249) A33(-0.103,13.249) A36(1.335,13.249) A39(2.961,13.249) A42(4.4,13.249) A45(5.838,13.249) A48(7.464,13.249) A51(8.902,13.249) A54(10.341,13.249) A57(11.967,13.249) BP10(-11.967,-13.249) BP13(-10.341,-13.249) BP16(-8.902,-13.249) BP19(-7.464,-13.249) BP22(-5.838,-13.249) BP25(-4.4,-13.249) BP28(-2.961,-13.249) BP31(-1.335,-13.249) BP34(0.103,-13.249) BP37(1.542,-13.249) BP40(3.168,-13.249) BP43(4.606,-13.249) BP46(6.045,-13.249) BP49(7.671,-13.249) BP52(9.109,-13.249) BP55(10.548,-13.249) BP58(12.173,-13.249)
  round 0.305 smd: AA3(-15.247,3.216) AA5(-14.014,3.186) AA47(6.842,3.156) AA62(14.08,3.388) AA64(15.243,3.398) AB2(-15.641,2.611) AB4(-14.901,2.605) AB5(-14.204,2.508) AB20(-6.842,2.916) AB62(14.204,2.695) AB63(14.901,2.787) AB65(15.639,2.818) AC8(-12.963,2.216) AC9(-12.201,2.216) AC11(-11.439,2.216) AC12(-10.677,2.216) AC14(-9.915,2.216) AC15(-9.153,2.216) AC17(-8.391,2.216) AC18(-7.629,2.216) AC20(-6.929,2.216) AC47(6.929,2.456) AC49(7.629,2.456) AC50(8.391,2.456) AC52(9.153,2.456) AC53(9.915,2.456) AC55(10.677,2.456) AC56(11.439,2.456) AC58(12.201,2.456) AC59(12.963,2.456) AD2(-15.639,1.685) AD4(-14.901,1.716) AD5(-14.204,1.808) AD8(-12.963,1.516) AD9(-12.201,1.516) AD11(-11.439,1.516) AD12(-10.677,1.516) AD14(-9.915,1.516) AD15(-9.153,1.516) AD17(-8.391,1.516) AD18(-7.629,1.516) AD20(-6.929,1.516) AD47(6.929,1.756) AD49(7.629,1.756) AD50(8.391,1.756) AD52(9.153,1.756) AD53(9.915,1.756) AD55(10.677,1.756) AD56(11.439,1.756) AD58(12.201,1.756) AD59(12.963,1.756) AD62(14.204,1.995) AD63(14.901,1.898) AD65(15.641,1.892) AE3(-15.243,1.105) AE5(-14.08,1.115) AE47(6.842,1.056) AE62(14.014,1.317) AE64(15.247,1.287) AF2(-15.752,0.618) AF4(-14.795,0.565) AF20(-6.842,0.816) AF62(14.063,0.614) AF63(14.752,0.783) AF65(15.806,0.863) AG5(-14.063,0.407) AG7(-13.344,0.23) AG8(-12.582,0.23) AG10(-11.82,0.23) AG11(-11.058,0.23) AG13(-10.296,0.23) AG14(-9.534,0.23) AG16(-8.772,0.23) AG17(-8.01,0.23) AG19(-7.248,0.23) AG48(7.248,0.47) AG50(8.01,0.47) AG51(8.772,0.47) AG53(9.534,0.47) AG54(10.296,0.47) AG56(11.058,0.47) AG57(11.82,0.47) AG59(12.582,0.47) AG60(13.344,0.47) AG63(14.543,0.104) AG64(15.305,0.053) AH3(-15.305,-0.053) AH4(-14.543,-0.104) AH7(-13.344,-0.47) AH8(-12.582,-0.47) AH10(-11.82,-0.47) AH11(-11.058,-0.47) AH13(-10.296,-0.47) AH14(-9.534,-0.47) AH16(-8.772,-0.47) AH17(-8.01,-0.47) AH19(-7.248,-0.47) AH48(7.248,-0.23) AH50(8.01,-0.23) AH51(8.772,-0.23) AH53(9.534,-0.23) AH54(10.296,-0.23) AH56(11.058,-0.23) AH57(11.82,-0.23) AH59(12.582,-0.23) AH60(13.344,-0.23) AH62(14.063,-0.407) AJ2(-15.806,-0.863) AJ4(-14.752,-0.783) AJ5(-14.063,-0.614) AJ47(6.842,-0.816) AJ63(14.795,-0.565) AJ65(15.752,-0.618) AK3(-15.247,-1.287) AK5(-14.014,-1.317) AK20(-6.842,-1.056) AK62(14.08,-1.115) AK64(15.243,-1.105) AL2(-15.641,-1.892) AL4(-14.901,-1.898) AL5(-14.204,-1.995) AL8(-12.963,-1.756) AL9(-12.201,-1.756) AL11(-11.439,-1.756) AL12(-10.677,-1.756) AL14(-9.915,-1.756) AL15(-9.153,-1.756) AL17(-8.391,-1.756) AL18(-7.629,-1.756) AL20(-6.929,-1.756) AL47(6.929,-1.516) AL49(7.629,-1.516) AL50(8.391,-1.516) AL52(9.153,-1.516) AL53(9.915,-1.516) AL55(10.677,-1.516) AL56(11.439,-1.516) AL58(12.201,-1.516) AL59(12.963,-1.516) AL62(14.204,-1.808) AL63(14.901,-1.716) AL65(15.639,-1.685) AM8(-12.963,-2.456) AM9(-12.201,-2.456) AM11(-11.439,-2.456) AM12(-10.677,-2.456) AM14(-9.915,-2.456) AM15(-9.153,-2.456) AM17(-8.391,-2.456) AM18(-7.629,-2.456) AM20(-6.929,-2.456) AM47(6.929,-2.216) AM49(7.629,-2.216) AM50(8.391,-2.216) AM52(9.153,-2.216) AM53(9.915,-2.216) AM55(10.677,-2.216) AM56(11.439,-2.216) AM58(12.201,-2.216) AM59(12.963,-2.216) AN2(-15.639,-2.818) AN4(-14.901,-2.787) AN5(-14.204,-2.695) AN47(6.842,-2.916) AN62(14.204,-2.508) AN63(14.901,-2.605) AN65(15.641,-2.611) AP3(-15.243,-3.398) AP5(-14.08,-3.388) AP20(-6.842,-3.156) AP62(14.014,-3.186) AP64(15.247,-3.216) AR2(-15.752,-3.885) AR4(-14.795,-3.938) AR7(-13.344,-3.742) AR8(-12.582,-3.742) AR10(-11.82,-3.742) AR11(-11.058,-3.742) AR13(-10.296,-3.742) AR14(-9.534,-3.742) AR16(-8.772,-3.742) AR17(-8.01,-3.742) AR19(-7.248,-3.742) AR48(7.248,-3.503) AR50(8.01,-3.503) AR51(8.772,-3.503) AR53(9.534,-3.503) AR54(10.296,-3.503) AR56(11.058,-3.503) AR57(11.82,-3.503) AR59(12.582,-3.503) AR60(13.344,-3.503) AR62(14.063,-3.888) AR63(14.752,-3.72) AR65(15.806,-3.64) AT5(-14.063,-4.096) AT7(-13.344,-4.442) AT8(-12.582,-4.442) AT10(-11.82,-4.442) AT11(-11.058,-4.442) AT13(-10.296,-4.442) AT14(-9.534,-4.442) AT16(-8.772,-4.442) AT17(-8.01,-4.442) AT19(-7.248,-4.442) AT48(7.248,-4.203) AT50(8.01,-4.203) AT51(8.772,-4.203) AT53(9.534,-4.203) AT54(10.296,-4.203) AT56(11.058,-4.203) AT57(11.82,-4.203) AT59(12.582,-4.203) AT60(13.344,-4.203) AT63(14.543,-4.399) AT64(15.305,-4.45) AU3(-15.305,-4.556) AU4(-14.543,-4.607) AU47(6.726,-4.801) AU62(14.063,-4.91) AV2(-15.806,-5.366) AV4(-14.752,-5.286) AV5(-14.063,-5.117) AV63(14.795,-5.068) AV65(15.752,-5.121) AW3(-15.247,-5.789) AW5(-14.014,-5.82) AW8(-12.963,-5.729) AW9(-12.201,-5.729) AW11(-11.439,-5.729) AW12(-10.677,-5.729) AW14(-9.915,-5.729) AW15(-9.153,-5.729) AW17(-8.175,-5.772) AW19(-7.475,-5.772) AW20(-6.801,-5.501) AW21(-5.901,-5.501) AW23(-5.201,-5.501) AW25(-4.203,-5.772) AW26(-3.503,-5.772) AW28(-2.8,-5.501) AW30(-1.9,-5.501) AW31(-1.2,-5.501) AW32(-0.23,-5.772) AW34(0.47,-5.772) AW36(1.2,-5.501) AW38(2.1,-5.501) AW39(2.8,-5.501) AW41(3.742,-5.772) AW42(4.442,-5.772) AW44(5.201,-5.501) AW46(6.001,-5.501) AW47(6.701,-5.501) AW49(7.715,-5.772) AW50(8.415,-5.772) AW52(9.153,-5.489) AW53(9.915,-5.489) AW55(10.677,-5.489) AW56(11.439,-5.489) AW58(12.201,-5.489) AW59(12.963,-5.489) AW62(14.08,-5.617) AW64(15.243,-5.608) AY2(-15.641,-6.395) AY4(-14.901,-6.401) AY5(-14.204,-6.498) AY8(-12.963,-6.429) AY9(-12.201,-6.429) AY11(-11.439,-6.429) AY12(-10.677,-6.429) AY14(-9.915,-6.429) AY15(-9.153,-6.429) AY19(-7.475,-6.534) AY21(-6.189,-6.153) AY23(-5.489,-6.153) AY29(-2.216,-6.153) AY30(-1.516,-6.153) AY37(1.756,-6.153) AY38(2.456,-6.153) AY45(5.729,-6.153) AY46(6.429,-6.153) AY52(9.153,-6.189) AY53(9.915,-6.189) AY55(10.677,-6.189) AY56(11.439,-6.189) AY58(12.201,-6.189) AY59(12.963,-6.189) AY62(14.204,-6.311) AY63(14.901,-6.219) AY65(15.639,-6.187) B10(-11.824,12.639) B12(-10.897,12.641) B14(-9.869,12.806) B17(-8.388,12.752) B19(-7.321,12.639) B21(-6.394,12.641) B23(-5.366,12.806) B26(-3.885,12.752) B28(-2.818,12.639) B30(-1.892,12.641) B32(-0.863,12.806) B35(0.618,12.752) B37(1.685,12.639) B39(2.611,12.641) B41(3.64,12.806) B44(5.121,12.752) B46(6.188,12.639) B48(7.114,12.641) B50(8.143,12.806) B53(9.624,12.752) B55(10.691,12.639) B57(11.617,12.641) BA17(-8.175,-6.534) BA21(-6.189,-6.915) BA23(-5.489,-6.915) BA25(-4.203,-6.534) BA26(-3.503,-6.534) BA29(-2.216,-6.915) BA30(-1.516,-6.915) BA32(-0.23,-6.534) BA34(0.47,-6.534) BA37(1.756,-6.915) BA38(2.456,-6.915) BA41(3.742,-6.534) BA42(4.442,-6.534) BA45(5.729,-6.915) BA46(6.429,-6.915) BA49(7.715,-6.534) BA50(8.415,-6.534) BB2(-15.639,-7.321) BB4(-14.901,-7.29) BB5(-14.204,-7.198) BB17(-8.175,-7.296) BB19(-7.475,-7.296) BB25(-4.203,-7.296) BB26(-3.503,-7.296) BB32(-0.23,-7.296) BB34(0.47,-7.296) BB41(3.742,-7.296) BB42(4.442,-7.296) BB49(7.715,-7.296) BB50(8.415,-7.296) BB53(9.534,-7.475) BB54(10.296,-7.475) BB56(11.058,-7.475) BB57(11.82,-7.475) BB59(12.582,-7.475) BB60(13.344,-7.475) BB62(14.204,-7.011) BB63(14.901,-7.108) BB65(15.641,-7.114) BC3(-15.243,-7.901) BC5(-14.08,-7.891) BC7(-13.344,-7.715) BC8(-12.582,-7.715) BC10(-11.82,-7.715) BC11(-11.058,-7.715) BC13(-10.296,-7.715) BC15(-9.461,-7.677) BC21(-6.189,-7.677) BC23(-5.489,-7.677) BC29(-2.216,-7.677) BC30(-1.516,-7.677) BC37(1.756,-7.677) BC38(2.456,-7.677) BC45(5.729,-7.677) BC46(6.429,-7.677) BC62(14.014,-7.689) BC64(15.247,-7.719) BD2(-15.752,-8.388) BD4(-14.795,-8.441) BD7(-13.344,-8.415) BD8(-12.582,-8.415) BD10(-11.82,-8.415) BD13(-10.162,-8.439) BD15(-9.461,-8.439) BD17(-8.175,-8.058) BD19(-7.475,-8.058) BD21(-6.189,-8.439) BD23(-5.489,-8.439) BD25(-4.203,-8.058) BD26(-3.503,-8.058) BD29(-2.216,-8.439) BD30(-1.516,-8.439) BD32(-0.23,-8.058) BD34(0.47,-8.058) BD37(1.756,-8.439) BD38(2.456,-8.439) BD41(3.742,-8.058) BD42(4.442,-8.058) BD45(5.729,-8.439) BD46(6.429,-8.439) BD49(7.715,-8.058) BD50(8.415,-8.058) BD53(9.701,-8.439) BD54(10.401,-8.439) BD59(12.582,-8.175) BD60(13.344,-8.175) BD62(14.063,-8.391) BD63(14.752,-8.222) BD65(15.806,-8.143) BE5(-14.063,-8.599) BE17(-8.175,-8.82) BE19(-7.475,-8.82) BE25(-4.203,-8.82) BE26(-3.503,-8.82) BE32(-0.23,-8.82) BE34(0.47,-8.82) BE41(3.742,-8.82) BE42(4.442,-8.82) BE49(7.715,-8.82) BE50(8.415,-8.82) BE57(11.688,-8.82) BE63(14.543,-8.902) BE64(15.305,-8.953) BF3(-15.305,-9.059) BF4(-14.543,-9.109) BF13(-10.162,-9.201) BF15(-9.461,-9.201) BF21(-6.189,-9.201) BF23(-5.489,-9.201) BF29(-2.216,-9.201) BF30(-1.516,-9.201) BF37(1.756,-9.201) BF38(2.456,-9.201) BF45(5.729,-9.201) BF46(6.429,-9.201) BF53(9.701,-9.201) BF54(10.401,-9.201) BF62(14.063,-9.413) BG4(-14.752,-9.789) BG5(-14.063,-9.62) BG8(-12.963,-9.701) BG9(-12.201,-9.701) BG11(-11.448,-9.582) BG13(-10.162,-9.963) BG15(-9.461,-9.963) BG17(-8.175,-9.582) BG19(-7.475,-9.582) BG21(-6.189,-9.963) BG23(-5.489,-9.963) BG25(-4.203,-9.582) BG26(-3.503,-9.582) BG29(-2.216,-9.963) BG30(-1.516,-9.963) BG32(-0.23,-9.582) BG34(0.47,-9.582) BG37(1.756,-9.963) BG38(2.456,-9.963) BG41(3.742,-9.582) BG42(4.442,-9.582) BG45(5.729,-9.963) BG46(6.429,-9.963) BG49(7.715,-9.582) BG50(8.415,-9.582) BG53(9.701,-9.963) BG54(10.401,-9.963) BG57(11.688,-9.582) BG58(12.388,-9.582) BG63(14.752,-9.582) BH3(-15.298,-10.318) BH5(-14.014,-10.323) BH8(-12.582,-10.344) BH11(-11.448,-10.344) BH17(-8.175,-10.344) BH19(-7.475,-10.344) BH25(-4.203,-10.344) BH26(-3.503,-10.344) BH32(-0.23,-10.344) BH34(0.47,-10.344) BH41(3.742,-10.344) BH42(4.442,-10.344) BH49(7.715,-10.344) BH50(8.415,-10.344) BH57(11.688,-10.344) BH58(12.388,-10.344) BH60(13.344,-10.162) BH62(14.08,-10.12) BH64(15.298,-10.11) BJ4(-14.901,-10.904) BJ62(14.204,-10.814) BJ63(14.901,-10.696) BK6(-13.916,-11.063) BK8(-12.895,-11.063) BK9(-12.192,-11.014) BK10(-11.514,-11.204) BK12(-10.814,-11.204) BK13(-10.121,-11.074) BK15(-9.413,-11.063) BK17(-8.392,-11.063) BK18(-7.689,-11.014) BK19(-7.011,-11.204) BK21(-6.311,-11.204) BK22(-5.618,-11.074) BK24(-4.91,-11.063) BK26(-3.889,-11.063) BK27(-3.186,-11.014) BK28(-2.508,-11.204) BK30(-1.808,-11.204) BK31(-1.115,-11.074) BK32(-0.407,-11.063) BK35(0.614,-11.063) BK36(1.316,-11.014) BK37(1.995,-11.204) BK39(2.695,-11.204) BK40(3.388,-11.074) BK42(4.095,-11.063) BK44(5.117,-11.063) BK45(5.819,-11.014) BK46(6.498,-11.204) BK48(7.198,-11.204) BK49(7.891,-11.08) BK51(8.598,-11.063) BK53(9.62,-11.063) BK54(10.322,-11.014) BK56(11,-11.204) BK57(11.701,-11.204) BK58(12.394,-11.08) BK60(13.102,-11.063) BL7(-13.405,-11.543) BL8(-12.726,-11.752) BL10(-11.611,-11.901) BL12(-10.722,-11.901) BL14(-9.571,-11.795) BL16(-8.902,-11.543) BL17(-8.223,-11.752) BL19(-7.108,-11.901) BL21(-6.219,-11.901) BL23(-5.068,-11.795) BL25(-4.4,-11.543) BL26(-3.72,-11.752) BL28(-2.605,-11.901) BL30(-1.716,-11.901) BL32(-0.565,-11.795) BL34(0.103,-11.543) BL35(0.783,-11.752) BL37(1.898,-11.901) BL39(2.787,-11.901) BL41(3.938,-11.795) BL43(4.606,-11.543) BL44(5.286,-11.752) BL46(6.401,-11.901) BL48(7.29,-11.901) BL50(8.441,-11.795) BL52(9.109,-11.543) BL53(9.789,-11.752) BL55(10.903,-11.901) BL57(11.792,-11.901) BL59(12.933,-11.752) BL61(13.612,-11.543) BM7(-13.405,-12.305) BM9(-12.222,-12.247) BM13(-10.111,-12.243) BM16(-8.953,-12.305) BM18(-7.72,-12.247) BM22(-5.608,-12.243) BM25(-4.45,-12.305) BM27(-3.217,-12.247) BM31(-1.105,-12.243) BM34(0.053,-12.305) BM36(1.286,-12.247) BM40(3.398,-12.243) BM43(4.555,-12.305) BM45(5.789,-12.247) BM49(7.901,-12.243) BM52(9.058,-12.305) BM54(10.292,-12.247) BM58(12.404,-12.243) BM61(13.612,-12.305) BN10(-11.617,-12.641) BN12(-10.691,-12.639) BN14(-9.624,-12.752) BN17(-8.143,-12.806) BN19(-7.114,-12.641) BN21(-6.188,-12.639) BN23(-5.121,-12.752) BN26(-3.64,-12.806) BN28(-2.611,-12.641) BN30(-1.685,-12.639) BN32(-0.618,-12.752) BN35(0.863,-12.806) BN37(1.892,-12.641) BN39(2.818,-12.639) BN41(3.885,-12.752) BN44(5.366,-12.806) BN46(6.394,-12.641) BN48(7.321,-12.639) BN50(8.388,-12.752) BN53(9.869,-12.806) BN55(10.897,-12.641) BN57(11.824,-12.639) C6(-13.612,12.305) C9(-12.404,12.243) C13(-10.292,12.247) C15(-9.058,12.305) C18(-7.901,12.243) C22(-5.789,12.247) C24(-4.555,12.305) C27(-3.398,12.243) C31(-1.286,12.247) C33(-0.053,12.305) C36(1.105,12.243) C40(3.217,12.247) C42(4.45,12.305) C45(5.608,12.243) C49(7.72,12.247) C51(8.953,12.305) C54(10.111,12.243) C58(12.222,12.247) C60(13.405,12.305) D6(-13.612,11.543) D8(-12.933,11.752) D10(-11.792,11.901) D12(-10.903,11.901) D14(-9.789,11.752) D15(-9.109,11.543) D17(-8.441,11.795) D19(-7.29,11.901) D21(-6.401,11.901) D23(-5.286,11.752) D24(-4.606,11.543) D26(-3.938,11.795) D28(-2.787,11.901) D30(-1.898,11.901) D32(-0.783,11.752) D33(-0.103,11.543) D35(0.565,11.795) D37(1.716,11.901) D39(2.605,11.901) D41(3.72,11.752) D42(4.4,11.543) D44(5.068,11.795) D46(6.219,11.901) D48(7.108,11.901) D50(8.223,11.752) D51(8.902,11.543) D53(9.571,11.795) D55(10.722,11.901) D57(11.611,11.901) D59(12.726,11.752) D60(13.405,11.543) E7(-13.102,11.063) E9(-12.394,11.08) E10(-11.701,11.204) E12(-11,11.204) E13(-10.322,11.014) E14(-9.62,11.063) E16(-8.598,11.063) E18(-7.891,11.08) E19(-7.198,11.204) E21(-6.498,11.204) E22(-5.819,11.014) E23(-5.117,11.063) E25(-4.095,11.063) E27(-3.388,11.08) E28(-2.695,11.204) E30(-1.995,11.204) E31(-1.316,11.014) E32(-0.614,11.063) E34(0.407,11.063) E36(1.115,11.074) E37(1.808,11.204) E39(2.508,11.204) E40(3.186,11.014) E41(3.889,11.063) E43(4.91,11.063) E45(5.618,11.08) E46(6.311,11.204) E48(7.011,11.204) E49(7.689,11.014) E50(8.392,11.063) E52(9.413,11.063) E54(10.121,11.08) E55(10.814,11.204) E57(11.514,11.204) E58(12.192,11.014) E59(12.895,11.063) E61(13.916,11.063) F4(-14.901,10.696) F5(-14.204,10.814) F63(14.901,10.904) G3(-15.298,10.11) G5(-14.08,10.12) G7(-13.344,10.162) G9(-12.388,10.344) G10(-11.688,10.344) G17(-8.415,10.344) G18(-7.715,10.344) G25(-4.442,10.344) G26(-3.742,10.344) G32(-0.47,10.344) G34(0.23,10.344) G41(3.503,10.344) G42(4.203,10.344) G48(7.475,10.344) G50(8.175,10.344) G56(11.448,10.344) G59(12.582,10.344) G62(14.014,10.323) G64(15.298,10.318) H4(-14.752,9.582) H9(-12.388,9.582) H10(-11.688,9.582) H13(-10.401,9.963) H14(-9.701,9.963) H17(-8.415,9.582) H18(-7.715,9.582) H21(-6.429,9.963) H22(-5.729,9.963) H25(-4.442,9.582) H26(-3.742,9.582) H29(-2.456,9.963) H30(-1.756,9.963) H32(-0.47,9.582) H34(0.23,9.582) H37(1.516,9.963) H38(2.216,9.963) H41(3.503,9.582) H42(4.203,9.582) H44(5.489,9.963) H46(6.189,9.963) H48(7.475,9.582) H50(8.175,9.582) H52(9.461,9.963) H54(10.162,9.963) H56(11.448,9.582) H58(12.201,9.701) H59(12.963,9.701) H62(14.063,9.62) H63(14.752,9.789) J5(-14.063,9.413) J13(-10.401,9.201) J14(-9.701,9.201) J21(-6.429,9.201) J22(-5.729,9.201) J29(-2.456,9.201) J30(-1.756,9.201) J37(1.516,9.201) J38(2.216,9.201) J44(5.489,9.201) J46(6.189,9.201) J52(9.461,9.201) J54(10.162,9.201) J63(14.543,9.109) J64(15.305,9.059) K3(-15.305,8.953) K4(-14.543,8.902) K10(-11.688,8.82) K17(-8.415,8.82) K18(-7.715,8.82) K25(-4.442,8.82) K26(-3.742,8.82) K32(-0.47,8.82) K34(0.23,8.82) K41(3.503,8.82) K42(4.203,8.82) K48(7.475,8.82) K50(8.175,8.82) K62(14.063,8.599) L2(-15.806,8.143) L4(-14.752,8.222) L5(-14.063,8.391) L7(-13.344,8.175) L8(-12.582,8.175) L13(-10.401,8.439) L14(-9.701,8.439) L17(-8.415,8.058) L18(-7.715,8.058) L21(-6.429,8.439) L22(-5.729,8.439) L25(-4.442,8.058) L26(-3.742,8.058) L29(-2.456,8.439) L30(-1.756,8.439) L32(-0.47,8.058) L34(0.23,8.058) L37(1.516,8.439) L38(2.216,8.439) L41(3.503,8.058) L42(4.203,8.058) L44(5.489,8.439) L46(6.189,8.439) L48(7.475,8.058) L50(8.175,8.058) L52(9.461,8.439) L54(10.162,8.439) L57(11.82,8.415) L59(12.582,8.415) L60(13.344,8.415) L63(14.795,8.441) L65(15.752,8.388) M3(-15.247,7.719) M5(-14.014,7.689) M21(-6.429,7.677) M22(-5.729,7.677) M29(-2.456,7.677) M30(-1.756,7.677) M37(1.516,7.677) M38(2.216,7.677) M44(5.489,7.677) M46(6.189,7.677) M52(9.461,7.677) M54(10.296,7.715) M56(11.058,7.715) M57(11.82,7.715) M59(12.582,7.715) M60(13.344,7.715) M62(14.08,7.891) M64(15.243,7.901) N2(-15.641,7.114) N4(-14.901,7.108) N5(-14.204,7.011) N7(-13.344,7.475) N8(-12.582,7.475) N10(-11.82,7.475) N11(-11.058,7.475) N13(-10.296,7.475) N14(-9.534,7.475) N17(-8.415,7.296) N18(-7.715,7.296) N25(-4.442,7.296) N26(-3.742,7.296) N32(-0.47,7.296) N34(0.23,7.296) N41(3.503,7.296) N42(4.203,7.296) N48(7.475,7.296) N50(8.175,7.296) N62(14.204,7.198) N63(14.901,7.29) N65(15.639,7.321) P17(-8.415,6.534) P18(-7.715,6.534) P21(-6.429,6.915) P22(-5.729,6.915) P25(-4.442,6.534) P26(-3.742,6.534) P29(-2.456,6.915) P30(-1.756,6.915) P32(-0.47,6.534) P34(0.23,6.534) P37(1.516,6.915) P38(2.216,6.915) P41(3.503,6.534) P42(4.203,6.534) P44(5.489,6.915) P46(6.189,6.915) P48(7.475,6.534) P50(8.175,6.534) R2(-15.639,6.187) R4(-14.901,6.219) R5(-14.204,6.311) R8(-12.963,6.189) R9(-12.201,6.189) R11(-11.439,6.189) R12(-10.677,6.189) R14(-9.915,6.189) R15(-9.153,6.189) R21(-6.429,6.153) R22(-5.729,6.153) R29(-2.456,6.153) R30(-1.756,6.153) R37(1.516,6.153) R38(2.216,6.153) R44(5.489,6.153) R46(6.189,6.153) R52(9.153,6.429) R53(9.915,6.429) R55(10.677,6.429) R56(11.439,6.429) R58(12.201,6.429) R59(12.963,6.429) R62(14.204,6.498) R63(14.901,6.401) R65(15.641,6.395) T3(-15.243,5.608) T5(-14.08,5.617) T17(-8.415,5.772) T18(-7.715,5.772) T20(-6.701,5.501) T21(-6.001,5.501) T23(-5.201,5.501) T25(-4.442,5.772) T26(-3.742,5.772) T28(-2.8,5.501) T29(-2.1,5.501) T31(-1.2,5.501) T32(-0.47,5.772) T34(0.23,5.772) T36(1.2,5.501) T37(1.9,5.501) T39(2.8,5.501) T41(3.503,5.772) T42(4.203,5.772) T44(5.201,5.501) T45(5.901,5.501) T47(6.801,5.501) T48(7.475,5.772) T50(8.175,5.772) T52(9.153,5.729) T53(9.915,5.729) T55(10.677,5.729) T56(11.439,5.729) T58(12.201,5.729) T59(12.963,5.729) T62(14.014,5.82) T64(15.247,5.789) U2(-15.752,5.121) U4(-14.795,5.068) U8(-12.963,5.489) U9(-12.201,5.489) U11(-11.439,5.489) U12(-10.677,5.489) U14(-9.915,5.489) U15(-9.153,5.489) U62(14.063,5.117) U63(14.752,5.286) U65(15.806,5.366) V5(-14.063,4.91) V20(-6.726,4.801) V63(14.543,4.607) V64(15.305,4.556) W3(-15.305,4.45) W4(-14.543,4.399) W7(-13.344,4.203) W8(-12.582,4.203) W10(-11.82,4.203) W11(-11.058,4.203) W13(-10.296,4.203) W14(-9.534,4.203) W16(-8.772,4.203) W17(-8.01,4.203) W19(-7.248,4.203) W48(7.248,4.442) W50(8.01,4.442) W51(8.772,4.442) W53(9.534,4.442) W54(10.296,4.442) W56(11.058,4.442) W57(11.82,4.442) W59(12.582,4.442) W60(13.344,4.442) W62(14.063,4.096) Y2(-15.806,3.64) Y4(-14.752,3.72) Y5(-14.063,3.888) Y7(-13.344,3.503) Y8(-12.582,3.503) Y10(-11.82,3.503) Y11(-11.058,3.503) Y13(-10.296,3.503) Y14(-9.534,3.503) Y16(-8.772,3.503) Y17(-8.01,3.503) Y19(-7.248,3.503) Y48(7.248,3.742) Y50(8.01,3.742) Y51(8.772,3.742) Y53(9.534,3.742) Y54(10.296,3.742) Y56(11.058,3.742) Y57(11.82,3.742) Y59(12.582,3.742) Y60(13.344,3.742) Y63(14.795,3.938) Y65(15.752,3.885)
  round 0.381 smd: AA21(-6.001,3.2) AA23(-5.201,3.2) AA25(-4.401,3.2) AA26(-3.6,3.2) AA28(-2.8,3.2) AA29(-2,3.2) AA31(-1.2,3.2) AA32(-0.4,3.2) AA34(0.4,3.2) AA36(1.2,3.2) AA38(2,3.2) AA39(2.8,3.2) AA41(3.6,3.2) AA42(4.401,3.2) AA44(5.201,3.2) AA46(6.001,3.2) AC21(-6.001,2.4) AC23(-5.201,2.4) AC25(-4.401,2.4) AC26(-3.6,2.4) AC28(-2.8,2.4) AC29(-2,2.4) AC31(-1.2,2.4) AC32(-0.4,2.4) AC34(0.4,2.4) AC36(1.2,2.4) AC38(2,2.4) AC39(2.8,2.4) AC41(3.6,2.4) AC42(4.401,2.4) AC44(5.201,2.4) AC46(6.001,2.4) AD21(-6.001,1.6) AD23(-5.201,1.6) AD25(-4.401,1.6) AD26(-3.6,1.6) AD28(-2.8,1.6) AD29(-2,1.6) AD31(-1.2,1.6) AD32(-0.4,1.6) AD34(0.4,1.6) AD36(1.2,1.6) AD38(2,1.6) AD39(2.8,1.6) AD41(3.6,1.6) AD42(4.401,1.6) AD44(5.201,1.6) AD46(6.001,1.6) AF21(-6.001,0.8) AF23(-5.201,0.8) AF25(-4.401,0.8) AF26(-3.6,0.8) AF28(-2.8,0.8) AF29(-2,0.8) AF31(-1.2,0.8) AF32(-0.4,0.8) AF34(0.4,0.8) AF36(1.2,0.8) AF38(2,0.8) AF39(2.8,0.8) AF41(3.6,0.8) AF42(4.401,0.8) AF44(5.201,0.8) AF46(6.001,0.8) AG21(-6.001,0) AG23(-5.201,0) AG25(-4.401,0) AG26(-3.6,0) AG28(-2.8,0) AG29(-2,0) AG31(-1.2,0) AG32(-0.4,0) AG34(0.4,0) AG36(1.2,0) AG38(2,0) AG39(2.8,0) AG41(3.6,0) AG42(4.401,0) AG44(5.201,0) AG46(6.001,0) AJ21(-6.001,-0.8) AJ23(-5.201,-0.8) AJ25(-4.401,-0.8) AJ26(-3.6,-0.8) AJ28(-2.8,-0.8) AJ29(-2,-0.8) AJ31(-1.2,-0.8) AJ32(-0.4,-0.8) AJ34(0.4,-0.8) AJ36(1.2,-0.8) AJ38(2,-0.8) AJ39(2.8,-0.8) AJ41(3.6,-0.8) AJ42(4.401,-0.8) AJ44(5.201,-0.8) AJ46(6.001,-0.8) AL21(-6.001,-1.6) AL23(-5.201,-1.6) AL25(-4.401,-1.6) AL26(-3.6,-1.6) AL28(-2.8,-1.6) AL29(-2,-1.6) AL31(-1.2,-1.6) AL32(-0.4,-1.6) AL34(0.4,-1.6) AL36(1.2,-1.6) AL38(2,-1.6) AL39(2.8,-1.6) AL41(3.6,-1.6) AL42(4.401,-1.6) AL44(5.201,-1.6) AL46(6.001,-1.6) AM21(-6.001,-2.4) AM23(-5.201,-2.4) AM25(-4.401,-2.4) AM26(-3.6,-2.4) AM28(-2.8,-2.4) AM29(-2,-2.4) AM31(-1.2,-2.4) AM32(-0.4,-2.4) AM34(0.4,-2.4) AM36(1.2,-2.4) AM38(2,-2.4) AM39(2.8,-2.4) AM41(3.6,-2.4) AM42(4.401,-2.4) AM44(5.201,-2.4) AM46(6.001,-2.4) AP21(-6.001,-3.2) AP23(-5.201,-3.2) AP25(-4.401,-3.2) AP26(-3.6,-3.2) AP28(-2.8,-3.2) AP29(-2,-3.2) AP31(-1.2,-3.2) AP32(-0.4,-3.2) AP34(0.4,-3.2) AP36(1.2,-3.2) AP38(2,-3.2) AP39(2.8,-3.2) AP41(3.6,-3.2) AP42(4.401,-3.2) AP44(5.201,-3.2) AP46(6.001,-3.2) AT21(-6.001,-4) AT23(-5.201,-4) AT25(-4.401,-4) AT26(-3.6,-4) AT28(-2.8,-4) AT29(-2,-4) AT31(-1.2,-4) AT32(-0.4,-4) AT34(0.4,-4) AT36(1.2,-4) AT38(2,-4) AT39(2.8,-4) AT41(3.6,-4) AT42(4.401,-4) AT44(5.201,-4) AT46(6.001,-4) AU21(-6.001,-4.801) AU23(-5.201,-4.801) AU25(-4.401,-4.801) AU26(-3.6,-4.801) AU28(-2.8,-4.801) AU29(-2,-4.801) AU31(-1.2,-4.801) AU32(-0.4,-4.801) AU34(0.4,-4.801) AU36(1.2,-4.801) AU38(2,-4.801) AU39(2.8,-4.801) AU41(3.6,-4.801) AU42(4.401,-4.801) AU44(5.201,-4.801) AU46(6.001,-4.801) V21(-6.001,4.801) V23(-5.201,4.801) V25(-4.401,4.801) V26(-3.6,4.801) V28(-2.8,4.801) V29(-2,4.801) V31(-1.2,4.801) V32(-0.4,4.801) V34(0.4,4.801) V36(1.2,4.801) V38(2,4.801) V39(2.8,4.801) V41(3.6,4.801) V42(4.401,4.801) V44(5.201,4.801) V46(6.001,4.801) W21(-6.001,4) W23(-5.201,4) W25(-4.401,4) W26(-3.6,4) W28(-2.8,4) W29(-2,4) W31(-1.2,4) W32(-0.4,4) W34(0.4,4) W36(1.2,4) W38(2,4) W39(2.8,4) W41(3.6,4) W42(4.401,4) W44(5.201,4) W46(6.001,4)
  oval 0.343x0.254 smd: AA66(16.249,3.168) AB1(-16.249,2.961) AD66(16.249,1.542) AE1(-16.249,1.335) AG66(16.249,0.104) AH1(-16.249,-0.104) AK66(16.249,-1.335) AL1(-16.249,-1.542) AN66(16.249,-2.961) AP1(-16.249,-3.168) AT66(16.249,-4.399) AU1(-16.249,-4.607) AW66(16.249,-5.838) AY1(-16.249,-6.045) BB66(16.249,-7.464) BC1(-16.249,-7.671) BE66(16.249,-8.902) BF1(-16.249,-9.109) J66(16.249,9.109) K1(-16.249,8.902) M66(16.249,7.671) N1(-16.249,7.464) R66(16.249,6.045) T1(-16.249,5.838) V66(16.249,4.607) W1(-16.249,4.399)
  oval 0.343x0.279 smd: BG1(-16.111,-9.86) BG66(16.111,-9.86) H1(-16.111,9.86) H66(16.111,9.86)
C0402
  rect 0.457x0.508 smd: 1(0.4,0) 2(-0.4,0)
C0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
C0805_H61
  rect 1.118x1.372 smd: 1(0.95,0) 2(-0.95,0)
C0805_H64
  rect 1.118x1.372 smd: 1(0.95,0) 2(-0.95,0)
C1206_H56
  rect 1.168x1.575 smd: 1(1.473,0) 2(-1.473,0)
C1206_H76
  rect 1.168x1.575 smd: 1(1.473,0) 2(-1.473,0)
CON_PWR2X2H
  round 3.048 hole 3.048 unplated: (-6.8,-2.29) (6.8,-2.29)
  rect 1.956x1.956 hole 1.448: 1(-2.1,2.75)
  round 1.956 hole 1.448: 2(2.1,2.75) 3(-2.1,-2.75) 4(2.1,-2.75)
DFN4_TH
  rect 0.508x0.356 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95)
  custom 0.57x0.57 smd: 5(1.4,-0.975)
DFN10_THXB
  rect 0.279x0.914 smd: 1(-1,-1.55) 2(-0.5,-1.55) 3(0,-1.55) 4(0.5,-1.55) 5(1,-1.55) 6(1,1.55) 7(0.5,1.55) 8(0,1.55) 9(-0.5,1.55) 10(-1,1.55)
  rect 3.251x1.753 smd: TH(0,0)
DFN10_THXE
  rect 0.279x0.914 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2,-3.1) 7(-1.5,-3.1) 8(-1,-3.1) 9(-0.5,-3.1) 10(0,-3.1)
  rect 2.667x1.753 smd: TH(-1,-1.55)
DIMM204S_1-5VXB
  round 1.651 hole 1.651 unplated: (4.1,1.75)
  round 1.168 hole 1.168 unplated: (4.1,-65.05)
  rect 2.057x0.381 smd: 1(0,0) 2(8.2,-0.3) 3(0,-0.6) 4(8.2,-0.9) 5(0,-1.2) 6(8.2,-1.5) 7(0,-1.8) 8(8.2,-2.1) 9(0,-2.4) 10(8.2,-2.7) 11(0,-3) 12(8.2,-3.3) 13(0,-3.6) 14(8.2,-3.9) 15(0,-4.2) 16(8.2,-4.5) 17(0,-4.8) 18(8.2,-5.1) 19(0,-5.4) 20(8.2,-5.7) 21(0,-6) 22(8.2,-6.3) 23(0,-6.6) 24(8.2,-6.9) 25(0,-7.2) 26(8.2,-7.5) 27(0,-7.8) 28(8.2,-8.1) 29(0,-8.4) 30(8.2,-8.7) 31(0,-9) 32(8.2,-9.3) 33(0,-9.6) 34(8.2,-9.9) 35(0,-10.2) 36(8.2,-10.5) 37(0,-10.8) 38(8.2,-11.1) 39(0,-11.4) 40(8.2,-11.7) 41(0,-12) 42(8.2,-12.3) 43(0,-12.6) 44(8.2,-12.9) 45(0,-13.2) 46(8.2,-13.5) 47(0,-13.8) 48(8.2,-14.1) 49(0,-14.4) 50(8.2,-14.7) 51(0,-15) 52(8.2,-15.3) 53(0,-15.6) 54(8.2,-15.9) 55(0,-16.2) 56(8.2,-16.5) 57(0,-16.8) 58(8.2,-17.1) 59(0,-17.4) 60(8.2,-17.7) 61(0,-18) 62(8.2,-18.3) 63(0,-18.6) 64(8.2,-18.9) 65(0,-19.2) 66(8.2,-19.5) 67(0,-19.8) 68(8.2,-20.1) 69(0,-20.4) 70(8.2,-20.7) 71(0,-21) 72(8.2,-21.3) 73(0,-24) 74(8.2,-24.3) 75(0,-24.6) 76(8.2,-24.9) 77(0,-25.2) 78(8.2,-25.5) 79(0,-25.8) 80(8.2,-26.1) 81(0,-26.4) 82(8.2,-26.7) 83(0,-27) 84(8.2,-27.3) 85(0,-27.6) 86(8.2,-27.9) 87(0,-28.2) 88(8.2,-28.5) 89(0,-28.8) 90(8.2,-29.1) 91(0,-29.4) 92(8.2,-29.7) 93(0,-30) 94(8.2,-30.3) 95(0,-30.6) 96(8.2,-30.9) 97(0,-31.2) 98(8.2,-31.5) 99(0,-31.8) 100(8.2,-32.1) 101(0,-32.4) 102(8.2,-32.7) 103(0,-33) 104(8.2,-33.3) 105(0,-33.6) 106(8.2,-33.9) 107(0,-34.2) 108(8.2,-34.5) 109(0,-34.8) 110(8.2,-35.1) 111(0,-35.4) 112(8.2,-35.7) 113(0,-36) 114(8.2,-36.3) 115(0,-36.6) 116(8.2,-36.9) 117(0,-37.2) 118(8.2,-37.5) 119(0,-37.8) 120(8.2,-38.1) 121(0,-38.4) 122(8.2,-38.7) 123(0,-39) 124(8.2,-39.3) 125(0,-39.6) 126(8.2,-39.9) 127(0,-40.2) 128(8.2,-40.5) 129(0,-40.8) 130(8.2,-41.1) 131(0,-41.4) 132(8.2,-41.7) 133(0,-42) 134(8.2,-42.3) 135(0,-42.6) 136(8.2,-42.9) 137(0,-43.2) 138(8.2,-43.5) 139(0,-43.8) 140(8.2,-44.1) 141(0,-44.4) 142(8.2,-44.7) 143(0,-45) 144(8.2,-45.3) 145(0,-45.6) 146(8.2,-45.9) 147(0,-46.2) 148(8.2,-46.5) 149(0,-46.8) 150(8.2,-47.1) 151(0,-47.4) 152(8.2,-47.7) 153(0,-48) 154(8.2,-48.3) 155(0,-48.6) 156(8.2,-48.9) 157(0,-49.2) 158(8.2,-49.5) 159(0,-49.8) 160(8.2,-50.1) 161(0,-50.4) 162(8.2,-50.7) 163(0,-51) 164(8.2,-51.3) 165(0,-51.6) 166(8.2,-51.9) 167(0,-52.2) 168(8.2,-52.5) 169(0,-52.8) 170(8.2,-53.1) 171(0,-53.4) 172(8.2,-53.7) 173(0,-54) 174(8.2,-54.3) 175(0,-54.6) 176(8.2,-54.9) 177(0,-55.2) 178(8.2,-55.5) 179(0,-55.8) 180(8.2,-56.1) 181(0,-56.4) 182(8.2,-56.7) 183(0,-57) 184(8.2,-57.3) 185(0,-57.6) 186(8.2,-57.9) 187(0,-58.2) 188(8.2,-58.5) 189(0,-58.8) 190(8.2,-59.1) 191(0,-59.4) 192(8.2,-59.7) 193(0,-60) 194(8.2,-60.3) 195(0,-60.6) 196(8.2,-60.9) 197(0,-61.2) 198(8.2,-61.5) 199(0,-61.8) 200(8.2,-62.1) 201(0,-62.4) 202(8.2,-62.7) 203(0,-63) 204(8.2,-63.3)
  rect 4.699x4.623 smd: G1(16.1,5.8) G2(16.1,-69.1)
DSUB15_3RXJ
  round 1.499 hole 1.499 unplated: (-0.5,3.984) (-0.5,-11.996)
  rect 1.143x1.143 hole 0.838: 1(0,0)
  round 1.143 hole 0.838: 2(1.5,-2.289) 3(0,-4.578) 4(1.5,-6.867) 5(0,-9.156) 6(0,1.526) 7(1.5,-0.763) 8(0,-3.052) 9(1.5,-5.341) 10(0,-7.63) 11(1.5,0.763) 12(0,-1.526) 13(1.5,-3.815) 14(0,-6.104) 15(1.5,-8.393)
  oval 1.016x3.429 hole 0.711x3.15: G1(0.3,8.489) G2(0.3,-16.501)
EC56_197_229S
  oval 1.6x3.023 smd: 1(0,2.2) 2(0,-2.2)
F1206
  rect 1.016x1.803 smd: 1(0,0) 2(2.9,0)
F1812
  rect 1.219x3.302 smd: 1(-2,0) 2(2,0)
GND_C10D4B10_OB5XC5B
  round 4.013 hole 4.013 unplated: (0,0)
  round 0.762 hole 0.559: 2(0,3.5) 3(-2.5,2.5) 4(-3.5,0) 5(-2.5,-2.5) 6(0,-3.5) 7(2.5,-2.5) 8(3.5,0) 9(2.5,2.5)
GOLD_PCI-E_X16
  rect 0.762x3.2 smd: A1(-41.5,0.5) B17(-23.5,0.5) B31(-9.5,0.5) B48(7.5,0.5) B81(40.5,0.5)
  rect 0.762x4.216 smd: A2(-40.5,0) A3(-39.5,0) A4(-38.5,0) A5(-37.5,0) A6(-36.5,0) A7(-35.5,0) A8(-34.5,0) A9(-33.5,0) A10(-32.5,0) A11(-31.5,0) A12(-28.5,0) A13(-27.5,0) A14(-26.5,0) A15(-25.5,0) A16(-24.5,0) A17(-23.5,0) A18(-22.5,0) A19(-21.5,0) A20(-20.5,0) A21(-19.5,0) A22(-18.5,0) A23(-17.5,0) A24(-16.5,0) A25(-15.5,0) A26(-14.5,0) A27(-13.5,0) A28(-12.5,0) A29(-11.5,0) A30(-10.5,0) A31(-9.5,0) A32(-8.5,0) A33(-7.5,0) A34(-6.5,0) A35(-5.5,0) A36(-4.5,0) A37(-3.5,0) A38(-2.5,0) A39(-1.5,0) A40(-0.5,0) A41(0.5,0) A42(1.5,0) A43(2.5,0) A44(3.5,0) A45(4.5,0) A46(5.5,0) A47(6.5,0) A48(7.5,0) A49(8.5,0) A50(9.5,0) A51(10.5,0) A52(11.5,0) A53(12.5,0) A54(13.5,0) A55(14.5,0) A56(15.5,0) A57(16.5,0) A58(17.5,0) A59(18.5,0) A60(19.5,0) A61(20.5,0) A62(21.5,0) A63(22.5,0) A64(23.5,0) A65(24.5,0) A66(25.5,0) A67(26.5,0) A68(27.5,0) A69(28.5,0) A70(29.5,0) A71(30.5,0) A72(31.5,0) A73(32.5,0) A74(33.5,0) A75(34.5,0) A76(35.5,0) A77(36.5,0) A78(37.5,0) A79(38.5,0) A80(39.5,0) A81(40.5,0) A82(41.5,0) B1(-41.5,0) B2(-40.5,0) B3(-39.5,0) B4(-38.5,0) B5(-37.5,0) B6(-36.5,0) B7(-35.5,0) B8(-34.5,0) B9(-33.5,0) B10(-32.5,0) B11(-31.5,0) B12(-28.5,0) B13(-27.5,0) B14(-26.5,0) B15(-25.5,0) B16(-24.5,0) B18(-22.5,0) B19(-21.5,0) B20(-20.5,0) B21(-19.5,0) B22(-18.5,0) B23(-17.5,0) B24(-16.5,0) B25(-15.5,0) B26(-14.5,0) B27(-13.5,0) B28(-12.5,0) B29(-11.5,0) B30(-10.5,0) B32(-8.5,0) B33(-7.5,0) B34(-6.5,0) B35(-5.5,0) B36(-4.5,0) B37(-3.5,0) B38(-2.5,0) B39(-1.5,0) B40(-0.5,0) B41(0.5,0) B42(1.5,0) B43(2.5,0) B44(3.5,0) B45(4.5,0) B46(5.5,0) B47(6.5,0) B49(8.5,0) B50(9.5,0) B51(10.5,0) B52(11.5,0) B53(12.5,0) B54(13.5,0) B55(14.5,0) B56(15.5,0) B57(16.5,0) B58(17.5,0) B59(18.5,0) B60(19.5,0) B61(20.5,0) B62(21.5,0) B63(22.5,0) B64(23.5,0) B65(24.5,0) B66(25.5,0) B67(26.5,0) B68(27.5,0) B69(28.5,0) B70(29.5,0) B71(30.5,0) B72(31.5,0) B73(32.5,0) B74(33.5,0) B75(34.5,0) B76(35.5,0) B77(36.5,0) B78(37.5,0) B79(38.5,0) B80(39.5,0) B82(41.5,0)
