# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PD_CPU_NODE1_HVMGEAR_SEL: length 26
  TOP w0.102: U2.AD52 79.19,77.55 79.22,77.52 v1(79.22,76.99)
  BOTTOM w0.102: R159.1 103.05,74.7 R162.2 100.9,75.01 100.82,75.01 100.82,75.03 100.71,75.13 100.11,75.13 99.99,75.01 v2(99.09,75.01) 98.77,74.69 96.2,74.69 95.97,74.47 91.79,74.47 91.25,75.01 90.2,75.01 89.81,75.4 86.99,75.4 86.32,76.07 80.19,76.07 79.28,76.99 v1(79.22,76.99)
PD_CPU_NODE1_MEM_SPEED1: length 25.5
  TOP w0.102: U2.AD53 79.95,77.55 79.83,77.44 v1(79.83,77.03)
  BOTTOM w0.102: v1(79.83,77.03) 79.83,76.83 80.35,76.32 86.36,76.32 87.07,75.61 90.12,75.61 90.45,75.27 91.78,75.27 v2(92.05,75) 97.68,75 98.4,75.72 R167.2 100.48,75.72 100.91,76.15 101.05,76.15 101.08,76.17 102.56,76.17 102.96,75.77 R164.1
PD_CPU_NODE1_NODE_ID: length 11.4
  TOP w0.102: R157.1 R160.1 87.51,93.43 v3(86.61,92.53) 85.38,91.3 82.63,91.3 81.05,89.72 81.05,88.06 80.76,87.76 U2.D55
PD_CPU_NODE1_PUNIT_ST_ADDR0: length 29.1
  TOP w0.114: U2.AG48 77.28,76.67 77.42,76.81 v1(77.42,77.1)
  BOTTOM w0.102: v1(77.42,77.1) 77.42,76.87 78.31,75.98 79.71,75.98 80.03,75.67 86.15,75.67 86.82,75 89.3,75 89.79,74.5 90.25,74.5 v2(90.61,74.15) 91.51,73.25 98.94,73.25 99.32,72.86 101.02,72.86 101.21,72.67 R168.2 103.05,72.16 R165.1
PD_CPU_NODE1_PUNIT_ST_ADDR1: length 29.1
  TOP w0.114: U2.AH48 77.28,75.56 v1(77.66,75.18)
  BOTTOM w0.102: R172.1 103.05,71.15 R174.2 100.6,70.54 99.9,70.54 v2(99.21,71.23) 98.43,72.01 91.14,72.01 89.47,73.68 86.61,73.68 85.92,74.36 81.33,74.36 80.51,73.54 80.18,73.54 79.79,73.93 78.56,73.93 77.66,74.82 v1(77.66,75.18)
PD_CPU_NODE1_RP1_PERN: length 20.9
  TOP w0.102: U2.AL4 55.13,74.06 55.64,74.57 55.64,75.55 U2.AH4 ; R46.1 49.93,72.39 v1(50.83,73.28) 50.83,73.29 52.67,73.29 52.76,73.38 53.56,73.38 53.95,72.98 U2.AN2
  TOP w0.114: U2.AH4 55.22,75.42 54.56,75.42 54.37,75.61 54.37,76.32 U2.AF2 54.1,76.42 53.78,76.1 U2.AH1 ; U2.AL4 55.13,73.61 55.49,73.25 55.49,72.95 55.62,72.83 55.62,72.28 55.67,72.23 55.97,71.93 U2.AT5 55.8,71.53 55.34,71.53 55.13,71.32 55.13,70.83 54.4,70.11 54,70.11 53.78,70.33 U2.AU1 53.78,71.56 54.14,71.91 U2.AR2 54.81,71.91 55.15,72.25 55.15,72.51 54.68,72.98 U2.AN2
PD_CPU_NODE1_RP1_PERP: length 16.9
  TOP w0.102: U2.AG5 55.81,76.36 U2.AF4 55.24,76.07 54.91,75.75 U2.AH3 54.66,75.82 54.66,76.58 54.48,76.75 54.05,76.75 52.19,74.9 52.19,73.83 ; U2.AV2 54.23,70.74 U2.AU3 55.24,71.75 U2.AR4 55.38,72 55.38,72.77 U2.AN4 54.39,73.75 U2.AL2 54.15,73.66 52.35,73.66 52.19,73.83 ; R45.1 50.1,73.4 50.52,73.82 v1(52.18,73.82) 52.19,73.83
PD_CPU_NODE1_RP2_PERN: length 16.9
  TOP w0.102: U2.AD5 55.53,77.61 55.44,77.52 U2.AD4 U2.AB4 55.45,78.4 55.72,78.67 56.15,78.67 56.33,78.85 56.33,79.13 56.1,79.36 55.85,79.36 55.6,79.61 55.6,80.09 U2.W4 55.48,80.2 55.12,80.56 54.64,80.56 U2.U2 ; U2.U2 54.28,81.09 54.21,81.16 54.21,81.8 U2.R2 54.39,82.91 ; U2.U2 53.66,80.92 53.59,80.99 52.24,80.99 52.05,81.18 51.62,81.18 50.62,82.18 v1(49.14,82.18) R44.1 ; 54.39,82.91 U2.N2 ; 54.39,82.91 54.48,82.83 54.77,82.54 55.4,82.54 U2.R5
PD_CPU_NODE1_RP2_PERP: length 21.4
  TOP w0.102: R43.1 48.41,78.88 48.61,79.08 v1(49.05,79.08) 49.19,79.22 51.8,79.22 52.61,78.41 U2.AB2 54.39,78.41 U2.AD2 54.65,77.48 54.94,77.19 55.3,77.19 55.35,77.24 55.97,77.24 56.17,77.44 56.17,77.73 55.83,78.07 U2.AB5 56.25,78.31 56.4,78.15 56.72,78.15 56.86,78.29 56.92,78.29 57.16,78.53 57.16,78.87 57.11,78.93 57.11,80.15 56.86,80.41 56.27,80.41 U2.V5 55.81,80.87 U2.U4 54.84,80.87 54.46,81.25 54.46,81.52 54.73,81.8 54.91,81.8 U2.R4 55.39,82.02 55.65,81.76 56.06,81.76 56.32,82.02 56.32,82.43 55.95,82.81 U2.N5 55.73,82.91 U2.N4
PD_CPU_NODE1_SPD_EN_L: length 28.1
  TOP w0.114: v1(78.03,77.17) 78.03,77.17 77.66,77.53 U2.AD49
  BOTTOM w0.102: R158.1 103.05,73.69 R161.2 100.78,73.25 99.29,73.25 98.18,74.37 96.69,74.37 v2(96.33,74.01) 91.51,74.01 90.76,74.76 89.98,74.76 89.54,75.2 86.91,75.2 86.24,75.87 80.11,75.87 79.8,76.18 78.41,76.18 78.03,76.57 v1(78.03,77.17)
PD_CPU_NODE1_W1: length 6.1
  TOP w0.102: U2.W1 53.37,80.2 53.27,80.1 52.32,80.1 52.28,80.15 51.46,80.15 50.8,80.81 v1(50.37,80.81) 50.13,81.04 R41.1
PD_CPU_NODE1_Y2: length 6.8
  TOP w0.102: U2.Y2 52.63,79.44 52.17,79.89 49.59,79.89 v1(49.01,80.48) 48.43,79.89 R40.1
PD_NODE1_DM0: length 6
  TOP w0.102: R212.2 v1(51.77,19.02) 54.5,19.02 55.38,19.9 J2.11
PD_NODE1_DM1: length 5.2
  TOP w0.102: J2.28 60.48,27.28 59.84,26.63 v1(59.84,26.56)
  BOTTOM w0.102: v1(59.84,26.56) 60.29,27.02 R211.2
PD_NODE1_DM2: length 3.4
  TOP w0.102: J2.44 65.28,30.56 65.53,30.8 v1(65.53,30.8)
  BOTTOM w0.102: v1(65.53,30.8) 65.63,30.71 R210.2
PD_NODE1_DM3: length 3.3
  TOP w0.102: J2.59 69.78,22.54 69.62,22.7 v1(69.59,22.7)
  BOTTOM w0.102: v1(69.59,22.7) 69.12,22.23 R209.2
PD_NODE1_DM4: length 7.5
  TOP w0.102: J2.140 96.48,30.2 97.11,30.83 97.11,31.72 96.25,32.57 v1(96.25,32.69)
  BOTTOM w0.102: v1(96.25,32.69) 97.33,31.62 R208.2
PD_NODE1_DM5: length 3.3
  TOP w0.102: R207.2 v1(101.59,18.87) 101.58,18.87 J2.157
PD_NODE1_DM6: length 6
  TOP w0.102: J2.172 106.08,30.5 107.36,31.77 108.05,31.77 108.09,31.73 v1(108.09,31.73)
  BOTTOM w0.102: v1(108.09,31.73) 108.46,31.35 108.46,30.22 R206.2
PD_NODE1_DM7: length 3.3
  TOP w0.102: R205.2 111.15,19.21 v1(111.18,19.25) J2.189
PD_NODE1_DM8: length 9
  TOP w0.102: v1(77.09,25.23) 75.64,26.68 75.64,27.44 75.93,27.73 77.13,27.73 77.28,27.89 J2.76
  BOTTOM w0.102: v1(77.09,25.23) 77.63,25.77 R204.2
PD_NODE1_NTB_CLKINN: length 3.7
  TOP w0.114: v1(60.86,85.68) 60.77,85.77 60.34,85.77 U2.H14
  BOTTOM w0.102: v1(60.86,85.68) 60.86,85.68 61.26,85.68 61.7,86.12 v2(61.7,86.6) 61.36,86.94 R99.1
PD_NODE1_NTB_CLKINP: length 4.3
  TOP w0.114: U2.J14 60.55,85 v1(60.81,84.74)
  BOTTOM w0.102: R97.1 60.31,87.36 60.1,87.15 60.1,85.75 60.81,85.04 v1(60.81,84.74)
PD_NODE1_NTB_PERN: length 41.2
  TOP w0.102: U2.B21 62.71,88.44 U2.B19 62.45,88.7 62.24,88.7 62.05,88.88 61.23,88.88 61.05,88.7 60.94,88.7 60.6,88.36 60.6,87.61 60.86,87.34 U2.D15 61.18,87.59 U2.D17 ; U2.B21 63.64,88.18 64.11,87.71 64.44,87.71 64.61,87.88 64.69,87.88 65.31,88.5 66.09,88.5 U2.B26 66.15,87.65 U2.D26 66.1,87.53 65.43,86.86 U2.E23 64.81,86.86 64.52,87.15 63.68,87.15 U2.E21 ; U2.B21 62.98,89.1 62.98,90.47 62.51,90.95 59.36,90.95 59.08,90.67 59.08,89.45 59.14,89.4 U2.B12 ; U2.B12 58.76,88.81 58.11,88.81 57.87,88.58 57.87,88.3 58.24,87.94 U2.D10 57.78,87.24 57.27,87.24 57.24,87.21 56.96,87.21 56.93,87.24 56.8,87.24 56.56,87.01 56.22,87.01 U2.F5 ; U2.B12 59.13,88.43 U2.D12 ; U2.H10 57.65,86.08 U2.G9 57.26,86.53 56.2,86.53 56.11,86.61 U2.F5 ; U2.F5 55.83,86.44 54.94,85.55 54.94,84.96 U2.K3 54.73,84.44 U2.L2 53.99,84.18 51.88,84.18 50.64,85.42 v1(50.26,85.42) 49.18,84.34 R108.1
PD_NODE1_NTB_PERP: length 31.7
  TOP w0.102: U2.E10 U2.E12 59.04,87 59.58,86.46 60.35,86.46 60.68,86.13 61.05,86.13 61.4,86.47 62.31,86.47 U2.E19 ; U2.E10 58.33,86.86 58.8,86.39 58.92,86.39 59.28,86.03 59.28,85.55 U2.K10 57.96,84.62 57.65,84.93 U2.H9 ; U2.E10 58.33,87.29 58.62,87.57 58.62,88.03 U2.B10 ; U2.E19 62.74,87.1 U2.D19 62.74,87.91 62.25,88.4 61.79,88.4 U2.B17 61.42,88.55 U2.C15 ; U2.E19 63.53,87.7 U2.D21 63.91,87.42 64.62,87.42 U2.D23 64.96,87.34 U2.D24 65.48,87.39 U2.C24 ; U2.H9 57.65,85.56 56.91,86.3 56.33,86.3 U2.G5 ; U2.H9 57.18,85.38 56.5,84.7 U2.K4 55.49,84.23 U2.L4 54.81,84.02 54.4,83.61 54.09,83.61 53.84,83.86 v1(50.44,83.86) 49.88,83.29 R107.1
PD_NODE1_NTB_RCOMP: length 5.8
  TOP w0.381: U2.AA23 v1(65.23,79.4)
  BOTTOM w0.381: v1(65.23,79.4) 65.23,80.3 64.78,80.75 62.73,80.75 v2(62.53,80.96) 62.04,81.44 R102.1
PE_SW_BMC_PERST_L: length 83.5
  TOP w0.102: R281.2 136.07,137.38 v1(136.48,137.38) U125.96
  IN2 w0.114: v1(136.48,137.38) 133.53,137.38 129.61,141.29 129.61,141.99 128.33,143.27 127.63,143.27 125.79,145.12 109.7,145.12 106.85,142.27 106.54,142.27 102.17,137.91 102.17,133.83 100.56,132.22 100.56,130.85 99.79,130.08 99.79,121.89 98.74,120.84 97,120.84 94.37,118.21 87.26,118.21 87.19,118.13 84.85,118.13 83.79,119.19 83.04,119.19 82.75,118.9 82.75,118.2 v1(82.9,118.06)
  BOTTOM w0.102: R272.1 83.75,118.38 83.43,118.06 v1(82.9,118.06)
PE_SW_USB_PERST_L: length 74.8
  TOP w0.102: v1(167.26,106.15) 167.26,105.9 167.58,105.58 R273.1 ; U125.97 139.37,135.29 138.49,134.41 138.49,134.08 138.99,133.58 R280.2 139.55,134.17 v1(139.37,134.35)
  IN1 w0.114: v1(176.23,130.29) 176.23,129.06 176.78,128.5 176.78,128.14 176.47,127.82 176.47,125.27 176.65,125.08 176.65,121.42 177.04,121.03 177.04,120.67 176.43,120.05 176.43,118.21 176.71,117.93 176.71,117.57 176.07,116.92 176.07,114.39 171.4,109.72 168.87,109.72 166.8,107.65 166.8,106.61 v1(167.26,106.15)
  IN2 w0.114: v1(139.37,134.35) 139.69,134.03 142.05,134.03 143.47,132.61 160.99,132.61 161.27,132.33 172.73,132.33 173.02,132.04 173.65,132.04 174.88,130.81 175.72,130.81 v1(176.23,130.29)
PECIVDD: length 12.3
  TOP w0.102: v1(68.87,121.07) 69.14,121.34 69.14,122.7 71.51,125.07 71.51,125.35 72.17,126.01 72.17,128.46 U14.V19
  BOTTOM w0.102: v1(68.87,121.07) 69.2,120.74 69.51,120.74 70.15,120.1 v2(70.15,118.82)
PLT_RST_LAN1_N: length 4
  TOP w0.102: R560.2 62.45,149.58 62.23,149.79 v1(62,149.79) 61.39,149.79 61.15,150.03 U35.17
PLT_RST_LAN2_N: length 4.5
  TOP w0.102: U37.17 168.5,157.51 167.37,158.64 v1(167.37,159.99) 167.29,160.08 R590.2
PMBUS1_EN: length 7.4
  TOP w0.102: U116.G 139.61,158.29 v1(139.56,158.24) 139.56,156.69 139.23,156.35 R1282.2 137.89,155.85 137.7,155.66 U117.G
PMBUS2_EN: length 15.3
  TOP w0.102: v1(125.22,159.78) R1283.2 123.95,159.38 U126.G ; U118.G v1(135.94,158.6)
  IN1 w0.114: v1(125.22,159.78) 131.44,159.78 132.18,159.03 135.52,159.03 v1(135.94,158.6)
PMBUS3_EN: length 5.9
  TOP w0.102: U139.G 143.15,159.76 143.15,156.99 v1(143.84,156.31) R1284.2 144.69,156.48 U127.G
PORT80_LOUT0: length 6.9
  TOP w0.102: U115.2 94.88,123.14 94.66,123.36 94.66,125.56 v1(95.02,125.92) 94.96,125.99 94.96,128.34 R1260.1
PORT80_LOUT1: length 4.4
  TOP w0.102: U115.48 97.4,125.85 95.77,127.48 v1(95.77,127.52) 95.77,127.88 R1253.1
PORT80_LOUT2: length 3.9
  TOP w0.102: v1(97.16,127.71) 97.16,127.71 ; 97.16,127.71 97.16,127.57 97.16,127.57 97.9,126.83 U115.47 ; 97.16,127.71 97.16,128.13 R1254.1
PORT80_LOUT3: length 3.6
  TOP w0.102: R1255.1 98.78,128.11 v1(98.62,127.95) 98.62,126.5 98.4,126.28 U115.46
PORT80_LOUT4: length 3.8
  TOP w0.102: U115.45 98.9,126.12 v1(99.26,126.48) 99.92,127.14 R1256.1
PORT80_LOUT5: length 4
  TOP w0.102: R1258.1 107.26,118.64 107.33,118.57 v1(107.33,117.85) 106.99,117.85 106.2,118.64 U115.26
PORT80_LOUT6: length 3.1
  TOP w0.102: R1257.1 102.62,114.17 v1(102.09,114.7) 101.9,114.89 U115.22
PORT80_LOUT7: length 4.1
  TOP w0.102: U115.44 99.4,125.85 99.73,126.18 99.73,126.36 100.32,126.95 100.32,127.07 v1(100.65,127.4) 101.06,127.82 R1259.1
POWER_SW1_PWR_CTR_12V: length 99.4
  TOP w0.381: Q44.3 114.42,162.94 v1(114.64,163.16) 115.02,162.78 R1003.2
  IN3 w0.254: v1(192.25,187.15) 191.53,187.15 189.63,189.05 186.45,189.05 181.55,184.15 181.55,179.27 176.75,174.47 176.75,174.07 172,169.32 169.92,169.32 168.12,167.51 167.23,167.51 162.2,162.48 156.94,162.48 156.71,162.71 153.05,162.71 152.82,162.48 143.46,162.48 142.62,161.65 139.39,161.65 138.73,160.99 138.73,160.68 138.45,160.4 137.74,160.4 135.65,162.48 133.39,162.48 132.43,163.45 130.07,163.45 129.43,162.81 127.2,162.81 126.69,163.32 124.23,163.32 123.27,162.36 119.88,162.36 118.48,163.75 115.23,163.75 v1(114.64,163.16)
POWER_SW1_PWR_CTR_12V_R: length 31.4
  TOP w0.381: 194.79,189.74 194.79,190.53 194.18,191.13 192.4,191.13 189.78,193.75 189.78,195.58 188.64,196.72 v1(187.22,196.72)
  BOTTOM w0.381: J18.A11 189.05,205.2 189.05,198.55 v1(187.22,196.72) 187.55,196.72 192.25,192.02 C592.1
POWER_SW1_PWR_CTR_N: length 25.7
  TOP w0.102: v1(104.32,165.23) 103.56,164.47 103.45,164.47 102.66,163.69 R801.1 103,163.62 103.8,162.81 U104.G
  IN3 w0.114: v1(111.58,176.97) 112.18,176.37 112.18,173.46 112.01,173.3 112.01,172.77 111.19,171.94 111.19,171.36 106.88,167.05 106.88,166.34 106.18,165.64 105.25,165.64 105.06,165.46 104.55,165.46 v1(104.32,165.23)
  BOTTOM w0.102: v1(111.58,176.97) 111.58,177.71 112.71,178.84 U65.15
POWER_SW2_PWR_CTR_12V: length 90.1
  TOP w0.254: 129.46,152.17 132.07,152.17
  TOP w0.381: R1004.2 121.61,149.45 Q45.3 122.54,150.8 123.17,151.42 128.71,151.42 129.46,152.17 ; 132.07,152.17 132.25,152.35 134.18,152.35 134.33,152.2 135.37,152.2 135.81,152.63 135.81,153.13 136.64,153.97 v1(136.64,154.47)
  IN3 w0.381: v1(195.19,175.11) 195.19,169.04 191.36,165.2 178.91,165.2 178.4,165.71 176.27,165.71 175.94,165.38 170.56,165.38 166.93,161.76 163.68,161.76 162.65,160.73 157.98,160.73 153.97,156.72 148.79,156.72 148.42,157.09 145.85,157.09 143.99,155.22 143.2,155.22 141.93,153.95 137.16,153.95 v1(136.64,154.47)
POWER_SW2_PWR_CTR_12V_R: length 52.9
  TOP w0.381: 198.21,175.87 198.95,176.61 198.95,191.59 197.6,192.94 193.72,192.94 191.94,194.72 191.94,196.24 191.08,197.1 v1(189.73,197.1)
  IN1 w0.381: v1(189.73,197.1) 189.73,193.14 197.66,185.22 v1(197.66,185.01)
  BOTTOM w0.381: J18.A10 190.05,203.02 189.74,202.72 189.73,202.72 v1(189.73,197.1) ; v1(197.66,185.01) 197.33,185.34 C594.1
POWER_SW2_PWR_CTR_N: length 48.1
  TOP w0.102: v1(125.94,158.99) 125.86,158.91 U107.G
  BOTTOM w0.102: U65.16 116.28,178.19 116.68,178.59 118.16,178.59 R803.1 119.45,177.97 120,177.41 120.09,177.41 120.98,176.52 120.98,174.87 120.29,174.18 120.29,171.57 123.42,168.44 125.83,168.44 128.19,170.8 131.92,170.8 134.26,168.46 134.36,168.36 134.36,167.34 135.27,166.43 135.27,163.06 130.46,158.25 126.68,158.25 v1(125.94,158.99)
POWER_SW3_PWR_CTR_12V: length 90.7
  TOP w0.381: v1(136.44,152.45) 136.43,152.45 136.42,152.44 136.42,151.78 136.16,151.53 136.16,151.23 135.58,150.65 135.2,150.65 134.44,149.89 134.44,148.72 133.39,147.68 Q46.3 132.58,147.75 R1038.2
  IN3 w0.381: v1(197.76,181.91) 198.77,180.9 198.77,171.12 191.92,164.26 176.09,164.26 175.56,163.73 169.79,163.73 166.92,160.86 163.9,160.86 162.31,159.27 161.27,159.27 156.98,154.98 146.82,154.98 145.86,154.03 144.16,154.03 143.05,152.91 142.33,152.91 141.98,153.26 137.25,153.26 v1(136.44,152.45)
POWER_SW3_PWR_CTR_12V_R: length 41.1
  TOP w0.381: v1(190.85,195.78) 190.85,194.01 192.83,192.02 196.94,192.02 198.29,190.68 198.29,186.18 197.88,185.78 195.42,185.78 194.99,185.34 194.99,182.55
  IN1 w0.381: v1(197.33,189.56) 197.07,189.56 v1(190.85,195.78)
  BOTTOM w0.381: J18.A9 191.05,202.54 190.47,201.96 190.47,196.16 v1(190.85,195.78) ; C596.1 v1(197.33,189.56)
POWER_SW3_PWR_CTR_N: length 52.4
  TOP w0.102: U110.G 129.36,158.54 v1(128.79,159.11)
  IN3 w0.114: v1(113.28,178.16) 113.28,182.84 v1(113.82,183.38)
  BOTTOM w0.102: v1(128.79,159.11) 129.55,159.11 132.65,162.22 133.84,162.22 135.01,163.39 135.01,166.31 134.11,167.21 134.11,168.25 131.82,170.54 128.43,170.54 125.31,167.42 124.08,167.42 120.03,171.46 120.03,174.3 120.46,174.72 120.46,175.08 119.68,175.86 119.25,175.86 119.24,175.84 118.85,175.84 118.14,176.56 117.09,176.56 116.1,177.54 U65.17 113.9,177.54 v1(113.28,178.16) ; v1(113.82,183.38) 113.82,183.16 113.49,182.84 R1060.1
PSU1_AC_OK: length 10.8
  TOP w0.102: C600.1 64.85,182.82 65.12,183.09 v1(65.12,183.48) 64.85,183.75 R831.2
  IN1 w0.114: v1(65.12,183.48) 65.33,183.27 65.33,182.48 65.98,181.82 65.98,180.82 v1(68.86,177.94)
  BOTTOM w0.102: U63.4 v1(68.86,177.94)
PSU1_AC_OK_R: length 21.4
  TOP w0.102: R831.1 64.85,186.21 65.36,186.72 65.36,187.99 64.85,188.5 R845.1 64.85,190.31 63.35,191.81 v1(63.35,199.37) 62.97,199.37 62.05,200.29 J35.B45
PSU1_DC_OK: length 7.6
  TOP w0.102: U84.4 76.55,173.1 76.29,173.36 v1(74.21,173.36)
  BOTTOM w0.102: v1(74.21,173.36) 74.21,173.36 73.53,174.04 U63.10
PSU1_DC_OK_R: length 21.3
  BOTTOM w0.102: J35.A45 62.05,200.22 62.59,199.68 62.59,196.48 v2(62.97,196.1) 63.59,195.48 63.59,191.51 64.85,190.25 R853.1 64.18,187.86 64.18,186.87 64.85,186.2 R832.1
PSU1_DC_OK_R_BUF: length 24.2
  TOP w0.102: v1(78.25,181.1) 78.82,180.52 U94.G 78.82,176.47 77.5,175.15 U84.2
  IN2 w0.114: v1(65.85,183.86) 66.34,183.86 67.64,182.56 68,182.56 68.23,182.33 75.13,182.33 76.07,181.39 77.96,181.39 v1(78.25,181.1)
  BOTTOM w0.102: R832.2 64.85,184.6 65.58,183.86 v1(65.85,183.86) 65.85,183.18 65.06,182.39 C601.1
PSU1_HUB_EN: length 7.2
  TOP w0.102: U60.5 127.75,170.02 128,169.77 128,168.61 v1(128.15,168.47) 128.15,167.29 127.76,166.91 U61.1
  BOTTOM w0.102: v1(128.15,168.47) 127.15,167.47 R1243.2
PSU2_AC_OK: length 12.2
  TOP w0.102: R833.2 63.71,184.24 63.75,184.19 v1(63.75,183.46) 63.75,182.97 63.71,182.93 C602.1
  IN1 w0.114: v1(68.25,177.29) 68.25,177.57 64.94,180.88 64.94,182.28 v1(63.75,183.46)
  BOTTOM w0.102: U63.5 v1(68.25,177.29)
PSU2_AC_OK_R: length 21.1
  TOP w0.102: J35.B46 61.05,199.75 62.26,198.54 62.26,194.55 v1(62.77,194.04) 62.77,191.4 63.71,190.47 R848.1 63.71,188.5 64.21,187.99 64.21,186.72 63.71,186.21 R833.1
PSU2_DC_OK: length 3.4
  TOP w0.102: v1(72.3,172.62) 72.62,172.3 U88.4
  BOTTOM w0.102: v1(72.3,172.62) 71.72,172.62 70.95,173.39 U63.11
PSU2_DC_OK_R: length 21.2
  BOTTOM w0.102: J35.A46 61.05,200.46 62.04,199.46 v2(62.04,197.91) 62.04,192.11 63.71,190.45 R854.1 63.06,187.88 63.06,186.86 63.71,186.21 R834.1
PSU2_DC_OK_R_BUF: length 21.6
  TOP w0.102: v1(73.67,180.93) 73.67,180.92 74.5,180.09 75.3,180.09 U97.G 75.14,177.07 74.07,176 U88.2
  IN2 w0.114: v1(64.33,183.99) 64.33,183.65 65.85,182.13 68.05,182.13 68.14,182.04 72.57,182.04 v1(73.67,180.93)
  BOTTOM w0.102: R834.2 63.71,184.74 64.33,184.12 v1(64.33,183.99) 64.33,183.08 63.71,182.46 C603.1
PSU2_HUB_EN: length 10.8
  TOP w0.102: U60.9 131.75,168.07 131.61,168.22 131.61,168.8 130.98,169.43 v1(130.65,169.43) 129.58,169.43 128.58,168.43 128.58,167.1 127.73,166.26 U61.2
  BOTTOM w0.102: R1244.2 132.19,168.56 131.31,169.43 v1(130.65,169.43)
PSU3_AC_OK: length 13.6
  TOP w0.102: C605.1 62.56,183.38 v1(62.47,183.48) 62.47,184.11 62.56,184.21 R836.2
  IN1 w0.114: v1(68.85,176.64) 67.9,176.64 64.65,179.89 64.65,181.29 v1(62.47,183.48)
  BOTTOM w0.102: U63.6 v1(68.85,176.64)
PSU3_AC_OK_R: length 21.1
  TOP w0.102: R836.1 62.56,186.21 63.07,186.72 63.07,187.99 62.56,188.5 R849.1 62.56,189.54 61.81,190.29 61.81,194.85 61.04,195.61 v1(61.04,195.84) 61.04,198.33 60.05,199.32 J35.B47
PSU3_DC_OK: length 8.3
  TOP w0.102: v1(67.47,171.31) 67.47,172.78 67.86,173.17 69.37,173.17 69.69,172.85 U86.4
  BOTTOM w0.102: v1(67.47,171.31) 67.37,171.31 65.93,172.74 U63.13
PSU3_DC_OK_R: length 21.2
  BOTTOM w0.102: R837.1 62.56,186.21 61.88,186.9 61.88,187.84 R855.1 62.56,190.18 61.58,191.16 61.58,196.92 61.04,197.46 61.04,199.11 v2(60.57,199.58) 60.05,200.1 J35.A47
PSU3_DC_OK_R_BUF: length 20.9
  TOP w0.102: v1(71.71,181.37) 71.45,181.11 U95.G 71.45,177.75 71.89,177.32 71.89,176.76 70.64,175.51 U86.2
  IN2 w0.114: v1(71.71,181.37) 70.27,181.37 69.92,181.72 68.09,181.72 67.27,180.9 66.91,180.9 66.04,181.77 64.82,181.77 63.04,183.55 v1(63.04,183.94)
  BOTTOM w0.102: C606.1 62.56,182.51 63.04,182.98 v1(63.04,183.94) 63.04,184.18 62.56,184.66 R837.2
PSU3_HUB_EN: length 12
  TOP w0.102: U60.12 132.62,170.04 129.03,170.04 v1(129.02,170.03) ; v1(129.38,166.24) 129.38,165.7 127.99,164.31 U61.5
  BOTTOM w0.102: v1(129.02,170.03) 129.02,168.15 128.6,167.73 R1245.2 129.02,166.42 129.19,166.24 v1(129.38,166.24)
PSU4_AC_OK: length 15.3
  TOP w0.102: R839.2 61.42,184.3 61.2,184.08 v1(61.2,183.47) 61.2,183.21 61.42,182.99 C608.1
  IN1 w0.114: v1(61.2,183.47) 61.43,183.47 63.78,181.12 63.78,179.73 67.51,175.99 v1(68.06,175.99)
  BOTTOM w0.102: U63.7 v1(68.06,175.99)
PSU4_AC_OK_R: length 20.5
  TOP w0.102: J35.B48 59.05,199.59 60.23,198.41 v1(60.23,197.63) 60.29,197.58 60.29,195.29 61.42,194.15 R850.1 61.42,188.5 61.93,187.99 61.93,186.59 61.42,186.09 R839.1
PSU4_DC_OK: length 7.7
  TOP w0.102: U89.4 66.23,170.78 v1(65.77,170.33)
  BOTTOM w0.102: v1(65.77,170.33) 65.77,171.31 65.09,171.99 63.91,171.99 63.41,172.49 63.41,173.15 63.66,173.39 U63.14
PSU4_DC_OK_R: length 21.1
  BOTTOM w0.102: J35.A48 59.05,200.35 59.73,199.67 59.73,195.78 v2(59.68,195.73) 60.03,195.38 60.03,191.29 61.42,189.91 R856.1 60.82,187.92 60.82,186.69 61.42,186.09 R840.1
PSU4_DC_OK_R_BUF: length 19.4
  TOP w0.102: U89.2 67.18,176.15 67.77,176.74 U98.G 67.77,180.45 v1(68.6,181.28)
  IN1 w0.114: v1(68.6,181.28) 68.57,181.25 67.1,181.25 66.83,181.52 66.83,183.37 66.67,183.54 66.67,183.67 65.91,184.43 62.38,184.43 v1(61.84,183.88)
  BOTTOM w0.102: C609.1 61.42,182.56 61.84,182.97 v1(61.84,183.88) 61.84,184.13 61.42,184.54 R840.2
PSU5_AC_OK: length 16.8
  TOP w0.102: C611.1 60.28,182.83 59.93,183.18 v1(59.93,183.48) 59.93,184.02 60.28,184.37 R842.2
  IN1 w0.114: v1(68.94,175.34) 67.64,175.34 63.53,179.45 62.78,179.45 61.41,180.82 61.41,181.99 v1(59.93,183.48)
  BOTTOM w0.102: U63.8 v1(68.94,175.34)
PSU5_AC_OK_R: length 20.9
  TOP w0.102: R842.1 60.28,186.09 60.78,186.59 60.78,187.99 60.28,188.5 R851.1 60.28,193.8 58.39,195.68 v1(58.39,198.32) 58.05,198.66 J35.B49
PSU5_DC_OK: length 3
  TOP w0.102: v1(62.73,173.45) 62.73,173.09 62.83,172.99 U85.4
  BOTTOM w0.102: v1(62.73,173.45) 63.32,174.04 U63.15
PSU5_DC_OK_R: length 21.3
  BOTTOM w0.102: R843.1 60.28,186.09 59.64,186.72 59.64,187.89 R857.1 60.28,190.39 59.04,191.62 59.04,196.32 v2(58.68,196.68) 59.04,197.04 59.04,198.54 58.05,199.53 J35.A49
PSU5_DC_OK_R_BUF: length 16.2
  TOP w0.102: U85.2 63.78,175.34 63.49,175.63 62.99,175.63 v1(62.67,175.95) 62.67,176.47 63.07,176.87 63.78,176.87 64.61,177.71 64.61,179.52 U96.G v1(64.21,180.98)
  IN2 w0.114: v1(64.21,180.98) 63.95,180.98 63.47,181.46 62.59,181.46 60.58,183.47 v1(60.58,183.92)
  BOTTOM w0.102: C612.1 60.28,183.03 60.58,183.33 v1(60.58,183.92) 60.28,184.23 R843.2
PSU6_AC_OK: length 19.1
  TOP w0.102: C614.1 59.13,182.7 58.66,183.17 v1(58.66,183.48) 58.66,183.88 59.13,184.36 R846.2
  IN1 w0.114: v1(58.66,183.48) 60.31,181.82 60.31,179.44 61.26,178.5 61.72,178.5 65.52,174.69 v1(69.01,174.69)
  BOTTOM w0.102: U63.9 v1(69.01,174.69)
PSU6_AC_OK_R: length 21
  TOP w0.102: R846.1 59.13,185.96 58.5,186.59 58.5,187.86 59.13,188.5 R852.1 59.13,192.84 57.05,194.93 v1(57.05,197.55) J35.B50
PSU6_DC_OK: length 6.7
  TOP w0.102: U87.4 v1(59.27,173.4)
  BOTTOM w0.102: U63.16 63.08,174.69 62.94,174.54 61.15,174.54 60,173.4 v1(59.27,173.4)
PSU6_DC_OK_R: length 21.1
  BOTTOM w0.102: J35.A50 57.05,199.62 v2(57.01,199.58) 57.01,198.44 57.96,197.48 57.96,192.08 59.13,190.91 R858.1 58.94,188.53 58.5,188.09 58.5,186.59 59.13,185.96 R847.1
PSU6_DC_OK_R_BUF: length 12.8
  TOP w0.102: U87.2 60.22,175.29 v1(60.68,175.75) 60.66,175.77 60.66,176.35 60.99,176.68 60.99,178.15 60.66,178.48 U99.G 60.66,180.1 59.66,181.09 59.66,183.01 59.32,183.36 v1(59.32,183.93)
  BOTTOM w0.102: R847.2 59.13,184.11 v1(59.32,183.93) 59.32,183.21 59.13,183.03 C615.1
PSU_ALERT_N: length 70
  TOP w0.102: v1(65.58,175.84) 65.25,176.16 65.25,177.58 66.48,178.81 66.48,180.45 67.09,181.06 67.09,181.49 v1(67.29,181.69)
  IN1 w0.114: v1(67.29,181.69) 67.69,182.09 67.69,183.12 70.1,185.53 103.01,185.53 103.35,185.19 103.88,185.19 105.8,187.1 107.91,187.1 108.28,186.74 108.28,186.48 108.27,186.48 108.27,184.58 109.37,183.48 113.09,183.48 113.64,182.94 115.35,182.94 v1(118.79,186.37)
  BOTTOM w0.102: U63.17 65.09,175.34 v1(65.58,175.84) ; R838.2 119.13,187.39 119.13,186.71 v1(118.79,186.37) 119.46,185.7 C607.1
PSU_ALERT_R_N: length 17.3
  BOTTOM w0.102: J18.A80 118.05,202.13 118.54,201.64 118.54,200.65 118.68,200.51 118.68,198.26 118.63,198.22 118.63,195.33 v2(119.22,194.74) 119.46,194.5 R838.1
PSU_DC_OK_N: length 40.6
  TOP w0.102: v1(62.13,177.27) 62.55,177.69 U96.D ; U97.D 73.6,177.69 v1(72.76,176.85) ; v1(65.69,176.68) 65.69,177.43 65.94,177.69 U98.D ; v1(55.51,173.69) U92.G 55.51,172.43 57.6,170.34 U114.D ; v1(71.46,177.14) 70.91,177.69 U95.D ; v1(60.39,176.69) 59.92,176.22 59.67,176.22 R1012.1 59.65,177.68 U99.D ; v1(75.9,177.16) 76.43,177.69 U94.D 77.82,177.67 R1014.2
  IN2 w0.114: v1(60.39,176.69) 61.15,176.69 61.73,177.27 v1(62.13,177.27) 64.04,177.27 64.63,176.68 v1(65.69,176.68) 67.39,178.38 69.97,178.38 71.21,177.14 v1(71.46,177.14) 72.47,177.14 v1(72.76,176.85) 73.07,177.16 v1(75.9,177.16)
  BOTTOM w0.102: v1(60.39,176.69) 59.88,176.69 56.88,173.69 v1(55.51,173.69)
PU_CPU_NODE1_BRD_ID0: length 13.1
  TOP w0.102: U2.B57 81.49,88.6 81.49,89.7 82.81,91.01 86.71,91.01 v1(87.1,91.39) 88.01,91.39 89.59,92.97 89.81,92.97 90.55,93.71 R156.2 R153.1
PU_CPU_NODE1_DFX_GPIO_GRP1_3: length 14
  TOP w0.102: U2.H34 70.27,85.38 70.64,85.01 v1(70.64,84.97)
  BOTTOM w0.102: R53.1 v2(67.07,95.11) 67.07,93.87 67.6,93.34 68.38,93.34 69.42,92.3 69.42,91.96 70.56,90.82 70.56,90.43 70.37,90.24 70.37,89.45 70.31,89.4 70.31,85.73 70.64,85.4 v1(70.64,84.97)
PU_CPU_NODE1_DFX_GPIO_GRP1_5: length 11.7
  TOP w0.114: U2.E31 68.54,86.81 v1(68.24,86.51)
  BOTTOM w0.102: v1(68.24,86.51) v2(68.24,88.96) 68.24,89.11 67.77,89.57 67.77,91.47 65.04,94.2 R51.1
PU_CPU_NODE1_DFX_GPIO_GRP1_6: length 9.3
  TOP w0.102: U2.C31 68.75,88.32 68.19,88.88 68.19,89.78 68.23,89.82 68.23,90.69 68.48,90.94 v1(68.48,92.46) 68.7,92.69 68.7,94.33 70.13,95.75 R47.1
PU_CPU_NODE1_MEM_SPEED0: length 22.2
  TOP w0.102: v1(81.71,77.07) 81.71,77.32 U2.AD56
  BOTTOM w0.102: v1(81.71,77.07) 82.08,77.44 83.32,77.44 83.83,76.93 87.1,76.93 87.21,77.03 88.62,77.03 89.34,76.32 95.72,76.32 96.33,76.93 v2(97.03,76.93) 97.75,77.65 97.75,77.88 98.4,78.53 99.51,78.53 99.75,78.77 R173.2 R171.1
PU_EMC1428_NODE1_TRIP: length 7.3
  TOP w0.102: U9.5 v1(63.15,102.44) 63.15,102.44 63.51,102.8 66.95,102.8 68.22,101.53 R196.2
PU_FAN_TACH: length 10.9
  TOP w0.102: R769.2 116.59,163.77 116.47,163.89 U70.9 114.57,163.89 114.03,163.36 113.14,163.36 112.4,164.1 111.15,164.1 v1(111.06,164.01) 111.06,166.09 110.72,166.43 U70.4
PU_I2C_BMC_SCL: length 6.8
  TOP w0.102: R346.2 78.92,122.13 v3(78.92,122.78) 78.54,123.16 78.54,125.47 79.37,126.3 79.37,126.86 U14.K21
PU_I2C_BMC_SDA: length 10.3
  TOP w0.102: U14.K22 78.97,126.34 78.09,125.45 78.09,122.12 77.77,121.8 77.77,118.89 77.78,118.88 77.78,118.81 R345.2 78.23,117.97 v1(79.04,117.15)
PU_I2C_SCL4: length 3.3
  TOP w0.102: U60.13 133.84,170.67 134.6,169.91 v1(134.6,169.68) 134.71,169.57 R672.2
PU_I2C_SDA4: length 3
  TOP w0.102: R674.2 134.94,170.59 v1(134.56,170.96) 134.13,170.96 133.78,171.32 U60.14
PU_LAN1_TDI: length 5.8
  TOP w0.102: U35.40 56.85,161.78 v1(57.53,162.46) 58.57,163.5 R536.2
PU_LAN1_TMS: length 5.5
  TOP w0.102: U35.38 57.85,160.65 v1(58.38,161.18) 58.95,161.76 59.39,161.76 60.78,163.15 R537.2
PU_LAN2_TDI: length 6.4
  TOP w0.102: U37.40 172.8,146.95 170,144.15 v1(170,144.05) R567.2
PU_LAN2_TMS: length 7.2
  TOP w0.102: U37.38 171.8,147.37 v1(171.31,146.88) 170.7,146.26 170.27,146.26 167.72,143.72 R568.2
PU_SATA_NODE1_GPIO4: length 2.7
  TOP w0.102: U30.18 160.36,58.85 v1(160.77,58.44) 161.31,57.9 R502.2
PU_TEMP1_NODE1_SYS_SHDN_L: length 9.3
  TOP w0.102: R197.2 69.24,101.49 v1(68.7,102.03) 67.68,103.05 62.81,103.05 62.5,102.75 U9.6
PV_VCCP_NODE1: length 37.3
  TOP w0.254: PR63.2 130.65,139.82 132.83,137.63 132.83,119.7 130.52,117.39 128.24,117.39 127.11,116.26 127.11,112.24 126.3,111.43 PC99.1
  vias: v1(75.63,80.19) v1(76.47,80.18) v1(77.71,79.14) v1(79.16,79.17) v1(79.92,79.16) v1(80.74,79.16) v1(82.23,79.17) v1(90.93,79.65) v1(91.57,79.65) v1(92.2,79.65) v1(92.84,79.65) v1(93.47,79.65) v1(94.11,79.65) v1(117.41,115.61) v1(117.41,114.55) v1(118.57,116.17) v1(118.57,115.1) v1(119.16,110.03) v1(119.15,107.83) v1(119.25,106.25) v1(119.24,105.32) v1(119.24,104.26) v1(119.34,114.16) v1(119.41,113.18) v1(119.44,112.21) v1(120.2,114.18) v1(121.17,114.19) v1(121.34,105.81) v1(121.87,106.37) v1(122,105.38) v1(122.2,114.16) v1(122.87,104.28) v1(122.96,113.35) v1(123.38,115.86) v1(123.42,114.89) v1(123.75,104.23) v1(124.02,113.35) v1(124.81,104.23) v1(125.02,113.37) v1(125.56,105.96) v1(125.48,104.98) v2(92.47,80.41)
PV_VDDR_NODE1: length 83.7
  TOP w0.178: v1(74.64,64.88) 74.64,64.8 74.48,64.65 74.48,64.59 74.27,64.37 74.27,64.19 74.31,64.15 74.31,64.08 74.59,63.8 U2.BM43 ; U2.BK44 75.15,65.04 75.39,65.28 v1(75.39,65.46) 75.76,65.46 76.53,64.69 U2.BK46 76.53,64.55 76.31,64.33 76.22,64.33 76.02,64.13 76.02,63.9 75.82,63.7 U2.BM45
  TOP w0.203: U2.BM49 77.95,63.54 v1(77.95,64.1)
  TOP w0.254: PC83.1 67.87,14.84 65.58,14.84 61.99,18.44 56.31,18.44 54.53,16.66 48.26,16.66 47.89,16.29 PR35.2 ; U2.BK39 73.23,64.1 73.23,63.76 U2.BM40 ; 127.92,25.53 U123.2
  TOP w0.305: v1(69.43,67.36) 69.45,67.36 69.8,67.01 U2.BE32 U2.BE34 ; 72.03,64.64 72.18,64.79 72.53,64.79 U2.BK39 ; 72.03,64.64 U2.BK37 ; 72.03,64.64 71.6,64.2 v1(71.44,64.2) 71.32,64.08 U2.BM36 ; U2.BD45 75.76,67.42 75.58,67.6 75.09,67.6 U2.BE42 U2.BE41 73.78,67.03 73.44,67.36 v1(73.4,67.36) ; v1(71.42,65.46) 71.4,65.46 70.68,64.74 U2.BK35 U2.BK32 ; U2.BD38 U2.BD37 71.76,67.36 71.42,67.71 v1(71.42,67.74) ; v1(69.82,62.02) 69.82,62.35 70.02,62.55 U2.BP34
  TOP w0.356: J2.132 v1(94.08,31.05) ; v1(91.68,31.09) J2.124
  TOP w0.381: R214.1 20.11,6.58 U10.6 ; J2.94 82.68,27.74 v1(82.87,27.55) ; v1(93.64,19.39) 93.64,19.39 93.78,19.53 J2.131 ; v1(80.12,19.41) 79.98,19.55 J2.85 ; v1(88.13,30.81) 88.02,30.81 87.48,30.27 J2.110 ; J2.116 89.28,30.59 v1(88.19,31.68) ; J2.102 v1(85.08,27.64) ; J2.109 v1(87.18,19.45) ; J2.101 84.78,19.75 v1(84.56,19.52) ; J2.115 v1(88.98,19.35) ; J2.123 v1(91.38,19.45) ; J2.86 v1(80.28,27.41) ; J2.93 v1(82.38,19.37)
  TOP w0.508: v1(19.25,6.71) R214.1 ; R215.1 v1(24.62,12.85)
  IN1 w0.457: v1(71.42,67.74) 71.37,67.74 71.1,68.01 70.19,68.01 69.54,67.36 ; v1(71.42,65.46) 71.42,65.4 71.19,65.18 70.66,65.18 70.14,65.69 70.14,66.79 69.57,67.36 69.54,67.36 ; 69.54,67.36 v1(69.43,67.36)
  BOTTOM w0.457: v1(69.43,67.36) 69.56,67.49 R1044.2
  BOTTOM w0.508: C169.1 84.97,27.75 v1(85.08,27.64) ; C170.1 80.52,27.18 v1(80.28,27.41) ; C174.1 94.32,30.81 v1(94.08,31.05) ; C157.1 91.73,31.03 v1(91.68,31.09)
  vias: v1(68.25,12.98) v1(68.49,11.56) v1(69.26,12.98) v1(69.51,11.56) v1(70.28,12.98) v1(70.48,47.6) v1(70.49,50.1) v1(70.53,11.56) v1(70.68,43.03) v1(70.62,41.8) v1(70.64,40.84) v1(70.71,44.04) v1(71.29,12.97) v1(72.31,12.95) v1(73.33,12.95) v1(73.57,11.56) v1(74.34,12.92) v1(74.59,11.56) v1(75.35,12.92) v1(75.61,11.56) v1(76.42,13.65) v1(80.59,18.88) v1(81.23,19.35) v1(81.78,18.87) v1(82.92,18.91) v1(83.51,19.29) v1(84.14,18.98) v1(85,19.05) v1(85.63,19.35) v1(86.28,19.39) v1(88.03,19.35) v1(89.73,19.4) v1(90.2,18.86) v1(90.7,19.36) v1(91.87,18.93) v1(92.45,19.32) v1(93.04,18.95) v1(94.24,18.9) v1(94.87,19.35) v1(128.34,26.85) v1(128.98,26.85) v1(129.61,26.85) v2(74.25,44.92) v2(74.52,50.26) v2(79.34,52.24) v2(84.01,34.58) v2(84.32,53.48)
PV_VDDR_NODE1_EN: length 2.6
  TOP w0.178: 51.55,8.19 51.18,8.19 50.92,8.46 PU7.10
  TOP w0.254: 51.55,8.19 51.74,8.19 v1(52.13,7.79) 52.21,7.72 PJ10.2
PV_VDDR_NODE1_MODE: length 4.4
  TOP w0.178: 51.47,12.98 50.92,12.43 PU7.16
  TOP w0.254: 51.47,12.98 51.73,13.24 PR33.1 51.73,14.79 v1(51.91,14.98) 52.14,15.21 PJ9.1
PV_VDDR_NODE1_SLEW: length 2.9
  TOP w0.178: PU7.19 49.72,12.5 49.19,13.03
  TOP w0.254: 49.19,13.03 48.74,13.03 v1(48.57,13.19) 48.92,13.54 PC85.2
PV_VDDR_NODE1_TRIP: length 2.1
  TOP w0.178: v1(49.88,13.14) 50.12,12.91 PU7.18
  TOP w0.254: v1(49.88,13.14) 49.92,13.17 PR103.1
PV_VDDR_NODE1_V0: length 3.5
  TOP w0.152: 47.94,9.34 48.11,9.5 PU7.5
  TOP w0.254: 47.94,9.34 v1(47.58,8.97) PR40.1 46.41,8.97 46.09,9.29 PR38.2
PV_VDDR_NODE1_V1:
  vias: v1(47.57,10.37)
PV_VDDR_NODE1_VID0: length 7.4
  TOP w0.102: v1(47.97,4.89) 48.66,4.2 Q43.3
  TOP w0.178: 50.14,7.66 50.12,7.69 PU7.8
  TOP w0.254: Q43.3 49.26,3.85 49.74,4.33 49.74,6.54 50.15,6.95 R1123.2 50.28,7.07 50.14,7.21 50.14,7.66
PV_VDDR_NODE1_VID1: length 2.1
  TOP w0.178: 50.85,7.76 50.52,8.09 PU7.9
  TOP w0.254: PR37.1 50.85,7.4 v1(50.85,7.6) 50.85,7.76
PV_VDDR_NODE1_VREF: length 1.1
  TOP w0.178: PU7.6 49.32,8.36 49.19,8.23 48.68,8.23
  vias: v1(47.05,7.51)
PV_VDDR_NODE1_VREF_LM321: length 28.6
  TOP w0.254: C181.1 R216.2 22.6,13.4 v1(23.21,14.01) ; R217.2 v1(45.32,19.45)
  IN1 w0.254: v1(45.32,19.45) 43.24,19.45 38.91,15.12 31.63,15.12 30.17,13.66 23.56,13.66 v1(23.21,14.01)
PV_VDDR_NODE1_VREF_R:
  vias: v1(24.7,7.72)
PV_VDDR_NODE1_VREF_RW: length 6.3
  TOP w0.254: R214.2 20.76,6.69 U10.5
  TOP w0.381: 20.85,7.73 21,7.73 21.6,7.13 U11.1 ; 20.85,7.73 v1(21.33,8.2) ; 20.85,7.73 R213.1 ; v1(21.39,6.4) 21.08,6.71 R214.2
  IN1 w0.254: v1(21.39,6.4) 21.39,8.13 v1(21.33,8.2)
PV_VDDR_VCCCLK_DDR3_NODE1: length 7.5
  TOP w0.305: U2.BA41 73.78,69.26 v1(73.4,68.88) 73.78,68.51 U2.BB41
  BOTTOM w0.102: L10.2 76.11,69.57 76.35,69.81 76.88,69.81 77.45,70.39 77.7,70.39 78.33,71.02 v2(78.33,71.29)
  BOTTOM w0.381: v1(73.4,68.88) 73.52,68.76 C131.1 75.15,68.76 C132.1 75.49,68.8 75.85,69.16 L10.2
PV_VTT_DDR_NODE1: length 6.8
  TOP w0.254: v1(127.33,25.04) 127.42,24.96 U123.3
  TOP w0.381: C141.1 115.38,18.84 J2.203 ; J2.204 v1(115.68,27.72)
  TOP w0.508: v1(116.35,19.35) 115.96,18.95 C141.1
  vias: v1(126.22,26.71) v1(127.14,26.71)
PV_VTT_DDR_NODE1_REFIN:
  vias: v1(129.28,25.23)
PV_VTT_DDR_NODE1_REFOUT:
  vias: v1(125.55,19.9)
PV_VTT_DDR_NODE1_VOSNS: length 2.5
  TOP w0.254: U123.5 126.42,24.21 v1(125.75,24.87) 125.23,25.39 J24.2
PWR_BTN_NODE1_C_L: length 8.3
  TOP w0.102: R1066.1 R1054.1 184.25,138.37 184.61,138 v1(186.47,138) U106.2 189.26,138 189.41,138.15 C798.1
PWR_BTN_NODE1_L: length 13.6
  TOP w0.102: R1054.2 C797.2 R1053.1 181.83,136.34 v1(181.46,135.97) 180.86,135.37 180.86,134.32 180.6,134.06 S1.1 S1.2
PWRGD_CPU_NODE1_EPWRGOOD: length 18.6
  TOP w0.102: U2.AD58 82.43,77.56 82.96,77.03 v1(83.09,77.03)
  BOTTOM w0.102: R141.2 98.48,76.68 v2(98.26,76.46) 97.47,75.67 95.33,75.67 95.16,75.84 89.5,75.84 88.51,76.83 87.29,76.83 87.19,76.72 83.4,76.72 v1(83.09,77.03)
PWRGD_NODE1_DDR3_DRAM_POK: length 136.3
  TOP w0.102: Q24.C 172.98,124.02 v1(172.16,124.84) ; v1(74.87,65.82) 74.84,65.82 U2.BH42
  IN3 w0.114: v1(172.16,124.84) 171.7,124.84 164.93,118.08 164.93,113.15 159.75,107.97 159.75,107.09 153.05,100.39 138.67,100.39 135.5,97.22 135.5,96.22 122.57,83.29 114.99,83.29 112.22,80.51 112.22,79.76 106.37,73.91 100.52,73.91 98.43,76 97.71,76 97.1,76.61 88.98,76.61 88.76,76.83 85.42,76.83 81.79,73.21 79.99,73.21 79.57,73.62 78.63,73.62 78.24,73.23 78.24,71.05 77.66,70.47 75.69,70.47 74.18,68.95 74.18,66.51 v1(74.87,65.82)
  BOTTOM w0.102: v1(74.87,65.82) 74.17,66.52 R1040.1
PWRGD_NODE1_DDR3_SYSPWRGD: length 141.8
  TOP w0.102: v1(69.43,66.6) 69.8,66.22 U2.BG32 ; Q26.C 173.28,121.03 172.9,121.41 172.9,121.41 v1(170.17,124.14)
  IN3 w0.114: v1(170.17,124.14) 164.67,118.64 164.67,113.26 159.48,108.08 159.48,107.2 153.04,100.76 138.66,100.76 135.24,97.33 135.24,96.44 122.35,83.55 114.8,83.55 111.61,80.36 111.61,79.53 106.26,74.18 100.63,74.18 98.54,76.26 97.82,76.26 97.21,76.88 91.04,76.88 90.17,77.74 85.66,77.74 81.45,73.53 80.11,73.53 79.6,74.04 78.39,74.04 77.95,73.6 77.95,72.24 76.54,70.84 75.2,70.84 74.39,70.03 73.81,70.03 73.62,70.22 69.85,70.22 69.52,69.88 69.52,69.29 69.84,68.97 69.84,67.01 v1(69.43,66.6)
  BOTTOM w0.102: R1044.1 69.52,66.69 v1(69.43,66.6)
PWRGD_NODE1_P1V0: length 80.7
  TOP w0.102: U102.F3 v5(191.54,121.87)
  TOP w0.254: v1(173.12,71.54) R1218.2 173.12,72.41 C884.2 173.02,73.53 173.02,76.22 173.16,76.36 U130.5
  IN1 w0.114: v5(191.54,121.87) 191.72,121.87 192.15,122.29 192.88,122.29 193.41,121.77 194.51,121.77 194.67,121.93 197.65,121.93 198.29,121.29 198.29,96.96 190.24,88.9 v1(184.61,88.9)
  BOTTOM w0.102: v1(184.61,88.9) 184.17,88.47 184.17,76.49 180.09,72.4 176.76,72.4 176.12,71.76 173.34,71.76 v1(173.12,71.54)
PWRGD_NODE1_P1V05_PG: length 189.1
  TOP w0.102: PU6.16 29.82,131.02 31.16,132.36 PR24.2 31.36,132.95 31.48,133.08 v1(32.87,133.08) ; U102.G3 v5(191.54,122.87)
  IN2 w0.114: v1(169,116.94) 167.18,116.94 166.95,116.71 165.18,116.71 160.15,121.74 150.25,121.74 149.92,122.07 146.4,122.07 145.97,122.5 145.36,122.5 145.33,122.54 142.12,122.54 140.36,120.77 140.36,119.19 132.24,111.08 132.24,110.87 131.99,110.61 131.62,110.61 131.24,111 113.28,111 107.12,117.15 96.72,117.15 95.67,116.1 94.63,116.1 94.09,115.57 62.5,115.57 58.97,119.1 57.23,119.1 56.17,120.16 52.75,120.16 52.06,120.85 48.79,120.85 48.44,120.5 40.58,120.5 38.54,122.55 38.54,127.41 v1(32.87,133.08)
  IN3 w0.114: v5(191.54,122.87) 191.31,122.87 190.75,122.31 184.76,122.31 182.86,120.41 171.44,120.41 169,117.97 v1(169,116.94)
PWRGD_NODE1_P1V5_SUS_PG: length 176.7
  TOP w0.102: v1(47.44,107.97) 47.15,107.69 45.77,107.69 45.61,107.53 R1087.2 45.6,107.27 C824.2 45.6,105.98 46.26,105.33 46.26,104.41 46.06,104.21 U120.5 ; U102.F1 194.82,121.37 v1(194.95,121.5)
  IN2 w0.114: v1(55.62,118.82) 56.6,117.84 57.94,117.84 60.53,115.25 60.53,114.6 62.35,112.78 64.04,112.78 65.51,114.25 94.56,114.25 95.16,114.85 98.64,114.85 99.69,115.9 106.6,115.9 113.4,109.1 134.97,109.1 137.24,111.37 139.85,111.37 140.03,111.18 143.91,111.18 144.21,110.88 157.72,110.88 161.61,114.77 165.29,114.77 165.51,114.56 168.9,114.56 170.64,116.3 175.14,116.3 175.14,116.29 v1(176.86,116.29)
  IN3 w0.114: v1(194.95,121.5) 190.72,117.27 190.24,117.27 189.53,116.55 184.74,116.55 183.88,115.69 181.69,115.69 181.43,115.95 181.09,116.29 v1(176.86,116.29) ; v1(47.44,107.97) 47.91,107.97 48.91,108.97 48.91,114.43 53.3,118.82 v1(55.62,118.82)
PWRGD_NODE1_P1V05_SUS_PG: length 111.2
  TOP w0.102: v1(193.73,122.2) 193.2,122.2 U102.G1
  IN2 w0.114: v1(193.73,122.2) 193.73,126.23 193.82,126.33 193.82,128.17 191.18,130.81 189.31,130.81 189.15,130.97 188.74,130.97 188.58,130.81 187.98,130.81 185.39,128.22 185.39,127.97 184.86,127.43 181.29,127.43 179.23,129.5 174.86,129.5 172.52,131.84 161.07,131.84 160.79,132.12 136.69,132.12 128,140.8 128,141.27 127.6,141.68 126.8,141.68 124.85,143.64 110.94,143.64 110.65,143.93 110.65,144.05 110.21,144.49 109.77,144.49 104.39,139.11 104.39,138.43 v1(105.71,137.1)
PWRGD_NODE1_P1V8_STB_PG: length 111.3
  TOP w0.102: U102.D2 v5(192.54,119.87)
  TOP w0.254: PU4.5 115.12,156.66 115.53,157.06 PR14.1 PR13.2 116.55,157.41 v1(116.19,157.06)
  IN1 w0.114: v5(192.54,119.87) 192.02,120.39 185.62,120.39 178.97,127.04 178.97,128.33 177.45,129.85 177.38,129.92 177.38,133.6 176.32,134.66 171.4,134.66 170.87,135.19 168.57,135.19 164.4,139.36 164.4,142.03 164.26,142.17 164.26,151.19 163.31,152.13 163.31,152.76 162.66,153.41 162.05,153.41 160.57,154.89 160.57,156.32 v1(158.01,158.88)
  IN2 w0.114: v1(116.19,157.06) 117.78,158.64 119.8,158.64 120.98,159.83 123.78,159.83 124.17,160.22 131.63,160.22 134.26,157.59 148.74,157.59 149.22,157.1 154.45,157.1 155.75,158.39 157.53,158.39 v1(158.01,158.88)
PWRGD_NODE1_P1V26_BMC_PG: length 120.6
  TOP w0.102: U122.5 96.96,139.22 97.55,138.63 R1096.1 98.23,137.41 v1(98.48,137.65) ; U102.E3 v5(191.54,120.87)
  IN1 w0.114: v1(150.03,124.72) 150.02,124.72 149.02,125.72 147.3,125.72 145.59,124.01 140.96,124.01 139.3,125.66 139.3,128.68 130.69,137.29 130.69,137.91 130,138.6 130,142.72 127.67,145.05 107.63,145.05 100.23,137.65 v1(98.48,137.65)
  IN2 w0.114: v1(176.27,117.75) 172.82,121.2 165.26,121.2 161.25,125.2 150.5,125.2 v1(150.03,124.72)
  IN3 w0.114: v1(176.27,117.75) 176.49,117.52 177.93,117.52 178.18,117.27 184.22,117.27 184.26,117.31 187.63,117.31 188.45,118.14 188.45,119.5 189.82,120.87 v5(191.54,120.87)
PWRGD_NODE1_P1V538_BMC_PG: length 181.9
  TOP w0.102: v1(39.97,129.37) R1094.2 C834.2 41.08,129.34 41.67,128.75 U121.5 ; U102.D3 v5(191.54,119.87)
  IN2 w0.114: v1(39.97,129.37) 39.97,128.91 39.03,127.98 39.03,123.52 39.58,122.97 39.58,122.21 40.79,121 48,121 48.35,121.35 52.26,121.35 52.95,120.66 56.38,120.66 57.44,119.6 59.18,119.6 62.7,116.07 92.93,116.07 93.46,116.6 95.46,116.6 97.8,118.94 104.83,118.94 105.09,118.67 107.13,118.67 108.35,117.46 108.35,117.2 114.06,111.49 131.19,111.49 132.51,112.81 132.98,112.81 139.86,119.69 139.86,120.98 142.26,123.38 145.84,123.38 146.65,122.57 150.12,122.57 150.46,122.24 160.49,122.24 165.52,117.21 166.68,117.21 166.91,117.44 169.46,117.44 170.05,116.85 177.59,116.85 v1(177.6,116.84)
  IN3 w0.114: v5(191.54,119.87) 191.54,119.26 190.65,118.37 189.39,118.37 188.07,117.05 184.53,117.05 184.49,117.01 177.76,117.01 v1(177.6,116.84)
PWRGD_NODE1_P3V3_PG: length 223.9
  TOP w0.102: v1(194.51,122.78) 194.45,122.84 192.52,122.84 U102.G2
  TOP w0.254: PU5.5 81.38,4.57 80.97,4.16 PR19.1 PR18.2 79.96,3.81 v1(80.31,4.17)
  IN2 w0.114: v1(80.31,4.17) 82.98,1.49 120.38,1.49 133.74,14.85 138.3,14.85 138.81,15.37 140.89,15.37 141.19,15.06 169.03,15.06 174.86,20.89 174.86,47.63 176.9,49.67 176.9,66.51 198.29,87.91 198.29,119.48 195.23,122.53 194.75,122.53 v1(194.51,122.78)
PWRGD_NODE1_P3V3_STB_PG: length 167.4
  TOP w0.102: R1247.2 199.18,118.71 199.32,118.57 v1(199.32,117.94)
  TOP w0.254: PU2.5 57.14,108.1 56.73,107.69 PR6.1 PR5.2 55.72,107.34 v1(56.07,107.7)
  IN2 w0.114: v1(171.1,114.36) 170.26,113.52 162.05,113.52 157.18,108.65 145.35,108.65 144.37,107.68 144.37,106.48 143.33,105.44 134.16,105.44 131.27,108.33 112.97,108.33 106.32,114.99 106.17,115.13 101.91,115.13 101.65,114.88 101.65,114.87 97.66,110.88 94.3,110.88 93.5,110.08 93.5,109.39 v1(93.18,109.06)
  IN3 w0.114: v1(199.32,117.94) 199.32,117.86 199.76,117.42 199.76,116.61 198.86,115.72 197.53,115.72 196.96,115.15 194.35,115.15 192.52,113.32 190.81,113.32 190.03,112.55 183.44,112.55 183.21,112.78 181.2,112.78 179.85,114.13 174.94,114.13 173.95,115.11 171.84,115.11 v1(171.1,114.36) ; v1(56.07,107.7) 58.68,105.09 76.76,105.09 76.84,105.17 83.63,105.17 87.53,109.06 v1(93.18,109.06)
PWRGD_NODE1_P3V3_STB_PG_CPLD: length 5.1
  TOP w0.102: R1247.1 197.58,118.71 v1(196.93,119.37) U102.D1
PWRGD_NODE1_P5V_STB_PG: length 236.5
  TOP w0.102: v1(90.32,109.87) 90.32,116.26 90.65,116.58 90.65,119.83 v1(90.18,120.3) ; R1246.2 199.15,116.96 v1(199.32,116.8) ; v1(95.63,158.37) 96.1,157.9 96.1,150.97 93.55,148.42 91.99,148.42 89.36,145.79 89.36,145.49 v1(89.35,145.49)
  TOP w0.254: PJ2.1 v1(58.29,106.26) 58.45,106.41 PC26.1 59.05,105.38 R1103.2 ; PU1.5 91.61,156.62 92.01,157.03 92.01,157.84 PR2.1 PR1.2 93.03,157.37 v1(92.68,157.02)
  IN1 w0.114: v1(140.3,156.57) 140.8,156.57 141.04,156.33 142.81,156.33 144.35,154.79 153.33,154.79 157.47,150.65 157.47,145.34 158.18,144.64 158.27,144.64 158.53,144.38 159.16,143.75 159.16,141.56 159.23,141.5 159.23,138.16 169.1,128.29 169.1,124.22 170.05,123.27 v1(170.05,118.32) ; v1(89.35,145.49) 89.8,145.04 89.8,128.27 90.48,127.59 90.48,120.6 v1(90.18,120.3)
  IN3 w0.114: v1(90.32,109.87) 89.78,109.33 87.02,109.33 83.3,105.61 76.87,105.61 76.63,105.36 59.19,105.36 v1(58.29,106.26) ; v1(92.68,157.02) 92.68,158.03 93.22,158.57 95.43,158.57 v1(95.63,158.37) 96.35,159.1 103.17,159.1 103.17,159.1 103.29,159.22 110.28,159.22 110.98,159.92 114.76,159.92 114.89,159.79 115.06,159.79 115.2,159.64 115.31,159.54 124.03,159.54 124.83,160.34 128.56,160.34 129.32,159.58 129.45,159.44 132.17,159.44 132.48,159.13 133.7,159.13 136.26,156.57 v1(140.3,156.57) ; v1(170.05,118.32) 170.05,117.63 171.22,116.46 174.04,116.46 176.11,114.39 180.77,114.39 181.6,113.57 190.63,113.57 193.24,116.17 198.69,116.17 v1(199.32,116.8)
PWRGD_NODE1_P5V_STB_PG_CPLD: length 6.4
  TOP w0.102: R1246.1 196.73,116.96 v1(196.65,117.05) 195.83,117.86 192.54,117.86 U102.C2
PWRGD_NODE1_P12V_PG: length 5.5
  TOP w0.102: R1027.1 196.62,115.77 v1(196.58,115.73) 194.95,117.37 U102.B1
PWRGD_NODE1_P12V_PG_R: length 3.5
  TOP w0.102: U101.2 199.29,114.26 v1(199.06,114.5) 198.56,114.5 198.01,113.95 R1029.1 R1027.2
PWRGD_NODE1_PVCCP_PG: length 107.8
  TOP w0.102: PU8.21 116.39,136.7 116.03,137.06 115.5,137.06 114.61,136.18 PR52.1 114.44,136.47 114.18,136.73 112.27,136.73 111.78,137.22 111.78,141 111.38,141.4 111.38,143.52 112.01,144.15 v1(112.01,144.18) ; U102.H4 190.53,123.85 190.53,125.17 190.53,128.23 190.51,128.24 190.51,128.54 190.02,129.04 v1(190.02,131.31)
  IN2 w0.114: v1(190.02,131.31) 189.51,131.31 189.35,131.46 188.53,131.46 188.37,131.31 183.6,131.31 181.26,133.65 171.13,133.65 170.89,133.41 161.72,133.41 159.51,135.62 152.32,135.62 150.55,133.86 144.93,133.86 143.13,135.66 134.54,135.66 128.99,141.21 128.99,141.68 128.01,142.67 127.54,142.67 125.58,144.63 112.45,144.63 v1(112.01,144.18)
PWRGD_NODE1_PVDDR_STB_PG: length 260.4
  TOP w0.102: PU7.7 49.72,8.13 49.48,7.89 v1(49.48,7.71) 49.21,7.45 PR31.2 ; U102.F2 v5(192.54,121.87)
  IN2 w0.114: v5(192.54,121.87) 192.7,121.71 194.28,121.71 194.51,121.93 195.13,121.93 195.39,121.68 195.39,85.74 176.4,66.76 176.4,49.93 173.85,47.38 173.85,20.6 168.83,15.57 142.28,15.57 141.93,15.93 136.38,15.93 135.62,16.69 131.37,16.69 129.34,14.65 103.45,14.65 102.99,15.11 76.11,15.11 75.82,15.41 55.23,15.41 54.99,15.17 54.22,15.17 v1(53.83,15.55)
  BOTTOM w0.102: v1(49.48,7.71) 49.03,8.17 46.45,8.17 44.78,9.85 44.78,14.85 46.32,16.39 52.99,16.39 v1(53.83,15.55)
PWRGD_NODE1_PVTT_DDR_PG: length 172.7
  TOP w0.102: U102.H1 194.91,123.37 v1(195.24,123.03) ; v1(139.77,14.65) 139.54,14.65 135.92,18.27 127.96,18.27 127.5,18.74 R1126.2 127.92,19.41 U123.9
  IN2 w0.114: v1(195.24,123.03) 196.47,123.03 200.79,118.71 200.79,89.67 177.39,66.27 177.39,49.46 175.39,47.46 175.39,20.71 169.03,14.35 140.05,14.35 139.77,14.63 v1(139.77,14.65)
RST_BMC_NODE1_PERST_L: length 11.4
  TOP w0.102: U14.K19 78.97,128.86 v5(79.37,128.46)
  BOTTOM w0.102: v5(79.37,128.46) 79.77,128.06 79.77,127.41 79.95,127.23 79.95,126.28 79.59,125.92 79.59,124.31 80.52,123.38 v2(81.17,123.38) 81.43,123.13 R253.2 82.7,121.44 R254.2 82.73,121.46 R272.2
RST_BTN_L: length 13.8
  TOP w0.102: R1063.2 164.39,137.14 165.19,136.34 R1062.1 C801.2 165.19,134.1 v1(165.2,134.09) 163.27,132.16 S3.1 S3.2
RST_BTN_NODE1_C_L: length 7
  TOP w0.102: R1067.1 R1063.1 165.52,137.19 165.99,136.72 U58.2 167.66,136.72 v1(167.85,136.52) 167.94,136.44 167.94,134.72 C802.1
RST_BTN_NODE1_L: length 31.9
  TOP w0.102: U102.J7 186.53,124.88 186.53,127.26 185.14,128.65 178.82,128.65 175.53,131.94 172.53,131.94 170.82,133.65 v1(170.82,135.69) 170.73,135.77 U58.4 169.24,136.36 166.78,138.82 164.81,138.82 164.39,138.4 R1067.2
RST_CPU_NODE1_SRTCRST_L: length 122.2
  TOP w0.102: U2.N62 84.6,82.64 v1(85.3,82.64) ; U102.E9 184.98,120.37 184.55,119.94 181.02,119.94 180.92,120.05 178.28,120.05 177.72,119.48 177.72,119.3 177.14,118.72 177.14,117.85 176.56,117.26 175.88,117.26 175.82,117.32 R176.1 R175.1 174.67,116.76 170.05,116.76 168,118.81 165.42,118.81 164.74,118.12 164.74,116.9 v1(162.17,114.33)
  IN3 w0.114: v1(85.3,82.64) 85.78,82.16 89.94,82.16 89.99,82.21 93.98,82.21 94.89,81.3 106.35,81.3 108.75,83.71 111.35,83.71 114.26,86.62 121.21,86.62 137.78,103.19 150.06,103.19 153.58,106.72 155.08,106.72 162.17,113.81 v1(162.17,114.33)
RST_NODE1_CPU_XDP_RSTIN_L: length 109.7
  TOP w0.102: U102.J9 v1(184.57,124.83) ; J3.48 123.74,64.91 125.3,63.35 C183.1 125.77,63.35 126.43,64.01 127.58,64.01 R223.1 128.16,63.82 v1(128.65,64.31)
  IN3 w0.114: v1(184.57,124.83) 180.78,124.83 179.99,125.63 178.73,125.63 177.48,124.37 174.98,124.37 173.87,123.26 171.81,123.26 166.37,117.83 166.37,113.14 160.78,107.55 160.78,106.53 153.61,99.36 142.32,99.36 124.7,81.74 124.7,71.93 125.34,71.29 125.34,66.98 128.02,64.31 v1(128.65,64.31)
SATA_A_NODE1_RX_N0: length 27.1
  TOP w0.104: U30.30 163.15,64.76 163.39,64.51 167.49,64.51 175.79,56.22 175.79,51.47 174.29,49.98 173.73,49.98 v1(173.31,49.56)
  BOTTOM w0.104: v1(173.31,49.56) 172.9,49.98 172.6,49.98 C494.2
SATA_A_NODE1_RX_P0: length 27.1
  TOP w0.104: U30.29 162.25,64.36 162.4,64.32 162.97,64.32 163.21,64.08 167.31,64.08 170.05,61.34 170.05,61.06 170.27,60.84 170.55,60.84 170.77,60.62 170.77,60.34 170.99,60.12 171.27,60.12 171.49,59.9 171.49,59.62 171.72,59.4 172,59.4 172.22,59.18 172.22,58.9 172.44,58.68 172.72,58.68 172.94,58.45 172.94,58.17 173.16,57.95 173.44,57.95 173.66,57.73 173.66,57.45 173.88,57.23 174.16,57.23 174.38,57.01 174.38,56.73 174.6,56.51 174.88,56.51 175.35,56.04 175.35,55.75 175.21,55.61 175.21,55.3 175.35,55.16 175.35,54.85 175.21,54.71 175.21,54.4 175.35,54.26 175.35,53.95 175.21,53.81 175.21,53.49 175.35,53.35 175.35,51.65 174.11,50.41 173.73,50.41 v1(173.31,50.83)
  BOTTOM w0.104: v1(173.31,50.83) 172.9,50.41 172.45,50.41 C492.2
SATA_A_NODE1_TX_N0: length 5.6
  TOP w0.104: U30.32 162.63,65.56 162.8,65.73 v4(165.93,65.73) 166.74,65.73 C490.2
SATA_A_NODE1_TX_P0: length 5.6
  TOP w0.104: C489.2 166.66,66.17 v4(163.24,66.17) 162.62,66.17 162.42,65.96 U30.33
SATA_NODE1_GPIO1: length 4.3
  TOP w0.102: U30.74 151.94,61.56 151.85,61.47 151.59,61.47 v1(150.64,62.41) 150.32,62.74 R510.2 R509.2
SATA_NODE1_GPIO2: length 4.3
  TOP w0.102: U30.75 151.85,61.16 v1(150.71,60.02) 150.38,59.69 R512.2 R511.2
SATA_NODE1_GPIO3: length 3.6
  TOP w0.102: U30.17 159.96,59.32 159.28,58.63 v1(159.28,58.27) R515.2 R514.2
SATA_NODE1_GPIO5: length 4.4
  TOP w0.102: U30.19 160.76,59.29 161.4,58.65 162.14,58.65 v1(162.33,58.46) R517.2 R518.2
SATA_NODE1_ISET: length 4.4
  TOP w0.102: U30.37 162.11,67.56 162.34,67.8 162.34,69.06 163.49,70.2 v1(163.56,70.2) R504.1
SATA_NODE1_XTLOUT: length 3.9
  TOP w0.102: U30.36 161.61,67.16 162.11,67.16 162.83,67.87 162.83,68.76 v1(163,68.93) 163.13,69.06 R505.2
SATA_P7:
  vias: v1(160.77,53.47)
SATA_RX0_C_DN: length 5.1
  BOTTOM w0.104: C494.1 171.13,49.91 170.46,49.91 170.35,49.8 v2(170.35,49.41) 169.86,49.91 168.04,49.91 J7.5
SATA_RX0_C_DP: length 5
  BOTTOM w0.104: C492.1 171.15,50.34 170.46,50.34 170.35,50.45 v2(170.35,50.84) 169.86,50.34 168.04,50.34 J7.6
SATA_SPI_CLK_NODE1: length 32.5
  TOP w0.102: R508.1 148.5,74.3 148.14,73.94 148.14,73.54 148.29,73.39 150.44,73.39 150.58,73.24 150.58,73.03 150.43,72.88 148.29,72.88 148.14,72.73 148.14,72.52 148.29,72.37 149.59,72.37 149.74,72.22 149.74,72.01 149.59,71.86 148.29,71.86 148.14,71.71 148.14,71.5 148.29,71.35 149.59,71.35 149.74,71.21 149.74,71 149.59,70.85 148.29,70.85 148.14,70.7 148.14,70.49 148.29,70.34 149.59,70.34 149.74,70.19 149.74,69.98 149.59,69.83 147.46,69.83 145.95,68.32 v1(145.5,68.32) 143.32,68.32 141.2,66.19 U31.6
SATA_SPI_CLK_NODE1_R: length 9.2
  TOP w0.102: U30.50 156.36,69.58 156.55,69.77 156.55,70.08 155.99,70.64 155.99,73.05 155.49,73.55 v1(153.02,73.55) 152.27,74.3 R508.2
SATA_SPI_CS_NODE1: length 30.3
  TOP w0.102: R507.1 148.95,75.39 147.36,73.8 v1(147.36,71.65) ; U31.1 143.61,63.65 143.52,63.56 v1(143.52,62.87)
  BOTTOM w0.102: v1(147.36,71.65) 147.36,67.23 146.62,66.48 146.37,66.48 145.12,67.73 144.87,67.73 144.69,67.55 144.69,67.3 145.93,66.05 145.93,65.8 145.76,65.62 145.5,65.62 144.26,66.87 144,66.87 143.83,66.69 143.83,66.43 145.07,65.19 145.07,64.94 144.89,64.76 144.64,64.76 143.39,66 143.14,66 142.96,65.82 142.96,65.57 144.21,64.33 144.21,63.56 v1(143.52,62.87)
