# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LPC_CPU_NODE1_CLKRUN_L: length 9.6
  TOP w0.102: U2.C42 74.48,88.52 74.13,88.88 74.13,90.64 74.63,91.14 74.63,93.51 v3(76,94.88) 77.24,96.12 R68.2
LPC_CPU_NODE1_FRAME_L: length 230.5
  TOP w0.102: v1(101.71,15.62) 101.71,15.77 101.28,16.2 R194.1 ; R181.1 v1(131.02,50.28) ; R65.1 77.97,97.4 77.97,98 v1(78.46,98.49) ; v1(99.73,115) 99.98,115 100.9,115.92 U115.20
  IN1 w0.114: v1(101.55,95.42) 101.55,95.51 100.93,96.12 99.39,96.12 98,97.51 98,110.02 99.73,111.75 v1(99.73,115) 98.63,113.89 98.63,112.22 97.44,111.04 93.27,111.04 92.53,111.77 91.61,111.77 89.72,109.89 89.72,104.57 85.37,100.21 83.94,100.21 83.62,100.53 78.66,100.53 78.34,100.21 78.34,98.61 v1(78.46,98.49) ; v1(108.48,94.55) 108.48,92.24 116.17,84.55 119.61,84.55 128.25,75.91 128.25,67.36 127.55,66.66 127.55,64.85 127.82,64.58 127.82,56.44 120.38,48.99 120.38,25.26 115.16,20.04 110.44,20.04 103.96,16.87 103.55,16.58 102.67,16.58 v1(101.71,15.62)
  IN3 w0.114: v1(101.55,95.42) 102.06,94.91 105.65,94.91 106.01,94.55 v1(108.48,94.55) ; v1(101.71,15.62) 101.83,15.74 103.37,15.74 104.96,17.33 107.7,17.33 108.12,17.75 110.01,17.75 110.43,17.33 112.8,17.33 112.89,17.24 113.35,17.24 113.74,17.64 116.56,17.64 121.98,23.05 121.98,27.51 123.11,28.65 123.11,31.29 126.56,34.74 127.35,34.74 131.21,38.61 131.21,50.09 v1(131.02,50.28)
LPC_CPU_NODE1_FRAME_L_R: length 10.7
  TOP w0.102: U2.D44 75.1,88.14 74.82,88.41 74.82,88.69 74.9,88.76 74.9,90.06 75.02,90.18 75.02,93.42 75.89,94.3 76.58,94.3 v3(77.37,95.09) 77.37,95.42 R65.2
LPC_CPU_NODE1_FRAME_SIO_L: length 6.8
  TOP w0.102: U43.40 133.46,44.39 132.95,44.9 132.95,47.29 v1(132.88,47.36) 131.72,48.51 R181.2
LPC_CPU_NODE1_LAD0: length 240
  TOP w0.102: v1(111.01,15.41) 111.01,15.93 110.61,16.34 R190.1 ; U115.42 100.4,123.65 v1(100.48,123.57)
  IN1 w0.114: v1(104.71,97.65) 103.78,98.12 102.44,99.45 102.44,99.45 101.33,101.19 101.33,101.2 99.7,102.83 99.7,108.1 101.6,110 101.6,120.11 v1(100.48,123.57) 100.21,123.29 97.99,123.29 96.99,122.29 96.99,118.27 96.54,116.74 96.54,115.09 96.95,114.68 96.95,113.62 96.04,112.71 93.97,112.71 93.24,113.45 90.91,113.45 88.05,110.59 88.05,106.08 85.3,103.33 81.24,103.33 78.61,102.76 78.07,102.22 77.71,102.22 76.98,101.48 72.13,101.48 71.02,101.15 70.62,100.75 70.15,99.75 70.15,99.05 70.17,98.97 70.82,98.32 71.19,98.32 71.44,98.58 71.44,98.71 71.92,99.19 v1(72.88,99.19) ; v1(111.01,15.41) 111.21,15.6 112.56,16.1 115.47,16.1 117.28,16.64 122.82,22.18 122.82,48.93 130.34,56.45 130.34,66.86 129.92,67.27 129.92,76.93 120.14,86.71 116.54,86.71 110.36,92.9 110.36,95.78 108.78,97.35 108.66,97.35 v1(108.49,97.53)
  IN3 w0.114: v1(132.59,44.41) 132.79,44.41 133.91,43.29 133.91,38.08 127.62,31.79 127.62,30.16 123.82,26.36 123.82,22.29 116.21,14.68 111.58,14.68 111.01,15.24 v1(111.01,15.41) ; v1(104.71,97.65) 104.85,97.52 108.48,97.52 v1(108.49,97.53)
  BOTTOM w0.102: R63.1 73.4,97.07 73.4,98.39 72.88,98.91 v1(72.88,99.19) ; v1(132.59,44.41) 133.25,44.41 133.57,44.73 R182.1
LPC_CPU_NODE1_LAD0_R: length 12.6
  TOP w0.102: U2.G42 v1(74.69,85.69)
  BOTTOM w0.102: 75.4,93.61 75.4,94.42 74.93,94.88 74.92,94.88 74.58,95.66 74.58,96.44 R63.2 ; 75.39,93.61 v2(75.38,93.61) ; 75.39,93.61 75.37,93.63 75.37,87.89 74.95,87.47 74.95,86.54 74.69,86.28 v1(74.69,85.69)
LPC_CPU_NODE1_LAD0_SIO: length 3.8
  TOP w0.102: U43.41 135.69,43.89 136.2,44.41 v1(136.2,44.56)
  BOTTOM w0.102: R182.2 136.02,44.73 v1(136.2,44.56)
LPC_CPU_NODE1_LAD1: length 227.9
  TOP w0.102: R191.1 v1(109.38,16.29) ; U115.19 100.4,118.21 100.11,118.5 v1(100.11,118.5)
  IN1 w0.114: v1(108.37,96.74) 108.52,96.74 109.94,95.32 109.94,92.73 109.98,92.68 109.98,92.67 116.36,86.29 119.95,86.29 120.2,86.05 129.5,76.74 129.5,67.1 129.55,67.05 129.55,67.05 129.92,66.68 129.92,56.75 121.64,48.47 121.64,21.75 116.89,17.01 111.52,17.01 110.81,16.29 v1(109.38,16.29) ; v1(99.35,97.07) 98.43,97.99 98.43,109.26 100.35,111.18 100.35,118.26 v1(100.11,118.5) 99.83,118.5 98.7,117.37 98.7,115.21 98.21,114.71 98.21,113.1 96.56,111.46 93.45,111.46 92.71,112.19 91.43,112.19 89.3,110.06 89.3,105.05 85.34,101.09 83.94,101.09 83.81,100.96 78.36,100.96 76.08,98.68 73.24,98.68 73.13,98.58 72.18,98.58 v1(72.08,98.48)
  IN3 w0.114: v1(99.35,97.07) 99.55,96.87 106.03,96.87 106.16,96.74 v1(108.37,96.74) ; v1(132.42,43.72) 132.89,43.72 133.49,43.12 133.49,38.88 125.88,31.26 125.88,29.02 123.23,26.37 123.23,22.38 115.99,15.13 112.76,15.13 111.87,16.02 109.64,16.02 v1(109.38,16.29)
  BOTTOM w0.102: R183.1 133.18,43.72 133.18,43.72 v1(132.42,43.72) ; v1(72.08,98.48) 72.13,98.48 72.6,98.01 72.6,97.69 72.15,97.24 R62.1
LPC_CPU_NODE1_LAD1_R: length 12.4
  TOP w0.102: U2.G41 73.34,86.14 v1(73.05,85.85)
  BOTTOM w0.102: v1(73.05,85.85) 73.23,86.04 73.23,86.64 73.58,86.98 73.98,88.52 73.98,90.18 v2(74.33,91.05) 74.68,92.07 74.68,92.37 74.28,93.69 74.28,93.78 72.15,95.91 72.15,96.3 R62.2
LPC_CPU_NODE1_LAD1_SIO: length 6
  TOP w0.102: v1(137.42,43.66) 136.01,43.66 135.75,43.39 U43.42
  BOTTOM w0.102: R183.2 137.36,43.72 v1(137.42,43.66)
LPC_CPU_NODE1_LAD2: length 237.3
  TOP w0.102: v1(98.08,121.83) 97.76,121.83 97.44,122.14 U115.4 ; R192.1 v1(106.92,16.25)
  IN1 w0.114: v1(72.09,99.94) 72.22,99.94 72.84,100.56 77.24,100.56 78.06,101.38 83.63,101.38 83.76,101.51 85.17,101.51 88.89,105.23 88.89,110.24 91.26,112.61 92.89,112.61 93.62,111.87 96.39,111.87 97.79,113.27 97.79,114.97 98.08,115.26 98.08,120.45 v1(98.08,121.83) 98.48,121.83 100.77,119.54 100.77,110.35 98.86,108.44 98.86,102.39 100.13,101.12 100.13,97.75 v1(102.12,95.76) ; v1(106.92,16.25) 108.02,16.25 109.33,17.56 112.2,17.56 112.85,18.21 114.13,18.21 114.31,18.03 117.18,18.03 121.22,22.07 121.22,48.65 129.5,56.93 129.5,66.5 129.19,66.82 129.19,66.82 129.13,66.88 129.13,66.88 129.09,66.93 129.09,76.26 119.47,85.88 116.08,85.88 109.52,92.44 109.52,95.03 108.7,95.85 108.53,95.85 v1(108.37,96.02)
  IN3 w0.114: v1(108.37,96.02) 106.29,96.02 105.9,96.41 102.93,96.41 102.28,95.76 v1(102.12,95.76) ; v1(106.92,16.25) 107.16,16.49 108.33,16.49 108.75,16.91 109.63,16.91 110.05,16.49 112.45,16.49 112.54,16.4 113.04,16.4 113.36,16.08 116.19,16.08 122.81,22.7 122.81,26.6 125.46,29.25 125.46,31.43 133.07,39.05 133.07,42.29 132.88,42.49 v1(132.88,42.86)
  BOTTOM w0.102: v1(72.09,99.94) 72.1,99.92 72.1,99.21 72.93,98.39 72.93,96.29 73.22,95.99 R61.1 ; v1(132.88,42.86) 133.04,42.7 R184.1
LPC_CPU_NODE1_LAD2_R: length 12.6
  TOP w0.102: U2.H42 74.05,85.38 73.67,85 v1(73.14,85)
  BOTTOM w0.102: R61.2 74.55,94.09 75.02,92.52 75.02,90.23 v2(74.62,88.63) 74.17,87.49 73.45,86.03 73.45,85.69 73.14,85.38 v1(73.14,85)
LPC_CPU_NODE1_LAD2_SIO: length 3.7
  TOP w0.102: v1(136.25,43.05) 136.09,42.89 U43.43
  BOTTOM w0.102: v1(136.25,43.05) 135.9,42.7 R184.2
LPC_CPU_NODE1_LAD3: length 237.8
  TOP w0.102: R189.1 104.75,16.2 v1(104.91,16.37) ; U115.3 v1(98.27,122.64)
  IN1 w0.114: v1(104.91,16.37) 105.61,16.37 106.5,17.27 109.38,18.63 111.3,18.63 111.99,19.31 115.11,19.31 120.8,25 120.8,48.82 128.43,56.45 128.43,62.65 129.08,63.3 129.08,66.33 128.77,66.64 128.77,66.64 128.71,66.7 128.71,66.71 128.67,66.75 128.67,76.09 119.3,85.46 115.91,85.46 109.1,92.27 109.1,94.81 108.74,95.17 108.51,95.17 v1(108.44,95.24) ; v1(104.65,95.77) 100.67,99.76 100.67,101.17 99.28,102.56 99.28,108.27 101.19,110.18 101.19,119.72 v1(98.27,122.64) 97.96,122.64 97.43,122.12 97.43,118.14 96.96,115.86 96.96,115.26 97.37,114.86 97.37,113.45 96.21,112.29 93.8,112.29 93.06,113.03 91.08,113.03 88.47,110.41 88.47,105.82 85.55,102.91 81.55,102.91 78.81,102.37 78.24,101.8 77.89,101.8 77.15,101.06 72.33,101.06 70.76,99.49 v1(70.76,99.42)
  IN3 w0.114: v1(132.09,42.27) 132.09,40.23 131.63,39.77 131.63,38.44 127.52,34.33 126.74,34.33 123.53,31.12 123.53,28.14 122.4,27.01 122.4,22.88 116.71,17.19 113.89,17.19 113.52,16.82 112.71,16.82 112.63,16.91 110.23,16.91 109.81,17.33 108.57,17.33 108.15,16.91 105.45,16.91 v1(104.91,16.37) ; v1(104.65,95.77) 105.87,95.77 106.41,95.24 v1(108.44,95.24)
  BOTTOM w0.102: R185.1 133.24,41.68 132.66,42.27 v1(132.09,42.27) ; R60.1 71.13,98.02 70.49,98.66 70.49,99.15 v1(70.76,99.42)
LPC_CPU_NODE1_LAD3_R: length 12.6
  TOP w0.102: v1(72.63,85.38) 72.69,85.44 73.3,85.44 73.36,85.38 U2.H41
  BOTTOM w0.102: v1(72.63,85.38) 72.63,85.62 72.32,85.93 72.32,87.65 v2(73.05,89.65) 73.27,90.21 73.27,91.32 73.12,92.65 72.89,93.36 72.89,94.13 72.68,94.34 71.53,95.46 R60.2
LPC_CPU_NODE1_LAD3_SIO: length 7.6
  TOP w0.102: v1(138.11,42.47) 138.02,42.39 U43.44
  BOTTOM w0.102: v1(138.11,42.47) 137.92,42.28 136.23,42.28 135.63,41.68 R185.2
LPC_CPU_NODE1_R_CLKOUT0: length 9.9
  TOP w0.102: U2.B44 75.15,89.92 75.35,90.11 75.35,92.77 76.29,93.72 76.82,93.72 76.93,93.83 77.19,93.83 78.21,94.84 v1(78.21,95.05) 78.21,95.18 79.27,96.24 R73.1
LPC_CPU_NODE1_R_CLKOUT1: length 10.7
  TOP w0.102: U2.C45 75.64,88.57 75.46,88.75 75.46,89.8 75.8,90.13 75.8,90.6 v1(75.91,90.71) 75.8,90.82 75.8,92.05 76.99,93.25 77.43,93.25 79.69,95.5 79.69,95.71 R72.1
LPC_CPU_TPM_LAD0: length 4.5
  TOP w0.102: J1.5 109.04,13.84 109.39,14.19 v1(109.39,15.22) 109.7,15.54 R190.2
LPC_CPU_TPM_LAD1: length 4.6
  TOP w0.102: J1.7 107.04,13.75 107.54,14.25 v1(107.54,15.49) R191.2
LPC_CPU_TPM_LAD2: length 4.3
  TOP w0.102: J1.9 105.04,13.82 105.33,14.11 v1(105.33,15.35) 105.42,15.45 R192.2
LPC_CPU_TPM_LAD3: length 4.5
  TOP w0.102: J1.11 103.04,13.53 103.96,14.45 v1(103.96,15.25) 103.81,15.4 R189.2
M1_DQ_NODE1_DQ0: length 68.5
  TOP w0.102: v1(59.23,65.22) 59.23,65.35 59.72,65.84 U2.BG13
  TOP w0.165: J2.5 53.58,25.68 v1(53.76,25.86)
  IN3 w0.102: v1(59.23,65.22) 58.61,65.22 57.68,64.28 56.46,64.28 53.59,61.41
  IN3 w0.203: v1(53.76,25.86) 53.36,26.26 53.36,27.96 52.74,28.58 52.35,28.58 52.13,28.36 52.13,28.11 51.92,27.9 51.61,27.9 51.4,28.11 51.4,28.36 51.18,28.58 50.88,28.58 50.66,28.36 50.66,28.11 50.44,27.9 50.14,27.9 49.92,28.11 49.92,28.36 49.71,28.58 49.4,28.58 49.19,28.36 49.19,28.11 48.97,27.9 48.67,27.9 48.45,28.11 48.45,28.36 48.23,28.58 47.93,28.58 47.71,28.36 47.71,28.11 47.5,27.9 47.19,27.9 46.98,28.11 46.98,28.36 46.76,28.58 46.06,28.58 42.97,31.67 42.97,54.83 48.22,60.07 51.6,60.07 51.8,60.28 51.8,60.59 51.51,60.88 51.51,61.19 51.73,61.4 52.03,61.4 52.32,61.11 52.63,61.11 52.93,61.41 53.59,61.41
M1_DQ_NODE1_DQ1: length 68.5
  TOP w0.102: v1(63.44,66.98) 63.49,66.98 63.84,66.63 U2.BF21
  TOP w0.165: v1(54.55,23.66) 54.55,23.33 54.18,22.96 J2.7
  IN3 w0.102: 61.43,61.32 61.64,61.53 61.64,62.27 62.87,63.5 62.87,64.02 63.82,64.98 63.82,66.6 v1(63.44,66.98)
  IN3 w0.203: 61.43,61.32 61.19,61.08 61.19,60.18 60.67,59.65 60.67,59.05 59.56,57.94 59.1,57.94 54.59,53.42 51.67,53.42 50.09,51.84 50.09,47.06 49.88,46.85 48.88,46.85 48.67,46.64 48.67,43.8 48.87,43.6 49.17,43.6 49.38,43.8 49.38,45.93 49.59,46.14 49.88,46.14 50.09,45.93 50.09,42.35 58.8,33.64 58.8,26.47 57.83,25.5 57.83,24.67 57.12,23.97 55.57,23.97 55.26,23.66 v1(54.55,23.66)
M1_DQ_NODE1_DQ2: length 68.7
  TOP w0.102: U2.BG15 60.57,65.81 60.12,65.35 60.12,65.35 60.01,65.24 v1(59.95,65.24)
  TOP w0.165: J2.13 55.98,22.09 55.36,22.72 55.36,24.77 v1(54.92,25.21)
  IN3 w0.102: 53.55,60.74 54.16,61.36 54.77,61.36 55.06,61.65 55.06,62.27 56.71,63.92 58.09,63.92 58.85,64.68 59.3,64.68 59.86,65.24 v1(59.95,65.24)
  IN3 w0.203: 53.55,60.74 53.32,60.74 52.02,59.44 48.61,59.44 43.61,54.44 43.61,31.93 45.51,30.03 46.18,30.03 46.4,29.82 46.4,29.5 46.62,29.28 46.92,29.28 47.14,29.5 47.14,29.82 47.35,30.03 47.66,30.03 47.87,29.82 47.87,29.5 48.09,29.28 48.39,29.28 48.61,29.5 48.61,29.82 48.83,30.03 49.13,30.03 49.35,29.82 49.35,29.5 49.56,29.28 49.87,29.28 50.08,29.5 50.08,29.82 50.3,30.03 50.6,30.03 50.82,29.82 50.82,29.5 51.04,29.28 51.34,29.28 51.56,29.5 51.56,29.82 51.77,30.03 52.34,30.03 54.13,28.25 54.13,26.64 54.53,26.24 54.53,25.6 v1(54.92,25.21)
M1_DQ_NODE1_DQ3: length 68.5
  TOP w0.102: U2.BH19 62.65,65.46 63.01,65.1 v1(63.08,65.1)
  TOP w0.165: J2.15 56.58,22.5 56.15,22.93 56.15,24.76 v1(56.2,24.81)
  IN3 w0.102: 60.07,59.63 60.69,60.25 60.69,62.17 61.1,62.57 61.34,62.57 62.31,63.54 62.31,64.03 63.08,64.8 v1(63.08,65.1)
  IN3 w0.203: v1(56.2,24.81) 56.27,24.87 56.27,25.87 57.14,26.74 57.14,28.09 58.1,29.06 58.1,31.59 57.66,32.03 57.66,33.7 49.38,41.98 48.97,41.98 48.02,42.93 48.02,52.01 48.23,52.22 48.52,52.22 48.73,52.01 48.73,47.8 48.94,47.59 49.23,47.59 49.45,47.81 49.45,52.11 51.41,54.06 54.27,54.06 58.08,57.87 58.08,58.74 58.39,59.04 59,59.04 59.58,59.63 60.07,59.63
M1_DQ_NODE1_DQ4: length 68.7
  TOP w0.102: v1(62.95,65.82) 62.56,66.22 U2.BG19
  TOP w0.165: v1(52.47,32.46) 52.47,31.04 53.28,30.22 J2.4
  IN3 w0.102: v1(62.95,65.82) 62.43,66.34 62.43,66.57 62,67.01 61.32,67.01 60.88,66.57 60.88,64.27 58.89,62.28
  IN3 w0.203: 58.89,62.28 58.89,62.28 56.56,59.95 56.05,59.95 55,58.89 54.52,58.89 53.16,57.53 49.76,57.53 45.51,53.28 45.51,40.93 45.73,40.72 46.77,40.72 46.99,40.5 46.99,37.81 46.77,37.6 46.47,37.6 46.25,37.81 46.25,39.77 46.04,39.98 45.73,39.98 45.51,39.77 45.51,37.19 48.92,33.78 49.21,33.78 49.44,34.02 49.44,34.31 47.23,36.52 47.23,36.82 47.45,37.04 47.75,37.04 52.34,32.46 v1(52.47,32.46)
M1_DQ_NODE1_DQ5: length 68.3
  TOP w0.102: v1(63.34,66.36) 63.33,66.36 63.67,66.02 63.67,66.01 U2.BG21
  TOP w0.165: v1(53.81,32.29) 53.88,32.22 J2.6
  IN3 w0.102: v1(63.34,66.36) 62.8,66.89 62.8,67.16 61.89,68.07 61.09,68.07 60.6,67.58 60.6,64.28 59.67,63.35 58.73,63.35 58.19,62.81
  IN3 w0.203: 58.19,62.81 58.19,62.67 57.57,62.05 57.57,61.7 56.52,60.65 55.95,60.65 54.93,59.62 54.35,59.62 52.89,58.17 49.43,58.17 44.88,53.62 44.88,36.66 45.38,36.16 45.38,35.85 44.98,35.45 44.98,35.15 45.2,34.93 45.51,34.93 45.9,35.33 46.21,35.33 47.48,34.05 47.48,31.79 47.69,31.58 48.27,31.58 48.47,31.79 48.47,32.83 48.69,33.05 50.76,33.05 50.98,32.83 50.98,32.53 50.76,32.31 49.43,32.31 49.21,32.09 49.21,31.79 49.43,31.57 53.1,31.57 v1(53.81,32.29)
M1_DQ_NODE1_DQ6: length 68.9
  TOP w0.102: U2.BD13 59.87,67.35 v1(59.5,66.98)
  TOP w0.165: v1(55.09,27.07) 55.59,27.57 56.35,27.57 56.88,28.1 J2.16
  IN3 w0.102: v1(59.5,66.98) 58.86,66.34 58.34,66.34 56.61,64.61 55.97,64.61
  IN3 w0.203: v1(55.09,27.07) 55.09,26.63 55.5,26.22 55.5,24.93 55.1,24.53 53.15,24.53 52.95,24.73 52.95,25.56 52.53,25.98 52.53,26.39 51.68,27.23 46.51,27.23 42.34,31.4 42.34,55.31 47.74,60.71 49.92,60.71 51.39,62.19 52.47,62.19 52.94,62.66 54.03,62.66 55.97,64.61
M1_DQ_NODE1_DQ7: length 68.4
  TOP w0.102: v1(59.5,66.22) 59.87,66.59 U2.BF13
  TOP w0.165: v1(56.41,26.85) 56.41,27 57.48,28.07 J2.18
  IN3 w0.102: 57.29,62.86 57.59,62.86 58.48,63.74 58.78,63.74 59.67,64.63 60.03,64.63 60.36,64.95 60.36,65.41 59.55,66.22 v1(59.5,66.22)
  IN3 w0.203: 57.29,62.86 56.79,62.35 56.79,61.65 56.48,61.34 55.91,61.34 54.81,60.24 54.07,60.24 52.63,58.8 49.12,58.8 44.24,53.93 44.24,32.25 44.63,31.86 44.94,31.86 45.57,32.5 45.88,32.5 46.09,32.28 46.09,31.98 45.46,31.34 45.46,31.04 45.73,30.77 52.72,30.77 53.81,29.68 56.16,29.68 56.41,29.44 56.41,28.92 56.19,28.7 55.08,28.7 54.86,28.49 54.86,28.18 55.08,27.97 56.19,27.97 56.41,27.75 v1(56.41,26.85)
M1_DQ_NODE1_DQ8: length 67.4
  TOP w0.102: U2.BM13 59.92,63.13 59.69,62.9 59.55,62.9 58.84,62.2 v1(58.84,61.24)
  TOP w0.165: J2.19 57.78,22.66 57.18,23.27 v1(57.18,23.36)
  IN1 w0.203: v1(58.84,61.24) 56.62,61.24 55.81,60.43 52.22,60.43 51.59,59.79 51.2,59.79 50.99,60 50.99,60.23 50.78,60.44 50.49,60.44 50.28,60.23 50.28,60 50.07,59.79 47.14,59.79 46.1,58.76 46.1,58.46 46.32,58.24 46.32,57.95 46.11,57.74 45.82,57.74 45.6,57.96 45.3,57.96 44.32,56.97 44.32,39.19 50.53,32.98 50.53,31.76 52.87,29.41 54.33,29.41 54.53,29.2 54.53,28.32 54.74,28.11 55.04,28.11 55.25,28.32 55.25,29.2 55.45,29.41 56.7,29.41 57.12,28.99 57.12,27.53 57.79,26.86 57.79,25.38 57.71,25.29 57.71,24.04 57.18,23.51 v1(57.18,23.36)
M1_DQ_NODE1_DQ9: length 67.5
  TOP w0.102: 63.48,60.87 63.48,61.96 63.48,61.97 63.48,63.5 63.08,63.9 U2.BL19
  TOP w0.165: v1(58.52,25.1) 58.16,24.74 58.16,23.36 58.38,23.13 J2.21 ; 63.48,60.87 63.48,59.32 62.61,58.46 v1(58.78,58.46)
  IN1 w0.203: v1(58.52,25.1) 58.52,27.32 58.72,27.52 58.72,28.08 57.96,28.83 57.96,32.81 56.97,33.81 56.1,33.81 55.67,33.37 54.74,33.37 54.3,33.81 51.6,33.81 46.36,39.05 46.36,55.11 47.76,56.5 47.76,57.21 48.88,58.34 52.59,58.34 53.03,58.78 58.45,58.78 v1(58.78,58.46)
M1_DQ_NODE1_DQ10: length 67.3
  TOP w0.102: v1(57.25,58.16) 57.46,58.16 58.35,59.05 59.07,59.05 59.41,59.39 59.41,59.94 59.59,60.13 59.59,61.96 60.04,62.41 60.04,62.67 U2.BN14
  TOP w0.165: J2.31 61.38,22.77 61.16,22.99 61.16,24.48 v1(60.32,25.32)
  IN1 w0.203: v1(57.25,58.16) 54.3,58.16 53.58,57.44 51.19,57.44 50.6,56.84 50.3,56.84 49.44,57.7 49.15,57.7 48.94,57.5 48.94,57.2 49.8,56.34 49.8,56.04 49.59,55.84 49.3,55.84 48.79,56.34 48.49,56.34 48.29,56.13 48.29,55.84 48.79,55.33 48.79,55.04 48.59,54.83 48.29,54.83 47.78,55.34 47.49,55.34 47.28,55.13 47.28,54.83 47.79,54.33 47.79,54.03 47,53.24 47,39.53 52.09,34.44 57.37,34.44 59.12,32.69 59.12,32.12 58.7,31.7 58.7,29.24 59.51,28.43 59.51,27.32 59.28,27.09 59.28,26.28 60.14,25.43 60.22,25.43 v1(60.32,25.32)
M1_DQ_NODE1_DQ11: length 67.3
  TOP w0.102: v1(62.4,59.11) 62.98,59.68 62.98,61.82 63.25,62.1 63.25,63.31 63.01,63.55 U2.BM18
  TOP w0.165: J2.33 v1(61.98,23.33)
  IN1 w0.102: 59.57,56.11 59.62,56.11 60.85,57.34 60.85,57.63 62.32,59.1 62.4,59.1 v1(62.4,59.11)
  IN1 w0.203: v1(61.98,23.33) 61.98,23.59 62.39,23.99 62.95,23.99 63.63,24.67 63.63,26.23 64.21,26.81 64.21,32.85 58.13,38.93 56.12,38.93 54.05,41.01 52.71,41.01 51.57,42.14 51.57,48.06 51.93,48.42 51.93,48.75 51.57,49.1 51.57,50.13 54.66,53.21 54.94,53.21 55.16,52.99 55.16,52.71 52.38,49.93 52.38,49.64 52.59,49.43 52.89,49.43 59.57,56.11
M1_DQ_NODE1_DQ12: length 68
  TOP w0.102: U2.BP13 59.25,62.11 59.25,60.72 58.76,60.24 58.76,59.81 v1(58.65,59.71)
  TOP w0.165: v1(57.18,30.75) 58.2,30.75 58.68,30.26 J2.22
  IN1 w0.203: v1(57.18,30.75) 57.18,30.69 56.62,30.12 53.61,30.12 53.38,30.35 53.38,30.91 53.13,31.16 52.04,31.16 51.29,31.92 51.29,33.12 45.73,38.68 45.73,40.06 45.52,40.27 45.22,40.27 45.01,40.48 45.01,40.77 45.22,40.98 45.52,40.98 45.73,41.19 45.73,41.49 45.52,41.69 45.22,41.69 45.01,41.9 45.01,42.2 45.22,42.41 45.52,42.41 45.73,42.61 45.73,42.91 45.52,43.12 45.22,43.12 45.01,43.32 45.01,43.62 45.22,43.83 45.52,43.83 45.73,44.04 45.73,44.33 45.52,44.54 45.22,44.54 45.01,44.75 45.01,45.04 45.22,45.25 45.52,45.25 45.73,45.46 45.73,45.75 45.52,45.96 45.22,45.96 45.01,46.17 45.01,46.46 45.22,46.67 45.52,46.67 45.73,46.88 45.73,47.18 45.52,47.38 45.22,47.38 45.01,47.59 45.01,47.89 45.22,48.09 45.52,48.09 45.73,48.3 45.73,48.6 45.52,48.81 45.22,48.81 45.01,49.01 45.01,49.31 45.22,49.52 45.52,49.52 45.73,49.73 45.73,50.02 45.52,50.23 45.22,50.23 45.01,50.44 45.01,50.73 45.22,50.94 45.52,50.94 45.73,51.15 45.73,51.44 45.52,51.65 45.22,51.65 45.01,51.86 45.01,52.15 45.22,52.36 45.52,52.36 45.73,52.57 45.73,52.86 45.52,53.07 45.22,53.07 45.01,53.28 45.01,53.58 45.22,53.78 45.52,53.78 45.73,53.99 45.73,54.5 45.52,54.71 45.19,54.71 44.99,54.92 44.99,55.21 45.19,55.42 45.52,55.42 45.93,55.84 45.93,56.13 45.67,56.39 45.67,56.69 45.88,56.89 46.17,56.89 46.43,56.63 46.73,56.63 46.96,56.87 46.96,57.32 47.33,57.69 47.33,57.98 46.97,58.34 46.97,58.64 47.18,58.84 47.47,58.84 47.83,58.49 48.13,58.49 48.7,59.06 52.02,59.06 52.45,59.49 56.71,59.49 56.92,59.7 56.92,60.25 57.13,60.46 57.42,60.46 57.63,60.25 57.63,60.25 57.93,59.94 58.42,59.94 v1(58.65,59.71)
M1_DQ_NODE1_DQ13: length 67.6
  TOP w0.102: U2.BN19 62.92,62.42 v1(62.5,62)
  TOP w0.165: v1(57.16,25.85) 57.47,26.15 57.73,26.15 59.28,27.7 J2.24
  IN1 w0.203: v1(57.16,25.85) 56.94,26.07 54.9,26.07 53.74,27.24 53.74,28.2 53.25,28.7 52.69,28.7 49.74,31.64 49.74,32.86 43.68,38.92 43.68,57.28 46.84,60.43 49.49,60.43 50.31,61.25 53.8,61.25 54.09,61.55 54.09,61.96 54.54,62.4 55.03,62.4 55.35,62.72 55.74,62.72 56.06,62.4 56.45,62.4 56.77,62.72 57.16,62.72 57.48,62.4 59.56,62.4 59.77,62.61 59.77,63.21 59.97,63.42 60.27,63.42 60.48,63.21 60.48,62.61 60.69,62.4 62.09,62.4 v1(62.5,62)
M1_DQ_NODE1_DQ14: length 67.2
  TOP w0.102: v1(61.59,63.49) 61.21,63.87 60.9,63.87 60.76,64 U2.BL14
  TOP w0.165: J2.34 62.28,27.17 v1(61.94,26.83)
  IN1 w0.102: 58.11,56.84 58.44,57.18 59.18,57.18 60.64,58.64 60.64,59.92 62.3,61.57 62.66,61.57 62.93,61.85 62.93,62.36 61.8,63.49 v1(61.59,63.49)
  IN1 w0.203: v1(61.94,26.83) 61.95,26.83 62.29,27.17 62.29,28.35 62.94,29 62.94,29.55 62.74,29.75 62.19,29.75 61.98,29.96 61.98,30.26 62.19,30.46 62.74,30.46 62.94,30.67 62.94,32.32 58.42,36.85 55.07,36.85 51.65,40.26 51.36,40.26 51.15,40.05 51.15,39.76 53.43,37.47 53.43,37.18 53.22,36.97 52.93,36.97 50.3,39.6 50.3,52.92 52.38,55 54.75,55 55.79,56.04 57.31,56.04 58.11,56.84
M1_DQ_NODE1_DQ15: length 67.9
  TOP w0.102: v1(62.5,60.3) 61.65,61.14 61.65,62.31 62.26,62.92 62.26,63.12 62,63.38 62,63.85 U2.BL17
  TOP w0.165: J2.36 62.88,26.99 62.83,26.94 v1(62.83,26.32)
  IN1 w0.102: v1(62.5,60.3) 61.31,59.11 61.31,58.75 60.27,57.71 60.27,57.5 59.48,56.71 59,56.71 58.81,56.52
  IN1 w0.203: v1(62.83,26.32) 62.83,26.32 62.94,26.43 62.94,27.96 63.58,28.6 63.58,32.59 58.61,37.55 57.17,37.55 56.96,37.76 56.96,38.03 56.75,38.24 56.46,38.24 56.25,38.03 56.25,37.76 56.04,37.55 55.26,37.55 54.7,38.11 54.7,38.41 55.05,38.75 55.05,39.05 54.84,39.25 54.54,39.25 54.2,38.91 53.9,38.91 53.7,39.12 53.7,39.41 54.04,39.76 54.04,40.05 53.83,40.26 53.54,40.26 53.19,39.91 52.9,39.91 50.94,41.87 50.94,52.4 52.9,54.36 53.19,54.36 53.4,54.15 53.4,53.86 51.68,52.14 51.68,51.92 51.97,51.64 52.19,51.64 54.68,54.14 54.98,54.14 55.47,53.64 55.93,53.64 56.33,54.04 56.33,54.33 55.8,54.86 55.8,55.15 56.01,55.36 56.31,55.36 56.83,54.84 57.13,54.84 58.81,56.52
M1_DQ_NODE1_DQ16: length 61.9
  TOP w0.102: U2.BH25 65.83,65.49 v1(65.45,65.87)
  TOP w0.165: J2.37 63.18,24.44 62.95,24.67 v1(62.95,24.81)
  IN3 w0.102: v1(65.45,65.87) 65.45,65.36 64.87,64.78 64.87,63.78 64.36,63.27
  IN3 w0.203: 64.36,63.27 63.6,62.51 63.6,60.05 63.31,59.76 63.31,58.84 53.8,49.33 53.8,46.39 53.59,46.18 53.29,46.18 53.09,46.39 53.09,47.03 52.88,47.23 52.58,47.23 52.38,47.03 52.38,43.54 62.38,33.53 62.38,31.35 62.38,31.35 62.38,30.42 62.18,30.22 61.13,30.22 60.92,30.01 60.92,29.71 61.13,29.5 62.18,29.5 62.38,29.3 62.38,28.82 62.21,28.65 61.36,28.65 61.05,28.34 61.05,27.38 61.05,27.38 61.05,26.92 62.95,25.01 v1(62.95,24.81)
M1_DQ_NODE1_DQ17: length 62
  TOP w0.102: U2.BA25 65.82,69.27 v1(65.45,68.89)
  TOP w0.165: v1(63.85,23.18) 63.85,22.43 63.78,22.37 J2.39
  IN3 w0.102: 62,61.64 62,62.09 63.63,63.71 63.63,64.36 64.21,64.95 64.21,68.44 64.82,69.05 65.29,69.05 v1(65.45,68.89)
  IN3 w0.203: 62,61.64 62,61.07 61.9,60.96 61.9,60.15 61.15,59.4 61.15,58.49 55.05,52.38 52.32,52.38 51.11,51.17 51.11,42.84 59.88,34.06 59.88,31.73 60.16,31.45 60.16,28.14 60.38,27.92 60.38,26.57 62.95,24 63.03,24 v1(63.85,23.18)
M1_DQ_NODE1_DQ18: length 62.3
  TOP w0.102: U2.BG25 65.83,66.24 v1(65.45,66.62)
  TOP w0.165: v1(66.84,22.9) 66.78,22.84 J2.49
  IN3 w0.102: 63.79,59.39 63.79,59.73 64.74,60.67 64.74,62.95 65.39,63.61 65.39,64.07 66.06,64.74 66.06,65.27 65.86,65.47 65.86,66.21 v1(65.45,66.62)
  IN3 w0.203: 63.79,59.39 63.79,58.34 54.55,49.1 54.55,45.75 54.35,45.54 53.25,45.54 53.04,45.33 53.04,45.03 53.25,44.83 54.35,44.83 54.55,44.62 54.55,44.32 54.35,44.11 53.44,44.11 53.23,43.91 53.23,43.61 53.44,43.4 54.35,43.4 54.55,43.2 54.55,42.49 63.07,33.98 63.07,32.57 63.07,28.26 62.81,28.01 62.81,27.19 63.45,26.55 63.45,25.54 63.62,25.37 63.62,24.36 64.99,22.99 66.74,22.99 v1(66.84,22.9)
M1_DQ_NODE1_DQ19: length 62.5
  TOP w0.102: v1(66.92,68.87) 66.91,68.87 66.55,68.5 U2.BB26
  TOP w0.165: v1(67.96,23.76) 67.57,23.38 67.57,22.86 67.38,22.67 J2.51
  IN3 w0.102: v1(66.92,68.87) 68.43,67.36 68.43,65.3 68.94,64.8 69.15,64.58
  IN3 w0.203: 69.15,64.58 69.42,64.32 69.42,62.61 68.28,61.47 68.28,55.23 62.46,49.42 62.46,48.22 62.68,48 63.27,48 63.48,47.79 63.48,47.48 63.27,47.27 62.68,47.27 62.46,47.05 62.46,46.75 62.68,46.53 63.27,46.53 63.48,46.32 63.48,46.01 63.27,45.79 62.68,45.79 62.46,45.58 62.46,45.27 62.68,45.06 63.27,45.06 63.48,44.84 63.48,44.54 63.27,44.32 62.68,44.32 62.46,44.11 62.46,43.8 62.68,43.59 63.27,43.59 63.48,43.37 63.48,41.62 63.27,41.41 62.82,41.41 62.61,41.21 62.61,40.91 62.82,40.7 63.27,40.7 63.48,40.49 63.48,40.01 67.52,35.97 67.52,34.17 68.56,33.13 68.56,30.51 69.62,29.46 69.62,26.9 69.62,26.9 69.62,25.49 68.09,23.97 67.96,23.84 v1(67.96,23.76)
M1_DQ_NODE1_DQ20: length 61.8
  TOP w0.165: J2.40 64.08,27.77 65.2,26.66 v1(65.99,26.66) ; v1(67.03,65.66) 67.03,65.67 66.81,65.46 U2.BH26
  IN3 w0.102: 66.34,58.38 66.34,62.79 67.38,63.83 67.38,64.51 67.03,64.86 v1(67.03,65.66)
  IN3 w0.203: v1(65.99,26.66) 66.19,26.86 66.19,28.17 66.52,28.51 66.52,28.86 66.31,29.08 65.72,29.08 65.52,29.28 65.52,29.58 65.72,29.79 66.31,29.79 66.58,30.05 66.58,31.16 65.52,32.22 65.52,34.92 59.06,41.37 59.06,42.98 58.85,43.19 57.38,43.19 57.17,43.39 57.17,43.69 57.38,43.9 58.85,43.9 59.06,44.11 59.06,44.4 58.85,44.61 58.72,44.61 58.51,44.82 58.51,45.11 58.72,45.32 58.85,45.32 59.06,45.53 59.06,50.12 59.26,50.33 59.57,50.33 59.77,50.12 59.77,48.28 59.98,48.07 60.27,48.07 60.48,48.28 60.48,51.64 60.82,51.98 61.12,51.98 61.43,51.67 61.74,51.67 61.95,51.88 61.95,52.19 61.64,52.5 61.64,52.81 65.79,56.95 65.79,57.84 66.34,58.38
M1_DQ_NODE1_DQ21: length 61.7
  TOP w0.102: U2.BB25 65.82,68.5 v1(65.45,68.13)
  TOP w0.165: J2.42 64.68,30.72 64.26,31.15 v1(61.43,31.15)
  IN3 w0.102: 63.09,62.03 63.09,62.69 63.92,63.51 63.92,64.24 64.45,64.77 64.45,65.84 64.69,66.08 64.69,66.34 64.45,66.58 64.45,67.14 64.58,67.27 64.58,67.78 64.72,67.92 65.23,67.92 65.44,68.13 v1(65.45,68.13)
  IN3 w0.203: 63.09,62.03 63.09,60.16 62.62,59.68 62.27,59.68 61.79,59.19 61.79,58.22 55.22,51.66 54.27,51.66 54.06,51.45 54.06,50.76 53.86,50.55 53.56,50.55 53.35,50.76 53.35,51.45 53.15,51.66 52.54,51.66 51.74,50.86 51.74,50.25 51.95,50.04 52.85,50.04 53.06,49.83 53.06,49.54 52.85,49.33 51.95,49.33 51.74,49.12 51.74,48.83 51.95,48.62 52.85,48.62 53.06,48.41 53.06,48.12 52.85,47.91 51.95,47.91 51.74,47.7 51.74,43.1 60.94,33.9 60.94,33.2 61.15,32.99 61.49,32.99 61.7,32.79 61.7,32.49 61.49,32.28 61.15,32.28 60.94,32.07 60.94,31.41 61.21,31.15 v1(61.43,31.15)
M1_DQ_NODE1_DQ22: length 62.4
  TOP w0.102: v5(66.94,68.22) 67.19,68.22 67.82,68.85 U2.BA29
  TOP w0.165: J2.48 66.48,27.56 66.58,27.46 66.58,26.01 v1(66.47,25.9)
  IN3 w0.102: v5(66.94,68.22) 68.15,67.02 68.15,65.15 68.78,64.51 68.78,64.13
  IN3 w0.203: v1(66.47,25.9) 67.48,24.9 68.03,24.9 68.78,25.65 68.78,29.37 67.93,30.22 67.93,32 66.89,33.04 66.89,35.51 61.83,40.57 61.83,41.67 62.03,41.88 62.37,41.88 62.58,42.09 62.58,42.38 62.37,42.59 62.03,42.59 61.83,42.8 61.83,49.71 63.96,51.84 63.96,52.14 63.57,52.53 63.57,52.82 63.78,53.03 64.07,53.03 64.46,52.64 64.76,52.64 64.97,52.85 64.97,53.14 64.57,53.54 64.57,53.83 64.78,54.04 65.08,54.04 65.47,53.64 65.76,53.64 65.97,53.85 65.97,54.15 65.58,54.54 65.58,54.84 65.79,55.04 66.08,55.04 66.48,54.65 66.77,54.65 66.98,54.86 66.98,55.15 66.58,55.55 66.58,55.84 67.33,56.58 67.33,57.93 67.64,58.24 67.64,61.75 68.78,62.89 68.78,64.13
M1_DQ_NODE1_DQ23: length 62.4
  TOP w0.102: v1(67.53,65.19) 67.53,65.55 U2.BG29
  TOP w0.165: v1(67.79,25.74) 67.79,26.3 67.08,27.01 J2.50
  IN3 w0.102: 66.69,58.35 66.69,62.25 68.3,63.86 68.3,64.43 v1(67.53,65.19)
  IN3 w0.203: 66.69,58.35 66.69,56.88 62.69,52.88 62.69,51.65 61.19,50.15 61.19,47.45 60.98,47.24 59.98,47.24 59.77,47.03 59.77,41.64 59.97,41.43 60.28,41.43 60.48,41.64 60.48,46.32 60.69,46.53 60.98,46.53 61.19,46.32 61.19,40.31 66.16,35.33 66.16,32.58 67.27,31.47 67.27,28.18 67.03,27.93 67.03,27.06 67.79,26.3 v1(67.79,25.74)
M1_DQ_NODE1_DQ24: length 61
  TOP w0.102: U2.BM22 64.43,63.29 63.84,62.7 63.84,61.47 64.17,61.14 v1(64.17,61.01)
  TOP w0.165: J2.55 68.58,23.18 v1(68.67,23.26)
  IN1 w0.102: v1(64.17,61.01) 64.17,60.18 63.72,59.73 63.72,58.81 62.7,57.79 62.7,57.11
  IN1 w0.203: 62.7,57.11 62.7,55.99 55.22,48.51 55.22,42.98 55.22,42.98 57.04,41.16 57.34,41.16 57.55,41.37 57.55,41.66 55.94,43.26 55.94,43.56 56.15,43.77 56.45,43.77 67.51,32.7 67.51,29.93 67.66,29.78 67.66,29.48 67.24,29.06 67.24,28.76 67.44,28.55 67.74,28.55 68.16,28.98 68.46,28.98 69.02,28.42 69.02,26.37 69.02,26.01 68.86,25.85 68.86,23.45 v1(68.67,23.26)
M1_DQ_NODE1_DQ25: length 61.3
  TOP w0.102: U2.BN28 67.79,62.79 67.79,60.91 v1(67.18,60.3)
  TOP w0.165: J2.57 69.18,22.16 69.04,22.31 69.04,22.97 70.15,24.08 v1(71.24,24.08)
  IN1 w0.102: v1(67.18,60.3) 67.18,60.04 66.16,59.02 65.68,59.02 65.4,58.74 65.4,58.39 65.65,58.14 65.76,58.14 66.29,57.61 66.29,57.04
  IN1 w0.203: v1(71.24,24.08) 70.89,24.42 70.89,25.89 71.5,26.49 71.5,27.27 71.69,27.46 71.69,28.55 71.69,30.63 72.43,31.36 72.43,32.97 66.29,39.12 65.92,39.48 65.92,40.08 65.72,40.28 65.12,40.28 64.81,40.59 64.81,40.89 65.02,41.1 65.65,41.1 65.86,41.3 65.86,41.6 65.65,41.81 64.23,41.81 64.02,42.01 64.02,42.31 64.23,42.52 65.56,42.52 65.76,42.72 65.76,43.03 65.56,43.23 64.81,43.23 64.6,43.44 64.6,43.73 64.81,43.94 65.45,43.94 65.66,44.15 65.66,44.44 65.45,44.65 65.24,44.65 65.03,44.86 65.03,45.15 65.24,45.36 65.58,45.36 65.79,45.57 65.79,45.87 65.58,46.07 65.28,46.07 65.07,46.28 65.07,46.58 65.28,46.78 65.7,46.78 65.91,46.99 65.91,47.29 65.7,47.5 65.39,47.5 65.18,47.7 65.18,48 65.39,48.21 65.72,48.21 65.93,48.42 65.93,48.71 65.72,48.92 64.87,48.92 64.67,49.13 64.67,49.42 64.87,49.63 66.08,49.63 66.29,49.84 66.29,50.3 65.89,50.7 65.89,50.94 66.29,51.34 66.29,57.04
M1_DQ_NODE1_DQ26: length 61.6
  TOP w0.102: U2.BN23 64.86,62.99 64.86,60.18 v1(64.24,59.56)
  TOP w0.165: v1(70.71,23.25) 70.98,22.98 J2.63
  IN1 w0.102: 63.29,56.97 63.29,57.79 64.24,58.74 64.24,59.56 v1(64.24,59.56)
  IN1 w0.203: v1(70.71,23.25) 70.28,23.25 69.78,23.75 69.78,24.22 70.18,24.63 70.18,24.96 69.78,25.37 69.78,25.7 70.18,26.1 70.18,26.43 69.78,26.84 69.78,29.21 69.58,29.4 69,29.4 68.14,30.26 68.14,32.97 57.68,43.44 57.68,48.21 57.47,48.41 57.17,48.41 56.97,48.21 56.97,44.65 56.76,44.45 56.46,44.45 56.25,44.65 56.25,48.64 56.92,49.31 57.36,49.31 57.66,49.62 57.66,50.05 63.29,55.68 63.29,56.97
M1_DQ_NODE1_DQ27: length 60.9
  TOP w0.102: v1(67.18,61.16) 67.44,61.16 67.59,61.31 67.59,62.52 67.03,63.08 67.03,63.34 U2.BM27
  TOP w0.165: v1(71.75,23.19) 71.58,23.02 J2.65
  IN1 w0.102: v1(67.18,61.16) 67.18,60.9 67.19,60.9 67.7,60.39 67.7,58.82 68.19,58.32 68.19,57.68
  IN1 w0.203: v1(71.75,23.19) 71.51,22.95 71.51,22.09 71.86,21.74 72.86,21.74 72.86,21.74 73.15,22.03 73.15,22.72 73.83,23.41 73.83,23.94 75.34,25.44 76.03,25.44 76.97,24.49 77.78,24.49 77.97,24.69 77.97,25.47 78.18,25.68 78.31,25.68 78.51,25.89 78.51,26.18 78.31,26.39 78.18,26.39 77.97,26.6 77.97,27.78 78.16,27.96 78.31,27.96 78.48,28.13 78.48,28.75 78.33,28.9 76.55,28.9 76.55,28.9 76.04,28.39 74.86,28.39 74.65,28.6 74.65,33.95 69.35,39.25 69.35,48.13 69.68,48.46 69.68,49.28 68.96,50 68.96,50.61 68.19,51.37 68.19,57.68
M1_DQ_NODE1_DQ28: length 60.7
  TOP w0.102: v1(64.25,61.85) 64.19,61.9 U2.BP22
  TOP w0.165: v1(68.16,26.97) 68.28,27.09 J2.54
  IN1 w0.102: 62.03,57.05 62.03,57.65 63.38,58.99 63.38,59.92 63.68,60.23 63.68,61.28 v1(64.25,61.85)
  IN1 w0.203: v1(68.16,26.97) 67,26.97 66.56,27.4 66.56,28.61 66.36,28.82 66.06,28.82 65.86,29.02 65.86,29.32 66.06,29.53 66.36,29.53 66.56,29.74 66.56,32.75 58.79,40.52 56.78,40.52 54.59,42.72 54.59,46.86 54.38,47.07 54.08,47.07 53.87,46.86 53.87,42.8 53.67,42.6 53.37,42.6 53.16,42.8 53.16,47.35 62.03,56.22 62.03,57.05
M1_DQ_NODE1_DQ29: length 61.1
  TOP w0.102: U2.BL28 67.43,63.66 68,63.09 68,60.4 67.18,59.58 v1(67.18,58.57)
  TOP w0.165: J2.56 68.88,28.09 v1(71.53,25.44)
  IN1 w0.102: v1(67.18,58.57) 67.18,58.47 67.56,58.1 67.56,57.56
  IN1 w0.203: 67.56,57.56 67.56,50.72 67.77,50.52 68.11,50.52 68.32,50.31 68.32,50.01 68.11,49.8 67.77,49.8 67.56,49.6 67.56,49.08 67.79,48.85 68.17,48.85 68.54,49.23 68.54,49.22 68.84,49.22 69.04,49.02 69.04,48.72 68.7,48.38 68.7,38.73 73.98,33.45 73.98,30.84 73.76,30.63 73.61,30.63 73.39,30.41 73.39,30.1 73.61,29.89 73.76,29.89 73.98,29.67 73.98,29.37 73.76,29.15 73.29,29.15 73.09,28.95 73.09,28.62 73.29,28.42 73.76,28.42 73.98,28.2 73.98,27.86 74.22,27.62 76.91,27.62 77.12,27.41 77.12,26.43 76.85,26.16 75.03,26.16 74.19,25.32 73.41,25.32 73.19,25.1 73.19,24.31 72.98,24.09 72.67,24.09 72.46,24.31 72.46,25.24 72.25,25.44 v1(71.53,25.44)
M1_DQ_NODE1_DQ30: length 60.9
  TOP w0.102: U2.BL23 65.25,63.72 65.25,59.09 v1(64.24,58.09)
  TOP w0.165: v1(70.62,27.56) 70.62,27.56 70.79,27.39 71.58,27.39 71.88,27.69 J2.66
  IN1 w0.102: v1(64.24,58.09) 63.9,57.74 63.9,56.78
  IN1 w0.203: v1(70.62,27.56) 70.95,27.89 70.95,28.34 70.59,28.7 70.59,29.01 70.95,29.38 70.95,29.84 70.72,30.07 69.29,30.07 68.81,30.55 68.81,32.36 68.81,32.36 68.81,33.2 59.27,42.74 59.27,43.11 59.73,43.57 59.73,49.48 59.53,49.68 59.23,49.68 59.02,49.48 59.02,44.24 58.81,44.03 58.52,44.03 58.31,44.24 58.31,49.8 63.9,55.38 63.9,56.78
M1_DQ_NODE1_DQ31: length 61.1
  TOP w0.102: U2.BL26 66.31,63.55 66.73,63.14 66.73,59.44 v1(65.86,58.57)
  TOP w0.165: J2.68 72.48,26.37 v1(72.43,26.32)
  IN1 w0.102: 66.92,57.56 66.92,57.83 66.18,58.57 v1(65.86,58.57)
  IN1 w0.203: 66.92,57.56 66.92,48.82 68.02,47.72 68.02,40.29 67.82,40.08 67.51,40.08 67.31,40.29 67.31,47.31 67.1,47.52 66.81,47.52 66.6,47.31 66.6,39.76 73.2,33.16 73.2,31.17 72.43,30.39 v1(72.43,26.32)
M1_DQ_NODE1_DQ32: length 60.1
  TOP w0.102: v1(80.68,60.21) 80.52,60.37 80.52,61.03 79.43,62.12 79.43,62.95 79.18,63.2 79.18,63.41 79.09,63.49 U2.BM52
  TOP w0.165: J2.133 94.38,22.53 v1(94.35,22.57)
  IN3 w0.203: v1(80.68,60.21) 80.68,59.97 79.44,58.73 79.44,42.94 82,40.39 82,37.98 85.83,34.14 86.13,34.14 86.33,34.35 86.33,34.65 84.92,36.06 84.92,36.34 85.14,36.56 85.43,36.56 87.8,34.19 87.8,33.24 88.37,32.67 88.61,32.67 89.26,32.01 89.26,31.78 89.26,27.95 89.9,27.31 89.9,23.01 91.09,21.82 92.33,21.82 92.87,22.36 92.87,22.85 93.12,23.1 93.81,23.1 v1(94.35,22.57)
M1_DQ_NODE1_DQ33: length 59.9
  TOP w0.102: U2.BM58 82.44,63.27 81.88,62.71 81.88,61.22 v1(81.28,60.62)
  TOP w0.165: J2.135 94.98,23.19 v1(94.67,23.5)
  IN3 w0.203: v1(94.67,23.5) 94.72,23.55 94.72,24.34 94.08,24.98 94.08,25.5 91.87,27.72 90.97,27.72 90.31,28.38 90.31,31.32 91.41,32.43 91.41,33.17 91.2,33.38 90.45,33.38 90.24,33.59 90.24,33.88 90.45,34.09 91.2,34.09 91.41,34.3 91.41,35.35 91.2,35.56 87.91,35.56 84.16,39.31 83.86,39.31 83.65,39.1 83.65,38.81 84.36,38.11 84.36,37.81 84.15,37.6 83.85,37.6 82.65,38.81 82.65,39.1 83.36,39.82 83.36,40.11 80.08,43.39 80.08,58.3 81.12,59.34 81.12,59.82 81.28,59.98 v1(81.28,60.62)
M1_DQ_NODE1_DQ34: length 59.9
  TOP w0.102: v1(79.88,62.38) 79.9,62.4 U2.BN53
  TOP w0.165: v1(99.17,25.24) 99.17,24.98 98.69,24.49 98.69,24.49 98.41,24.21 98.41,23.36 97.98,22.94 97.98,20.95 J2.145
  IN3 w0.102: 81.43,65.61 80.87,65.61 79.22,63.97 79.22,63.03 79.39,62.87 79.39,62.87 v1(79.88,62.38)
  IN3 w0.203: v1(99.17,25.24) 99.1,25.31 99.1,29.54 98.37,30.26 98.37,38.75 98.37,38.75 98.37,39 93.71,43.66 93.71,43.82 93.71,44.12 93.44,44.39 92.98,44.39 92.71,44.66 92.71,44.83 92.71,45.12 92.43,45.39 91.97,45.39 91.3,46.07 91.3,47.84 85.9,53.23 85.9,59.3 86.15,59.55 86.15,61.72 86.2,61.77 86.21,61.77 86.21,63.02 84.85,64.38 83,64.38 81.77,65.61 81.43,65.61
M1_DQ_NODE1_DQ35: length 59.5
  TOP w0.102: U2.BN57 82.07,63.37 82.07,63.67 82.2,63.81 82.2,63.99 v1(82.37,64.15)
  TOP w0.165: v1(98.53,22.52) 98.58,22.46 J2.147
  IN3 w0.102: v1(82.37,64.15) 83.1,63.42 84.49,63.42 85.32,62.59 85.32,61.63 85.42,61.53
  IN3 w0.203: 85.42,61.53 85.42,59.24 85.27,59.09 85.27,52.96 87.78,50.46 87.78,50.46 90.66,47.57 90.66,47.28 90.45,47.07 90.16,47.07 88.08,49.14 87.79,49.14 87.58,48.93 87.58,48.64 97.74,38.49 97.74,29.95 98.46,29.22 98.46,26.66 97.95,26.14 97.95,25.47 98.53,24.89 v1(98.53,22.52)
M1_DQ_NODE1_DQ36: length 59.7
  TOP w0.102: U2.BL57 81.5,63.58 81.5,63.01 81.62,62.9 81.62,61.88 81.62,61.66 81.26,61.3 v1(80.98,61.3)
  TOP w0.165: J2.134 94.68,27.09 95.14,26.64 v1(95.14,26.37)
  IN3 w0.203: v1(95.14,26.37) 94.6,26.37 92.4,28.57 92.4,31.3 92.08,31.63 92.08,36.06 91.86,36.28 88.35,36.28 85.88,38.75 85.88,39.05 86.39,39.55 86.39,39.84 86.18,40.05 85.88,40.05 85.38,39.55 85.08,39.55 84.88,39.76 84.88,40.05 85.38,40.55 85.38,40.85 85.17,41.06 84.88,41.06 84.37,40.55 84.08,40.55 83.87,40.76 83.87,41.06 84.37,41.56 84.37,41.86 84.17,42.06 83.87,42.06 83.37,41.56 83.07,41.56 82.86,41.77 82.86,42.06 83.37,42.57 83.37,42.86 83.16,43.07 82.86,43.07 82.36,42.57 82.07,42.57 81.86,42.77 81.86,43.07 82.36,43.57 82.36,43.87 82.15,44.08 81.86,44.08 81.36,43.57 81.06,43.57 80.85,43.78 80.85,44.07 81.36,44.58 81.36,44.87 80.71,45.52 80.71,58.04 81.6,58.92 81.6,59.62 81.77,59.78 81.77,60.85 81.37,61.25 81.04,61.25 v1(80.98,61.3)
M1_DQ_NODE1_DQ37: length 59.5
  TOP w0.102: v1(82.94,60.41) 83.26,60.73 83.26,63.1 82.97,63.39 U2.BL59
  TOP w0.165: v1(95.2,27.48) 95.28,27.57 J2.136
  IN3 w0.203: v1(95.2,27.48) 94.6,27.48 93.22,28.86 93.22,31.47 92.84,31.85 92.84,36.49 91.92,37.41 88.6,37.41 87.42,38.6 87.42,40.05 86.35,41.11 86.02,41.11 82.64,44.49 82.64,44.79 82.84,45 83.14,45 85.79,42.35 86.08,42.35 86.29,42.56 86.29,42.85 83.14,46 82.84,46 82.13,45.29 81.84,45.29 81.35,45.78 81.35,46.54 81.55,46.75 81.79,46.75 82,46.96 82,47.25 81.79,47.46 81.55,47.46 81.35,47.67 81.35,48.2 81.6,48.45 81.6,48.91 81.35,49.17 81.35,49.62 81.6,49.88 81.6,50.33 81.35,50.59 81.35,51.04 81.6,51.3 81.6,51.75 81.35,52.01 81.35,52.46 81.6,52.72 81.6,53.18 81.35,53.43 81.35,57.59 82.12,58.36 82.12,59.52 82.94,60.34 v1(82.94,60.41)
M1_DQ_NODE1_DQ38: length 59.8
  TOP w0.102: v1(79.64,63.46) 79.82,63.64 U2.BL53
  TOP w0.165: v1(97.79,27) 97.79,27 97.71,27 97.08,27.62 J2.142
  IN3 w0.102: v1(79.64,63.46) 79.64,63.46 79.64,64.05 80.24,64.65 80.81,64.65 82.3,63.17 84.06,63.17 85.09,62.14 85.09,61.7 84.96,61.57
  IN3 w0.203: 84.96,61.57 84.96,59.6 84.63,59.28 84.63,52.7 86.77,50.56 86.77,50.27 86.55,50.06 86.27,50.06 85.24,51.09 84.94,51.09 84.73,50.88 84.73,50.59 97.02,38.3 97.02,37.88 96.81,37.67 96.23,37.67 96.02,37.47 96.02,37.17 96.23,36.96 96.81,36.96 97.02,36.75 97.02,36.46 96.81,36.25 96.23,36.25 96.02,36.04 96.02,35.75 96.23,35.54 96.81,35.54 97.02,35.33 97.02,35.04 96.81,34.83 96.23,34.83 96.02,34.62 96.02,34.33 96.23,34.12 96.81,34.12 97.02,33.91 97.02,29.6 97.79,28.83 v1(97.79,27)
M1_DQ_NODE1_DQ39: length 60.4
  TOP w0.102: U2.BM54 80.33,64.11 v1(80.43,64.21)
  TOP w0.165: v1(97.05,25.95) 97.05,25.96 97.5,25.96 98.35,26.81 98.35,27.44 97.68,28.1 J2.144
  IN3 w0.102: 84.15,61.68 84.15,62.58 83.9,62.83 82.21,62.83 81.59,63.45 80.76,63.45 80.43,63.79 v1(80.43,64.21)
  IN3 w0.203: v1(97.05,25.95) 97.05,28.5 96.18,29.38 96.18,30.4 95.96,30.61 95.96,31.69 95.36,32.29 95.36,39.06 94.44,39.98 94.14,39.98 93.82,39.67 93.53,39.67 93.32,39.87 93.32,40.17 93.64,40.49 93.64,40.78 93.43,40.99 93.13,40.99 92.82,40.67 92.52,40.67 92.31,40.88 92.31,41.17 92.63,41.49 92.63,41.79 92.42,42 92.13,42 91.81,41.68 91.52,41.68 91.31,41.89 91.31,42.18 91.63,42.5 91.63,42.79 91.42,43 91.12,43 90.55,42.43 90.26,42.43 90.05,42.64 90.05,42.94 90.62,43.51 90.62,43.8 90.41,44.01 90.12,44.01 89.69,43.58 89.39,43.58 89.18,43.79 89.18,44.08 89.61,44.51 89.61,44.81 89.41,45.01 89.11,45.01 88.79,44.7 88.5,44.7 88.29,44.9 88.29,45.2 88.61,45.52 88.61,45.81 84,50.42 84,59.4 84.32,59.72 84.32,61.52 84.15,61.68
M1_DQ_NODE1_DQ40: length 64.6
  TOP w0.102: U2.BH58 82.49,65.46 v1(82.85,65.82)
  TOP w0.165: v1(99.78,23.07) 99.78,23.07 J2.151
  IN1 w0.102: 83.29,64.03 83,64.31 83,65.67 82.85,65.82 v1(82.85,65.82)
  IN1 w0.203: 83.29,64.03 83.95,63.36 84.58,63.36 85.19,62.75 85.19,61.81 85.87,61.14 86.03,61.14 89.19,57.98 89.69,57.98 90,57.67 90.3,57.67 90.61,57.98 90.9,57.98 91.11,57.77 91.11,57.47 90.8,57.16 90.8,56.87 91.01,56.66 91.3,56.66 91.49,56.85 91.78,56.85 91.99,56.64 91.99,56.34 91.81,56.16 91.81,55.86 95.86,51.81 96.91,51.81 98.45,50.27 98.75,50.27 98.96,50.48 98.96,50.77 97.8,51.93 97.8,52.22 98.01,52.43 98.3,52.43 101.97,48.77 101.97,38.01 99.34,35.38 99.34,32.6 100.84,31.09 100.84,24.13 v1(99.78,23.07)
M1_DQ_NODE1_DQ41: length 64.9
  TOP w0.102: U2.BB59 82.62,68.35 v1(82.25,68.72)
  TOP w0.165: v1(99.63,24.09) 99.85,24.09 100.38,23.56 J2.153
  IN1 w0.102: 81.25,63.76 81.01,64 81.01,64.21 80.32,64.89 80.32,67.43 81.11,68.21 81.68,68.21 81.99,68.52 82.05,68.52 v1(82.25,68.72)
  IN1 w0.203: v1(99.63,24.09) 100.12,24.58 100.12,29.58 99.84,29.86 98.63,29.86 98.07,30.43 98.07,36.39 99.85,38.18 99.85,45.45 99.64,45.66 99.35,45.66 99.14,45.45 99.14,44.24 98.93,44.03 98.64,44.03 98.43,44.24 98.43,47.43 98.43,47.43 89.16,56.7 88.33,56.7 83.22,61.81 83.22,62.35 82.88,62.69 82.32,62.69 81.25,63.76
M1_DQ_NODE1_DQ42: length 65.5
  TOP w0.102: U2.BG58 82.98,66.78 v1(82.98,67.26)
  TOP w0.165: J2.159 102.18,22.24 101.88,22.54 v1(101.88,23.64)
  IN1 w0.102: v1(82.98,67.26) 83.24,67.51 83.98,67.51 84.28,67.21 85.14,67.21 87.43,64.92 88.57,64.92 88.75,64.73
  IN1 w0.203: 88.75,64.73 88.96,64.52 88.96,62.45 90.42,61 94.02,61 105.41,49.6 105.41,44.05 105.12,43.76 105.12,43.34 105.41,43.04 105.41,42.63 105.12,42.33 105.12,41.92 105.41,41.62 105.41,41.2 105.12,40.91 105.12,40.49 105.41,40.2 105.41,39.78 105.12,39.49 105.12,39.07 105.41,38.78 105.41,38.36 105.12,38.07 105.12,37.65 105.41,37.35 105.41,36.94 105.12,36.64 105.12,36.23 105.41,35.93 105.41,34.49 103.43,32.51 103.43,30.16 104.47,29.12 104.47,27.14 104.11,26.78 103.33,26.78 102.98,26.43 102.98,25.76 101.88,24.66 v1(101.88,23.64)
M1_DQ_NODE1_DQ43: length 64.7
  TOP w0.102: v1(83.74,68.69) 83.74,67.99 U2.BD60
  TOP w0.165: v1(103.05,23.1) 102.78,22.83 J2.161
  IN1 w0.102: v1(83.74,68.69) 84.7,67.73 85.31,67.73 86.91,66.13 89.23,66.13 89.45,65.9
  IN1 w0.203: 89.45,65.9 90.51,64.84 90.51,64.24 90.51,64.24 90.51,62.61 90.84,62.28 94.54,62.28 107.4,49.42 107.4,33.66 106.89,33.16 106.89,29.33 105.79,28.22 105.79,27.06 104.98,26.26 104.98,25.28 103.68,23.97 103.38,23.97 103.05,23.65 v1(103.05,23.1)
M1_DQ_NODE1_DQ44: length 65.2
  TOP w0.102: U2.BB57 81.85,68.35 v1(81.49,68.72)
  TOP w0.165: v1(98.51,25.89) 99.18,26.56 99.18,27.6 98.88,27.89 J2.148
  IN1 w0.102: v1(81.49,68.72) 81.34,68.57 81.17,68.57 79.86,67.26 79.86,66.43 79.45,66.02 79.45,64.44 80.23,63.67 80.56,63.67 81.13,63.09
  IN1 w0.203: v1(98.51,25.89) 99.47,26.85 99.47,28.01 97.43,30.05 97.43,41.85 97.64,42.06 97.94,42.06 98.14,41.85 98.14,39.47 98.35,39.26 98.65,39.26 98.85,39.47 98.85,42.56 98.65,42.77 97.64,42.77 97.43,42.98 97.43,47.54 88.9,56.07 88.07,56.07 83,61.13 82.74,61.13 82.11,61.76 82.11,62.11 81.13,63.09
M1_DQ_NODE1_DQ45: length 65.2
  TOP w0.102: v1(83.01,68.72) 83.38,68.35 U2.BB60
  TOP w0.165: v1(99.34,30.73) 99.48,30.59 J2.150
  IN1 w0.102: v1(83.01,68.72) 82.79,68.49 82.79,68.49 82.27,67.98 81.21,67.98 80.62,67.39 80.62,65.06 81.33,64.34
  IN1 w0.203: 81.33,64.34 81.48,64.34 82.48,63.35 83.23,63.35 84.17,62.41 84.17,61.8 88.63,57.34 89.43,57.34 95.8,50.97 96.09,50.97 96.27,51.15 96.57,51.15 96.77,50.94 96.77,50.65 96.59,50.47 96.59,50.18 97.14,49.63 99.15,49.63 101.12,47.66 101.12,47.36 101.13,47.36 100.92,47.15 100.62,47.15 99.04,48.74 98.74,48.74 98.53,48.53 98.53,48.24 101.33,45.44 101.33,45.12 101.12,44.91 100.69,44.91 100.49,44.71 100.49,44.41 100.69,44.2 101.12,44.2 101.33,43.99 101.33,43.7 101.12,43.49 100.69,43.49 100.49,43.28 100.49,42.99 100.69,42.78 101.12,42.78 101.33,42.57 101.33,42.28 101.12,42.07 100.69,42.07 100.49,41.86 100.49,41.57 100.69,41.36 101.12,41.36 101.33,41.15 101.33,40.86 101.12,40.65 100.69,40.65 100.49,40.44 100.49,40.14 100.69,39.94 101.12,39.94 101.33,39.73 101.33,38.28 98.7,35.65 98.7,31.37 v1(99.34,30.73)
M1_DQ_NODE1_DQ46: length 65.3
  TOP w0.102: U2.BH57 81.72,65.55 v1(81.24,66.03)
  TOP w0.165: J2.160 102.48,27.88 v1(102.06,27.46)
  IN1 w0.102: 85.38,65.69 83.87,67.2 83.54,67.2 83.13,66.79 82,66.79 81.59,66.38 81.59,66.38 v1(81.24,66.03)
  IN1 w0.203: 85.38,65.69 85.84,65.69 86.69,64.84 86.69,63.22 87.65,62.26 88.28,62.26 89.26,61.29 89.26,61.27 90.17,60.36 93.72,60.36 104.45,49.63 104.45,48.73 104.78,48.41 104.78,48.02 104.45,47.7 104.45,47.31 104.78,46.99 104.78,46.6 104.45,46.27 104.45,45.89 104.78,45.56 104.78,45.18 104.45,44.85 104.45,34.46 104.03,34.04 103.73,34.04 103.23,34.54 102.94,34.54 102.73,34.33 102.73,34.04 103.23,33.54 103.23,33.24 102.75,32.76 102.75,31.61 102.54,31.4 101.79,31.4 101.59,31.19 101.59,30.9 101.79,30.69 102.54,30.69 102.75,30.48 102.75,29.91 102.54,29.7 101.75,29.7 101.54,29.49 101.54,29.2 101.75,28.99 103.04,28.99 103.24,28.79 103.24,28.37 103.04,28.16 102.2,28.16 102.06,28.03 v1(102.06,27.46)
M1_DQ_NODE1_DQ47: length 64.8
  TOP w0.102: U2.BE57 81.72,67.31 v1(81.51,67.53)
  TOP w0.165: v1(104.81,32.54) 104.54,32.54 103.08,31.08 J2.162
  IN1 w0.102: 89.04,65.26 88.48,65.82 86.87,65.82 85.22,67.47 84.43,67.47 84.01,67.9 82.93,67.9 82.73,67.69 81.67,67.69 v1(81.51,67.53)
  IN1 w0.203: 89.04,65.26 89.74,64.56 89.74,62.66 90.76,61.63 94.28,61.63 106.05,49.87 106.05,48.59 106.25,48.38 106.55,48.38 106.76,48.17 106.76,47.88 106.55,47.67 106.25,47.67 106.05,47.46 106.05,47.17 106.25,46.96 106.55,46.96 106.76,46.75 106.76,46.46 106.55,46.25 106.25,46.25 106.05,46.04 106.05,45.75 106.25,45.54 106.55,45.54 106.76,45.33 106.76,45.03 106.55,44.83 106.25,44.83 106.05,44.62 106.05,44.32 106.25,44.11 106.55,44.11 106.76,43.91 106.76,43.61 106.55,43.4 106.25,43.4 106.05,43.2 106.05,42.9 106.25,42.69 106.55,42.69 106.76,42.48 106.76,42.19 106.55,41.98 106.25,41.98 106.05,41.77 106.05,41.48 106.25,41.27 106.55,41.27 106.76,41.06 106.76,40.77 106.55,40.56 106.25,40.56 106.05,40.35 106.05,40.06 106.25,39.85 106.55,39.85 106.76,39.64 106.76,39.34 106.55,39.14 106.25,39.14 106.05,38.93 106.05,38.63 106.25,38.43 106.55,38.43 106.76,38.22 106.76,37.92 106.55,37.71 106.25,37.71 106.05,37.51 106.05,37.21 106.25,37 106.55,37 106.76,36.79 106.76,36.5 106.55,36.29 106.25,36.29 106.05,36.08 106.05,35.58 106.41,35.22 106.41,34.87 106.05,34.5 106.05,33.77 104.82,32.54 v1(104.81,32.54)
M1_DQ_NODE1_DQ48: length 64
  TOP w0.102: v1(87.27,64.31) 87.41,64.45 87.41,66.97 87.12,67.26 86.24,67.26 U2.BD65
  TOP w0.165: v1(104.01,23.08) 104.01,22.43 104.01,22.43 103.98,22.4 J2.165
  IN3 w0.102: v1(87.27,64.31) 86.73,63.77 86.73,62.41 86.92,62.22
  IN3 w0.203: 86.92,62.22 86.92,53.65 92.31,48.26 92.31,46.96 94.84,44.43 94.84,44.08 99.56,39.36 99.56,32.7 100.11,32.15 100.11,26.23 100.23,26.11 100.23,26.06 100.48,25.81 100.48,22.9 100.21,22.64 100.21,21.33 100.49,21.05 101.42,21.05 101.63,21.26 101.63,22.35 101.84,22.56 102.13,22.56 102.34,22.35 102.34,21.26 102.55,21.05 103.77,21.05 104.01,21.29 v1(104.01,23.08)
M1_DQ_NODE1_DQ49: length 63.8
  TOP w0.102: U2.AY65 86.02,69.61 86.1,69.54 87.18,69.54 88.86,67.86 88.86,66.97 88.62,66.73 v1(88.62,66.6)
  TOP w0.165: v1(105.93,25.36) 104.58,24.01 104.58,20.95 J2.167
  IN3 w0.203: v1(105.93,25.36) 105.93,26.26 104.92,27.27 104.92,27.85 104.71,28.07 104.42,28.07 104.2,28.29 104.2,28.59 104.42,28.81 104.71,28.81 104.92,29.02 104.92,29.6 104.32,30.2 104.32,39.14 104.69,39.51 105,39.51 105.23,39.74 105.23,42.32 103.98,43.57 103.67,43.57 103.47,43.36 103.16,43.36 102.95,43.58 102.95,43.89 103.15,44.09 103.15,44.39 102.94,44.61 102.63,44.61 102.43,44.41 102.12,44.41 101.91,44.62 101.91,44.93 102.11,45.13 102.11,45.43 101.2,46.35 100.9,46.35 100.82,46.26 100.53,46.26 100.32,46.47 100.32,46.77 100.4,46.85 100.4,47.14 99.88,47.66 98.49,47.66 90.55,55.6 90.55,59.09 89.72,59.93 89.72,65.07 88.62,66.17 v1(88.62,66.6)
M1_DQ_NODE1_DQ50: length 64
  TOP w0.102: U2.BE64 85.52,66.85 86.03,66.33 86.34,66.33 86.59,66.09 86.59,63.19 86.98,62.81
  TOP w0.165: J2.177 107.58,22.99 107.58,23.78 107.72,23.92 v1(107.72,23.92) ; v1(91.1,62.8) 90.58,62.28 87.51,62.28 86.98,62.81
  IN3 w0.203: v1(91.1,62.8) 91.29,62.62 91.29,60.3 93.59,57.99 93.59,57.47 93.11,56.99 93.11,56.68 93.33,56.47 93.63,56.47 94.12,56.95 94.42,56.95 94.64,56.74 94.64,56.43 94.15,55.95 94.15,55.64 94.37,55.43 94.67,55.43 95.16,55.91 95.46,55.91 95.68,55.69 95.68,55.39 95.19,54.9 95.19,54.6 95.51,54.29 95.8,54.29 96.18,54.67 96.48,54.67 96.69,54.46 96.69,54.16 96.31,53.78 96.31,53.49 106.55,43.25 106.55,38.11 106.06,37.62 106.06,27.17 106.72,26.51 106.72,25.72 107.72,24.72 107.72,23.92 v1(107.72,23.92)
M1_DQ_NODE1_DQ51: length 63.7
  TOP w0.102: U2.AW62 84.46,70.53 84.46,70.89 84.61,71.04 85.95,71.04 86.12,70.87 87.04,70.87 87.42,70.48 87.97,70.48 88.25,70.2
  TOP w0.165: v1(91.45,65.62) 90.43,66.65 90.43,68.03 88.25,70.2 ; v1(108.68,25.16) 108.68,24.45 108.67,23.51 108.18,23.02 J2.179
  IN3 w0.203: v1(108.68,25.16) 108.29,25.16 107.53,25.92 107.53,26.62 106.69,27.46 106.69,37.36 107.33,38 107.33,43.36 97.42,53.27 97.42,55.18 91.93,60.68 91.93,65.15 v1(91.45,65.62)
M1_DQ_NODE1_DQ52: length 63.6
  TOP w0.102: v1(88.35,67.31) 88.35,67.89 86.97,69.27 85.24,69.27 U2.AY63
  TOP w0.165: v1(105.34,31.48) 105.09,31.48 104.28,30.67 J2.166
  IN3 w0.102: v1(88.35,67.31) 88.53,67.31 89.17,66.68
  IN3 w0.203: 89.17,66.68 90.44,65.4 90.44,65.08 90.65,64.87 91.03,64.87 91.24,64.66 91.24,64.36 91.03,64.16 90.65,64.16 90.44,63.95 90.44,60.1 91.19,59.36 91.19,58.69 91.39,58.48 92.02,58.48 92.23,58.27 92.23,57.98 92.02,57.77 91.39,57.77 91.19,57.56 91.19,55.86 91.56,55.49 91.87,55.49 92.27,55.9 92.58,55.9 92.8,55.68 92.8,55.38 92.39,54.97 92.39,54.66 92.6,54.45 92.91,54.45 93.32,54.86 93.62,54.86 93.84,54.64 93.84,54.33 93.43,53.93 93.43,53.62 93.65,53.41 93.95,53.41 94.36,53.81 94.66,53.81 94.88,53.6 94.88,53.29 94.47,52.88 94.47,52.58 94.69,52.36 94.99,52.36 95.4,52.77 95.7,52.77 95.92,52.56 95.92,52.25 95.51,51.84 95.51,51.54 95.73,51.32 96.03,51.32 96.44,51.73 96.75,51.73 96.96,51.51 96.96,51.21 96.56,50.8 96.56,50.5 96.77,50.28 97.08,50.28 97.48,50.69 97.79,50.69 98,50.47 98,50.17 97.6,49.76 97.6,49.45 98.75,48.3 100.14,48.3 105.91,42.53 105.91,38.73 105.41,38.23 105.41,31.54 v1(105.34,31.48)
M1_DQ_NODE1_DQ53: length 63.9
  TOP w0.102: 87.76,69.85 87.1,70.5 86.19,70.5 85.88,70.19 U2.AW64
  TOP w0.165: J2.168 104.88,27.84 103.51,26.46 v1(102.19,26.46) ; v1(88.18,62.99) 88.54,62.99 89.58,64.04 89.58,68.03 87.76,69.85
  IN3 w0.102: v1(88.18,62.99) 88.08,62.9 88.08,59.03 88.19,58.92 88.19,58.54
  IN3 w0.203: v1(102.19,26.46) 102.19,26.66 101.39,27.46 101.39,28.31 101.57,28.49 101.57,30.83 101.92,31.18 101.92,33.92 101.92,33.92 101.92,34.89 101.67,35.14 101.67,38.6 100.95,39.32 100.95,40.6 99.83,41.71 99.83,42.01 99.95,42.13 99.95,42.43 99.74,42.63 99.45,42.63 99.33,42.51 99.03,42.51 98.83,42.72 98.83,43.02 99.18,43.37 99.18,43.66 98.96,43.87 98.68,43.87 98.32,43.52 98.03,43.52 97.82,43.73 97.82,44.02 98.13,44.33 98.13,44.62 97.92,44.84 97.63,44.84 97.32,44.52 97.02,44.52 96.81,44.73 96.81,45.03 96.92,45.13 96.92,45.42 96.71,45.63 96.41,45.63 96.31,45.53 96.02,45.53 95.81,45.74 95.81,46.03 95.91,46.14 95.91,46.43 95.7,46.64 95.41,46.64 95.31,46.54 95.01,46.54 94.8,46.74 94.8,47.04 94.91,47.14 94.91,47.44 94.7,47.64 94.4,47.64 94.3,47.54 94,47.54 93.69,47.86 93.69,48.68 88.19,54.18 88.19,58.54
