# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 97.9,95.52 97.9,92.28 97.61,91.99 95.61,91.99 95.61,92.42 95.62,92.43 95.62,95.77 95.74,95.89 97.53,95.89
GND on TOP (solid shape): 123.89,41.13 123.89,34.54 123.46,34.11 116.71,34.11 116.59,34.23 116.59,39.44 116.59,39.44 116.59,40.99 117.16,41.56 123.46,41.56
GND on TOP (solid shape): 182.75,55.36 182.75,47.66 182.75,47.66 182.98,47.43 182.98,46.83 182.43,46.28 179.59,46.28 179.02,46.84 179.02,55.52 179.29,55.79 182.32,55.79
GND on TOP (solid shape): 31.16,149.07 31.16,147.9 30.52,147.26 30.52,138.95 30.1,138.54 28.12,138.54 27.94,138.71 27.94,147.46 29.81,149.33 30.9,149.33
GND on TOP (solid shape): 53.97,83.3 53.97,83.3 54.04,83.23 54.04,82.07 53.9,81.93 53.9,81.55 53.9,81.54 52.25,81.54 51.86,81.93 51.86,83.1 52.32,83.56 53.72,83.56
GND on TOP (solid shape): 89.39,98.07 89.39,97.69 89.08,97.38 89.05,97.38 88.96,97.29 88.96,96.39 88.85,96.28 87.58,96.28 87.54,96.31 87.54,97.95 87.76,98.17 89.29,98.17
GND on TOP (solid shape): 111.08,141.04 111.08,138.74 109.51,138.74 109.5,138.75 109.5,140.02 108.98,140.54 108.98,141.05 109.17,141.24 110.88,141.24
GND on TOP (solid shape): 114.89,117.7 114.89,114.44 115.67,113.66 116.73,113.66 116.85,113.54 116.85,104.24 116.45,103.85 113.42,103.85 112.88,104.39 112.88,117.43 113.17,117.71 114.88,117.71
GND on TOP (solid shape): 118.62,127.38 118.62,124.31 118.48,124.17 114.35,124.17 114.27,124.25 114.27,127.23 114.53,127.49 118.51,127.49
GND on TOP (solid shape): 206.23,27.37 206.23,26.05 205.99,25.82 203.94,25.82 203.84,25.92 203.81,25.96 203.8,26.01 203.8,27.47 203.95,27.62 205.97,27.62
GND on TOP (solid shape): 95.17,17.56 95.26,17.52 95.3,17.43 95.3,15.81 95.3,15.8 79.79,15.8 79.67,15.93 79.67,17.53 79.7,17.56
GND on TOP (solid shape): 131.3,26.32 131.3,22.91 131.08,22.68 130.36,22.68 130.28,22.76 130.28,23.22 130.48,23.42 130.48,25.76 130.33,25.91 130.33,26.25 130.43,26.35 131.27,26.35
GND on TOP (solid shape): 133.03,114.99 133.03,103.61 132.78,103.35 128.78,103.35 128.53,103.6 128.53,114.96 128.57,115.05 128.66,115.09 132.94,115.09
GND on TOP (solid shape): 162.78,51.3 162.78,48.49 162.53,48.24 158.69,48.24 158.42,48.5 158.42,51.36 158.46,51.45 158.55,51.49 162.59,51.49
GND on TOP (solid shape): 173.98,142.69 174.07,142.73 174.16,142.69 174.79,142.07 174.79,141.12 174.65,140.99 173.42,140.99 173.33,141.08 173.33,142.04
GND on TOP (solid shape): 181.21,91.77 181.3,91.81 181.39,91.77 182.17,90.99 182.17,90.06 182.09,89.97 180.58,89.97 180.43,90.12 180.43,90.99
GND on TOP (solid shape): 211.08,151.12 211.08,139.5 210.79,139.21 205.55,139.21 205.34,139.43 205.34,141.71 205.35,141.73 205.35,142.68 205.43,142.76 205.43,145.63 205.69,145.89 205.69,150.99 205.93,151.23 210.97,151.23
GND on TOP (solid shape): 44.05,188.74 44.05,187.18 44.01,187.09 43.92,187.06 42.95,187.06 42.93,187.03 42.4,187.03 42.23,187.2 42.23,188.66 42.42,188.85 43.93,188.85
GND on TOP (solid shape): 56.3,4.04 60.85,4.04 61.05,3.84 61.05,1.6 60.91,1.46 53.94,1.46 53.92,1.44 53.26,1.44 53.01,1.69 53.01,3.88 53.17,4.04 56.3,4.04
GND on TOP (solid shape): 60.39,17.13 60.39,13.11 60.33,13.05 57.78,13.05 57.46,12.72 57.46,11.65 57.31,11.51 55.53,11.51 55.48,11.55 55.48,16.18 56.48,17.18 60.35,17.18
GND on TOP (solid shape): 109.66,135.14 111.45,135.14 111.66,134.93 111.66,132.03 109.64,132.03 109.51,132.15 109.51,133.03 108.73,133.82 104.7,133.82 104.57,133.96 104.57,135.33 104.75,135.51 109.29,135.51
GND on TOP (solid shape): 76.98,17.11 76.98,15.23 76.81,15.07 68.2,15.07 68.19,15.06 68.03,15.22 68.02,15.22 67.75,15.49 67.75,17.18 67.79,17.27 67.88,17.31 76.78,17.31
GND on TOP (solid shape): 94.4,146.03 94.4,144.63 94.27,144.5 92.93,144.5 92.37,143.94 92.37,142.32 92.75,141.94 92.75,139.9 92.14,139.29 92.14,138.22 92.02,138.1 91.04,138.1 90.9,138.25 90.9,144.94 92.34,146.38 94.05,146.38
GND on TOP (solid shape): 26.19,114.16 26.22,114.12 26.23,114.07 26.23,104.7 26.19,104.61 26.1,104.57 21.4,104.57 21.05,104.92 21.05,114.31 21.33,114.58 25.77,114.58
GND on TOP (solid shape): 48.98,39.19 49.02,39.15 49.03,39.09 49.03,37.41 49.05,37.39 49.05,32.68 48.68,32.31 44.98,32.31 44.23,33.07 44.23,39.19 44.42,39.38 47.06,39.38 47.2,39.51 48.59,39.51
GND on TOP (solid shape): 38.46,125.66 38.46,121.13 38.17,120.84 34.11,120.84 33.95,120.99 33.95,123.58 33.78,123.74 32.35,123.74 32.24,123.85 32.24,124.21 32.24,124.21 32.24,125.86 32.27,125.9 38.23,125.9
GND on TOP (solid shape): 39.21,113.78 39.3,113.74 39.34,113.65 39.34,106.4 38.41,105.48 36.25,105.48 36.16,105.51 36.13,105.6 36.13,107.86 36.03,107.96 36.03,113.53 36.28,113.78
GND on TOP (solid shape): 27,130.08 27,129.52 26.88,129.41 26.88,129.41 25.8,128.34 25.8,126.3 25.75,126.24 24.51,126.24 24.39,126.36 24.39,129.76 24.59,129.96 25.53,129.96 25.56,129.95 25.69,129.93 25.82,129.95 25.84,129.96 25.93,129.96 26.08,130.11 26.96,130.11
GND on TOP (solid shape): 58.74,109.17 58.74,108.92 59.3,108.36 59.3,107.93 59.31,107.91 59.31,106.84 59.29,106.82 58.36,106.82 58.16,107.02 58.16,107.97 58.03,108.1 58.03,109.07 57.97,109.13 57.04,109.16 57.04,110.78 57.06,110.8 58.74,110.8
GND on TOP (solid shape): 82.98,7.26 82.98,5.39 83.54,4.83 83.54,4.39 83.55,4.38 83.55,3.31 83.53,3.29 82.6,3.29 82.4,3.49 82.4,4.44 82.27,4.56 82.27,5.54 82.21,5.6 81.28,5.63 81.28,7.25 81.3,7.26 82.97,7.26
GND on TOP (solid shape): 90.58,157.7 90.58,156.75 90.71,156.62 90.71,155.65 90.77,155.59 91.7,155.56 91.7,153.94 91.69,153.92 90.01,153.92 90.01,153.92 90.01,155.79 89.45,156.36 89.45,156.79 89.44,156.8 89.44,157.88 89.45,157.9 90.39,157.9
GND on TOP (solid shape): 114.1,157.73 114.1,156.78 114.23,156.66 114.23,155.68 114.29,155.62 115.22,155.59 115.22,153.97 115.21,153.96 113.53,153.96 113.53,153.96 113.53,155.83 112.97,156.39 112.97,156.83 112.95,156.84 112.95,157.91 112.97,157.93 113.9,157.93
GND on TOP (solid shape): 100.81,81.86 104.08,81.86 104.13,81.81 104.18,81.81 104.25,81.73 104.38,81.73 104.88,81.23 104.88,80.44 104.55,80.11 103.24,80.11 103.02,80.33 101.57,80.33 101.55,80.32 101.01,80.32 101.01,80.31 99.8,80.31 99.71,80.35 99.67,80.44 99.67,82.14 99.76,82.23 100.44,82.23
GND on TOP (solid shape): 125.68,23.83 125.68,23.23 125.76,23.15 129.86,23.15 129.99,23.01 129.99,22.55 130.15,22.4 131.62,22.4 131.83,22.2 131.83,20.71 131.59,20.47 130.23,20.47 129.24,21.46 125.72,21.46 125.71,21.45 125.02,21.45 124.7,21.13 124.7,21.11 124.47,20.88 122.95,20.88 122.64,21.2 122.64,23.65 122.92,23.93 125.58,23.93
GND on TOP (solid shape): 40.85,138.85 42.91,138.85 43.12,138.64 43.12,133.68 42.92,133.48 41.55,133.48 40.58,132.51 33.72,132.51 33.58,132.66 33.58,133.16 33.07,133.67 31.47,133.67 31.24,133.9 31.24,138.61 31.47,138.84 34.08,138.84 34.29,138.62 34.29,135.23 35.48,134.04 38.45,134.04 39.24,134.82 39.24,138.47 39.62,138.85 40.85,138.85
GND on TOP (solid shape): 182.33,103.93 182.33,97.95 182.28,97.9 181.7,97.9 181.68,97.91 181.38,97.99 181.08,97.98 180.77,97.99 180.47,97.91 180.45,97.9 176.37,97.9 176.2,98.07 176.2,103.92 176.31,104.02 182.24,104.02
GND on TOP (solid shape): 101.12,143.08 101.12,139.54 100.42,138.84 98.03,138.84 97.52,139.35 97.52,140.35 97.4,140.47 93.99,140.47 93.99,140.48 93.94,140.48 93.87,140.55 93.87,141.69 93.85,141.71 93.85,142.1 93.88,142.14 94.63,142.14 94.66,142.11 96.61,142.11 96.65,142.15 96.7,142.15 96.71,142.16 97.01,142.16 97.01,142.16 97.33,142.16 97.55,142.38 97.56,142.38 97.56,143.02 97.74,143.2 101,143.2
GND on TOP (solid shape): 140.47,109.7 140.47,109.09 139.59,108.21 139.36,108.21 139.1,107.95 139.1,106.6 139.22,106.48 139.98,106.48 139.99,106.48 140.18,106.46 140.36,106.48 140.38,106.48 141.1,106.48 141.62,107.01 141.62,107.5 142.23,108.12 144.12,108.12 144.48,107.76 144.48,105.36 144.48,105.36 143.95,104.82 138.33,104.82 138.04,105.11 138.04,109.38 138.47,109.82 140.35,109.82
GND on TOP (solid shape): 51.01,11.16 51.01,10.89 50.98,10.87 50.98,10.55 50.99,10.54 50.99,10.13 50.97,10.05 50.97,9.73 50.97,9.66 50.97,9.55 50.94,9.46 50.85,9.42 49.27,9.42 49.23,9.46 49.23,9.7 49.25,9.72 49.25,10.05 49.24,10.06 49.24,10.53 49.25,10.53 49.25,10.86 49.23,10.87 49.23,11.14 49.29,11.19 50.97,11.19
GND on TOP (solid shape): 44.3,107.76 44.3,107.27 44.31,107.16 44.34,107.06 44.35,107.04 44.35,106.64 44.51,106.48 45.02,106.48 45.03,106.47 45.03,104.91 44.64,104.53 44.64,101.59 45,101.24 45.05,101.24 45.08,101.2 46.27,101.2 46.56,100.91 46.56,99.96 46.55,99.95 42.92,99.95 42.46,100.41 42.46,100.89 42.98,101.42 42.98,104.69 42.85,104.82 41.74,104.82 41.51,105.04 41.51,107.74 41.63,107.85 44.2,107.85
GND on TOP (solid shape): 41.19,128.27 41.19,127.78 41.33,127.64 44.05,127.64 44.14,127.61 44.18,127.52 44.18,126.12 44.14,126.03 44.05,125.99 43.48,125.99 43.43,125.95 41.94,125.95 41.93,125.94 41.39,125.94 41.02,125.57 39.56,125.57 38.72,126.41 37.73,126.41 37.59,126.55 37.59,128.48 37.95,128.83 40.62,128.83
GND on TOP (solid shape): 68.41,117.8 68.41,117.74 68.67,117.3 69.19,117.31 69.22,117.33 69.76,117.33 69.82,117.3 69.9,117.28 70.06,117.11 70.06,116.89 69.96,116.78 66.73,116.78 66.58,116.94 66.58,117.95 66.87,118.24 67.97,118.24
GND on TOP (solid shape): 91.01,82.44 91.21,82.38 91.42,82.44 91.45,82.46 91.69,82.46 91.93,82.22 96.12,82.22 96.21,82.18 96.25,82.09 96.25,80.93 96.21,80.84 96.12,80.81 90.66,80.81 90.5,80.97 90.5,81.31 90.26,81.55 90.26,81.85 90.87,82.46 90.98,82.46
GND on TOP (solid shape): 183.19,81.32 183.19,76.52 182.78,76.12 180.78,76.12 180.45,76.44 180.45,78.52 180.31,78.66 179.12,78.66 178.99,78.79 178.96,78.83 178.95,78.88 178.95,80.45 178.8,80.6 177.56,80.6 177.31,80.35 177.31,79.26 176.84,78.79 176.22,78.79 176.05,78.62 176.05,75.82 176.26,75.62 176.26,74.38 176.28,74.36 176.28,73 173.68,73 173.64,73.04 173.64,75.57 173.98,75.91 174.33,75.91 174.36,75.94 174.36,79.48 174.45,79.56 174.86,79.56 175.32,80.03 175.32,82.93 175.66,83.27 181.23,83.27
GND on TOP (solid shape): 58.83,167.67 58.92,167.64 58.95,167.55 58.95,167.33 58.92,167.24 58.83,167.2 56.45,167.2 56.45,166.11 55.67,165.33 55.58,165.29 55.49,165.33 54.72,166.11 54.72,167.2 52.34,167.2 52.26,167.24 52.22,167.33 52.22,167.55 52.26,167.64 52.34,167.67
GND on TOP (solid shape): 132.96,175.17 132.96,174.16 132.94,174.12 132.93,174.11 132.47,174.11 132.2,173.84 131.67,173.3 131.57,173.12 131.36,173.07 131.1,173.04 130.93,172.85 130.91,172.81 130.85,172.77 127.95,172.77 127.9,172.78 127.86,172.81 127.74,172.93 126.47,172.93 125.95,173.45 125.95,175.21 125.98,175.3 126.07,175.34 132.8,175.34
GND on TOP (solid shape): 68.65,74.28 68.77,74.34 68.9,74.34 69,74.24 69.02,74.2 69.02,74.16 68.65,73.79 68.63,73.78 68.58,73.75 68.53,73.7 67.83,73.01 67.69,73.01 67.61,73.04 67.57,73.13 67.57,73.17 67.59,73.2 67.64,73.34 67.63,73.48 67.68,73.7 67.87,73.79 68.03,73.79 68.24,73.85 68.39,74.01 68.4,74.03
GND on TOP (solid shape): 128.46,45.63 128.55,45.59 128.59,45.5 128.59,44.22 128.77,44.04 130.06,44.04 130.15,44 130.19,43.91 130.19,41.01 129.93,40.75 128.67,40.75 128.67,39.07 130.06,39.07 130.15,39.04 130.19,38.95 130.19,38.9 130.15,38.81 130.06,38.77 124.93,38.77 124.85,38.84 124.85,43.88 124.89,43.97 124.98,44.01 126.21,44.01 126.45,44.25 126.45,45.5 126.49,45.59 126.58,45.63
GND on TOP (solid shape): 103.55,77.83 103.55,75.5 103.08,75.04 99.96,75.04 99.84,75.15 99.84,75.51 99.95,75.62 99.95,77.6 100.12,77.77 101.15,77.77 101.38,77.81 101.54,77.66 101.89,77.39 102.26,77.62 102.19,78.03 101.78,78.13 101.54,78.16 101.44,78.37 101.44,78.78 101.44,78.78 102.6,78.78
GND on TOP (solid shape): 65.14,72.33 65.23,72.37 65.32,72.34 65.33,72.33 65.62,72.19 65.92,72.31 65.96,72.35 66.07,72.35 66.43,71.99 66.51,71.99 66.63,71.92 66.6,71.78 66.53,71.7 66.46,71.62 66.42,71.51 66.4,71.46 66.33,71.38 66.3,71.37 66.22,71.33 66.16,71.28 66.04,71.16 66.03,71.16 65.8,71.39 65.78,71.39 65.6,71.57 65.57,71.63 65.47,71.73 65.35,71.79 65.32,71.8 65.23,71.89 65.22,71.92 65.18,72.02 65.11,72.1 65.09,72.12 65.07,72.15 65.06,72.22 65.1,72.29
GND on TOP (solid shape): 84.01,73.72 84.11,73.72 84.15,73.7 84.2,73.69 84.28,73.65 84.31,73.56 84.31,72.6 84.33,72.58 84.34,72.54 84.39,72.43 84.47,72.34 84.51,72.27 84.5,72.19 84.48,72.08 84.5,71.96 84.51,71.79 84.41,71.65 84.28,71.49 84.3,71.28 84.3,71.2 84.27,71.14 84.15,71.02 84.15,70.83 84.12,70.74 84.03,70.7 83.99,70.7 83.94,70.73 83.92,70.76 83.87,70.82 83.8,70.87 83.76,70.92 83.74,70.98 83.74,71.66 83.59,71.81 83.56,71.84 83.5,71.95 83.56,72.05 83.65,72.16 83.68,72.3 83.68,72.99 83.79,73.1 83.79,73.45 83.81,73.51 83.84,73.55 83.9,73.61 83.94,73.67
GND on TOP (solid shape): outline of 214 points within 81.35,85.19 87.28,89.86
GND on TOP (solid shape): outline of 272 points within 112.03,90.8 122.04,100.8
GND on TOP (solid shape): 83.93,77.77 83.96,77.67 83.97,77.5 83.87,77.37 83.75,77.06 83.97,76.82 84,76.81 84.15,76.66 84.15,76.21 84.29,76.07 84.31,76 84.3,75.91 84.23,75.75 84.07,75.67 83.83,75.3 84.25,75.16 84.44,75.19 84.59,75.08 84.64,75.02 84.64,74.92 84.38,74.66 84.38,74.56 84.02,74.21 84.01,74.19 83.93,74.15 83.84,74.17 83.48,74.22 83.24,73.95 83.23,73.91 83.18,73.86 83.18,73.35 83.08,73.25 83.01,73.23 82.93,73.25 82.54,73.64 82.53,73.67 82.5,73.73 82.46,73.78 82.4,73.95 82.45,74.11 82.49,74.41 82.23,74.56 82.15,74.6 82.11,74.69 82.11,74.88 81.91,75.08 81.89,75.15 81.9,75.25 81.96,75.31 82.01,75.34 82.05,75.37 82.23,75.45 82.42,75.37 82.8,75.36 82.84,75.74 82.78,75.91 82.84,76.07 82.87,76.1 82.89,76.15 83.01,76.22 83.13,76.15 83.57,76.06 83.52,76.51 83.4,76.66 83.43,76.85 83.41,77.24 83.07,77.41 83.01,77.42 82.97,77.45 82.81,77.61 82.78,77.75 82.9,77.83 83.86,77.83
GND on TOP (solid shape): outline of 84 points within 79.87,72.45 81.7,77.83
GND on TOP (solid shape): outline of 113 points within 67.46,74.61 72.24,80.67
GND on TOP (solid shape): outline of 361 points within 31.03,171.8 43.03,188.8
GND on TOP (solid shape): outline of 361 points within 31.03,15.8 43.03,32.8
GND on TOP (solid shape): outline of 361 points within 181.03,171.75 193.03,188.75
GND on TOP (solid shape): outline of 361 points within 181.03,15.75 193.03,32.75
GND on TOP (solid shape): outline of 407 points within 63.14,74.39 69.03,83.65
GND on TOP (solid shape): outline of 3020 points within 63.46,60.62 86.61,79.16
GND on BOTTOM (solid shape): 177.35,140.9 170.87,140.9 170.87,143.15 177.35,143.15
GND on BOTTOM (solid shape): 26.23,114.12 26.23,104.57 22.54,104.57 21.93,105.19 21.93,114.21 22.29,114.58 25.77,114.58
GND on BOTTOM (solid shape): 54.39,72.03 54.29,71.93 52.26,71.93 51.86,72.33 51.86,72.7 52.85,73.69 54.39,73.69
GND on BOTTOM (solid shape): 24.9,125.91 24.9,121.28 24.77,121.15 22.97,121.15 22.88,121.24 22.88,125.79 23.06,125.97 24.84,125.97
GND on BOTTOM (solid shape): 40.26,165.18 40.26,163.33 40.16,163.23 38.62,163.23 38.56,163.29 38.56,165.19 38.64,165.27 40.17,165.27
GND on BOTTOM (solid shape): 50.99,11.09 50.99,9.39 50.96,9.37 49.24,9.37 49.2,9.4 49.2,11.08 49.25,11.14 50.94,11.14
GND on BOTTOM (solid shape): 60.23,146.06 60.23,145.02 60.1,144.89 58.02,144.89 57.87,145.04 57.87,146.12 57.93,146.18 60.11,146.18
GND on BOTTOM (solid shape): 66.93,89.85 66.93,88.52 66.76,88.36 64.5,88.36 64.13,88.72 64.13,89.86 64.28,90.01 66.77,90.01
GND on BOTTOM (solid shape): 76.62,6.33 76.62,1.97 76.2,1.55 65.39,1.55 65.15,1.79 65.15,6.18 65.55,6.58 76.36,6.58
GND on BOTTOM (solid shape): 97.55,86.81 97.55,82.56 97.48,82.5 95.52,82.5 95.41,82.6 95.41,86.76 95.56,86.91 97.46,86.91
GND on BOTTOM (solid shape): 98.94,8.1 98.94,2.02 98.64,1.72 96.5,1.72 96.32,1.9 96.32,8.07 96.63,8.37 98.67,8.37
GND on BOTTOM (solid shape): 131.18,123.66 131.18,120.6 131.05,120.47 126.4,120.47 126.27,120.6 126.27,123.74 126.3,123.77 131.07,123.77
GND on BOTTOM (solid shape): 133.03,114.99 133.03,103.61 132.78,103.35 128.78,103.35 127.17,104.96 127.17,113.73 128.53,115.09 132.94,115.09
GND on BOTTOM (solid shape): 159.24,73.89 159.24,70.41 159.17,70.33 158.3,70.33 158,70.64 158,73.81 158.15,73.96 159.17,73.96
GND on BOTTOM (solid shape): 166.97,68.4 166.97,67.46 166.89,67.38 163.45,67.38 163.26,67.58 163.26,68.35 163.44,68.53 166.84,68.53
GND on BOTTOM (solid shape): 166.97,64.77 166.97,63.5 166.76,63.3 163.46,63.3 163.31,63.45 163.31,64.74 163.38,64.82 166.92,64.82
GND on BOTTOM (solid shape): 195.9,159.16 195.9,157.03 195.76,156.9 192.82,156.9 192.3,157.41 192.3,159.17 192.41,159.27 195.78,159.27
GND on BOTTOM (solid shape): 206.23,27.37 206.23,26.05 205.99,25.82 203.94,25.82 203.8,25.96 203.8,27.47 203.95,27.62 205.97,27.62
GND on BOTTOM (solid shape): 63.15,114.72 63.15,112.81 62.89,112.55 59.84,112.55 59.84,115.26 59.88,115.3 62.57,115.3
GND on BOTTOM (solid shape): 88.91,149.46 88.87,149.42 85.05,149.42 84.88,149.59 84.88,151.97 85.08,152.17 88.91,152.17
GND on BOTTOM (solid shape): 112.43,149.49 112.39,149.45 109.03,149.45 108.78,149.71 108.78,152.02 108.96,152.21 112.43,152.21
GND on BOTTOM (solid shape): 200.41,29.34 200.41,26.05 199.97,25.61 196.25,25.61 195.89,25.97 195.89,29.4 196.22,29.73 200.02,29.73
GND on BOTTOM (solid shape): 69.37,143.25 69.37,139.85 69.94,139.28 69.94,138.7 69.71,138.47 68.8,138.47 67.91,139.36 67.91,143.22 68.11,143.42 69.2,143.42
GND on BOTTOM (solid shape): 167.02,61.82 167.02,60.96 166.79,60.73 163.44,60.73 163.38,60.78 163.38,61.57 163.31,61.65 163.31,61.87 163.36,61.92 166.92,61.92
GND on BOTTOM (solid shape): 88.25,13.45 88.25,9.5 87.77,9.02 84.08,9.02 84.08,13.99 84.17,14.08 87.63,14.08
GND on BOTTOM (solid shape): 129.99,23.77 129.99,21.67 129.82,21.5 122.78,21.5 122.64,21.65 122.64,23.65 122.92,23.93 129.83,23.93
GND on BOTTOM (solid shape): 134.69,32.05 134.68,32.04 134.68,31.72 134.61,31.64 134.31,31.64 134.29,31.66 132.34,31.66 132.15,31.85 132.15,33.84 132.6,34.29 134.69,34.29
GND on BOTTOM (solid shape): 31.16,149.07 31.16,147.9 30.52,147.26 30.52,138.95 30.1,138.54 28.12,138.54 27.94,138.71 27.94,147.46 29.81,149.33 30.9,149.33
GND on BOTTOM (solid shape): 75.75,159.12 75.78,159.07 75.79,159.03 75.79,152.83 75.53,152.57 73.66,152.57 73.49,152.75 73.49,158.7 73.94,159.16 75.71,159.16
GND on BOTTOM (solid shape): 103.77,84.96 103.8,84.92 103.81,84.87 103.81,83.35 103.5,83.04 101.06,83.04 100.73,83.37 100.73,84.92 100.92,85.12 103.62,85.12
GND on BOTTOM (solid shape): 114.89,117.7 114.89,114.44 115.67,113.66 116.73,113.66 116.85,113.54 116.85,104.24 116.45,103.85 113.42,103.85 112.88,104.39 112.88,117.43 113.17,117.71 114.88,117.71
GND on BOTTOM (solid shape): 118.62,127.38 118.62,124.31 118.48,124.17 114.35,124.17 114.27,124.25 114.27,127.23 114.53,127.49 118.51,127.49
GND on BOTTOM (solid shape): 121.24,136.64 121.24,132.68 121.01,132.46 119.91,132.46 119.23,133.14 117.84,133.14 117.78,133.2 117.78,136.63 117.78,136.64 120.41,136.64 120.43,136.66 121.22,136.66
GND on BOTTOM (solid shape): 187.06,159.31 187.15,159.27 187.18,159.18 187.18,157.64 187.13,157.59 185.33,157.59 185.33,159.31
GND on BOTTOM (solid shape): 28.91,131.04 28.91,129.54 28.85,129.48 27.33,129.48 27.29,129.52 27.29,130.96 27.33,131.05 27.42,131.09 28.86,131.09
GND on BOTTOM (solid shape): 49.76,160.1 49.76,157.47 49.79,157.45 49.79,155.03 49.38,154.62 48.47,154.62 48.34,154.76 48.34,159.66 48.34,160.26 48.59,160.51 49.35,160.51
GND on BOTTOM (solid shape): 60.95,3.89 60.95,1.51 60.91,1.46 53.45,1.46 52.96,1.95 52.96,3.75 53.2,3.99 54.25,3.99 54.27,4 60.84,4
GND on BOTTOM (solid shape): 74.45,111.52 74.45,105.75 74.18,105.49 72.29,105.49 72.01,105.76 72.01,112.02 72.05,112.11 72.14,112.14 73.82,112.14
GND on BOTTOM (solid shape): 76.98,17.11 76.98,15.21 76.84,15.08 68.16,15.08 67.75,15.49 67.75,17.18 67.79,17.27 67.88,17.31 76.78,17.31
GND on BOTTOM (solid shape): 154.29,160.98 154.29,158.19 154.26,158.16 150.82,158.16 150.69,158.29 150.69,160.92 150.73,161.01 150.82,161.05 154.22,161.05
GND on BOTTOM (solid shape): 162.78,51.3 162.78,48.49 162.53,48.24 158.69,48.24 158.42,48.5 158.42,51.36 158.46,51.45 158.55,51.49 162.59,51.49
GND on BOTTOM (solid shape): 182.75,55.36 182.75,47.66 182.75,47.66 182.98,47.43 182.98,46.83 182.43,46.28 179.59,46.28 179.02,46.84 179.02,55.52 179.29,55.79 182.32,55.79
GND on BOTTOM (solid shape): 189,124.03 189,123.64 189.18,123.45 189.33,123.45 189.79,123 189.79,122.67 189.71,122.59 189.25,122.59 189.05,122.8 188.57,122.8 188.09,123.28 188.09,123.96 188.25,124.13 188.9,124.13
GND on BOTTOM (solid shape): 78.5,31.83 78.5,30.51 78.51,30.5 78.52,30.47 78.52,30.44 78.52,29.59 78.38,29.45 77.49,29.45 77.42,29.52 77.42,30.38 77.21,30.59 77.21,31.91 77.34,32.04 78.29,32.04
GND on BOTTOM (solid shape): 211.08,151.12 211.08,139.5 210.79,139.21 205.55,139.21 205.33,139.43 205.33,142.67 205.43,142.76 205.43,145.63 205.69,145.89 205.69,150.99 205.93,151.23 210.97,151.23
GND on BOTTOM (solid shape): 60.36,17.11 60.36,13.11 60.24,12.99 57.75,12.99 57.42,12.66 57.42,11.59 57.28,11.45 55.49,11.45 55.45,11.5 55.45,16.93 55.63,17.12 60.35,17.12
GND on BOTTOM (solid shape): 76.45,78.89 76.45,78.46 76.38,78.38 75.23,78.38 75.07,78.22 73.87,78.22 73.77,78.32 73.77,78.8 73.83,78.86 73.88,78.88 73.91,78.88 74.42,78.88 74.53,78.99 76.35,78.99
GND on BOTTOM (solid shape): 100.03,158.52 100.03,151.93 100,151.84 99.91,151.8 98.45,151.8 97.46,152.78 97.46,154.41 97.41,154.46 97.41,158.48 97.63,158.69 99.86,158.69
GND on BOTTOM (solid shape): 46.36,126.91 46.45,126.87 46.49,126.78 46.49,125.16 46.48,125.12 46.45,125.07 46.18,124.8 45.25,124.8 44.81,125.25 44.81,126.88 44.85,126.91
GND on BOTTOM (solid shape): 58.74,108.92 59.3,108.36 59.3,107.93 59.31,107.91 59.31,106.84 59.29,106.82 58.36,106.82 58.16,107.02 58.16,107.97 58.03,108.1 58.03,109.07 57.97,109.13 57.08,109.13 57.04,109.16 57.04,110.78 57.06,110.8 58.74,110.8
GND on BOTTOM (solid shape): 66.95,125.34 66.95,124.44 67.33,124.06 67.33,123.41 67.29,123.32 67.2,123.28 64.79,123.28 64.66,123.41 64.66,125.49 64.76,125.59 66.7,125.59
GND on BOTTOM (solid shape): 82.98,7.26 82.98,5.39 83.54,4.83 83.54,4.39 83.55,4.38 83.55,3.31 83.53,3.29 82.6,3.29 82.4,3.49 82.4,4.44 82.27,4.56 82.27,5.54 82.21,5.6 81.32,5.6 81.28,5.63 81.28,7.25 81.3,7.26 82.97,7.26
GND on BOTTOM (solid shape): 90.58,157.7 90.58,156.75 90.71,156.62 90.71,155.65 90.77,155.59 91.67,155.59 91.7,155.56 91.7,153.94 91.69,153.92 90.01,153.92 90.01,153.92 90.01,155.79 89.45,156.36 89.45,156.79 89.44,156.8 89.44,157.88 89.45,157.9 90.39,157.9
GND on BOTTOM (solid shape): 114.1,157.73 114.1,156.78 114.23,156.66 114.23,155.68 114.29,155.62 115.19,155.62 115.22,155.59 115.22,153.97 115.21,153.96 113.53,153.96 113.53,153.96 113.53,155.83 112.97,156.39 112.97,156.83 112.95,156.84 112.95,157.91 112.97,157.93 113.9,157.93
GND on BOTTOM (solid shape): 67.33,130.01 67.42,129.97 67.46,129.88 67.46,127.32 67.36,127.23 65.84,127.23 65.6,126.99 65.6,126.83 64.98,126.21 64.61,126.21 63.49,127.34 63.49,129.85 63.65,130.01
GND on BOTTOM (solid shape): 38.46,125.66 38.46,121.13 38.17,120.84 34.11,120.84 33.95,120.99 33.95,123.58 33.78,123.74 32.35,123.74 32.24,123.85 32.24,124.21 32.24,124.21 32.24,125.86 32.27,125.9 38.23,125.9
GND on BOTTOM (solid shape): 69.36,71.61 69.4,71.61 70.01,71.61 70.11,71.51 70.11,71.14 70.05,71.08 69.56,71.08 69.49,71.01 69.49,70.15 69.39,70.05 68.94,70.05 68.72,70.27 68.72,70.58 68.83,70.69 68.83,71.51 68.93,71.61
GND on BOTTOM (solid shape): 71.1,77.29 71.1,77.02 71.07,76.99 71.07,76.74 71.04,76.71 69.98,76.71 69.98,76.68 69.63,76.68 69.62,76.67 68.88,76.67 68.8,76.74 68.19,76.74 68.18,76.74 68.18,77.17 68.3,77.28 70.37,77.28 70.41,77.25 70.59,77.25 70.69,77.34 71.05,77.34
GND on BOTTOM (solid shape): 41.19,128.27 41.19,127.78 41.33,127.64 44.18,127.64 44.18,125.94 41.39,125.94 41.02,125.57 39.56,125.57 38.72,126.41 37.73,126.41 37.59,126.55 37.59,128.48 37.95,128.83 40.62,128.83
GND on BOTTOM (solid shape): 148.41,120.02 148.41,119.8 148.39,119.77 148.31,119.49 148.39,119.2 148.41,119.17 148.41,114.71 147.75,114.05 142.45,114.05 141.76,114.74 141.76,120.12 142.47,120.83 147.6,120.83
GND on BOTTOM (solid shape): 87.9,99.69 88.1,99.63 88.3,99.67 88.33,99.69 90.28,99.69 90.42,99.55 90.42,96.34 90.39,96.32 87.83,96.32 87.74,96.36 87.71,96.44 87.71,99.54 87.86,99.69
GND on BOTTOM (solid shape): 89.57,179.76 89.57,178.65 89.51,178.54 89.48,178.52 89.3,178.32 89.24,178.05 89.24,178 89.21,177.95 88.61,177.36 88.45,177.36 88.12,177.69 88.12,178.87 87.81,179.18 87.81,179.85 87.89,179.93 89.4,179.93
GND on BOTTOM (solid shape): 161.38,68.25 161.38,60.32 161.15,60.1 153.48,60.1 152.89,60.68 152.89,61.74 152.9,61.82 152.89,61.9 152.89,62.81 152.9,62.89 152.89,62.97 152.89,65.47 152.9,65.56 152.89,65.64 152.89,68.3 153.2,68.6 161.02,68.6
GND on BOTTOM (solid shape): 183.09,104.11 183.09,97.35 182.93,97.2 176.05,97.2 175.26,97.99 175.26,98.29 175.27,98.37 175.26,98.45 175.26,99.51 175.27,99.59 175.26,99.67 175.26,100.75 175.27,100.83 175.26,100.92 175.26,103.73 176.25,104.72 182.48,104.72
GND on BOTTOM (solid shape): 40.85,138.85 42.91,138.85 43.12,138.64 43.12,133.68 42.92,133.48 41.55,133.48 40.58,132.51 33.72,132.51 33.58,132.66 33.58,133.16 33.07,133.67 31.47,133.67 31.24,133.9 31.24,138.61 31.47,138.84 34.08,138.84 34.29,138.62 34.29,135.23 35.48,134.04 38.45,134.04 39.24,134.82 39.24,138.47 39.62,138.85 40.85,138.85
GND on BOTTOM (solid shape): 65.29,77.55 65.56,77.28 66.07,77.28 66.44,76.91 66.98,76.91 67.25,76.64 67.25,76.03 67.73,75.54 67.73,74.97 67.69,74.93 67.03,74.93 66.97,74.99 66.62,74.99 66.38,74.76 66.38,73.81 66.11,73.54 65.81,73.54 65.71,73.63 65.71,74.88 65.62,74.97 65.04,74.97 65.01,75 65.01,76.79 64.89,76.91 64.89,77.41 65.03,77.55 65.29,77.55
GND on BOTTOM (solid shape): 76.04,70.86 76.04,70.31 75.84,70.11 75.84,69.84 75.3,69.29 73.82,69.29 73.61,69.5 73.04,69.5 73.03,69.51 73.03,69.73 73.02,69.86 72.96,69.97 72.94,70 72.94,70.06 72.94,70.06 72.77,70.23 72.26,70.23 72.16,70.33 72.16,70.76 72.29,70.89 73.02,70.89 73.02,70.89 76,70.89
GND on BOTTOM (solid shape): 66.11,72.41 66.11,71.67 66.32,71.47 66.32,71.27 66.31,71.23 65.81,71.23 65.72,71.27 65.68,71.36 65.68,71.53 65.38,71.83 64.85,71.83 64.75,71.93 64.75,72.34 64.79,72.43 64.88,72.46 66.06,72.46
GND on BOTTOM (solid shape): 27,130.08 27,129.52 26.88,129.41 26.88,129.41 25.8,128.34 25.8,126.3 25.75,126.24 24.51,126.24 24.39,126.36 24.39,129.76 24.59,129.96 25.39,129.96 25.42,129.94 25.77,129.86 26.07,130.06 26.09,130.08 26.14,130.11 26.96,130.11
GND on BOTTOM (solid shape): 76.73,76.17 76.73,74.89 77.06,74.56 77.24,74.56 77.31,74.5 77.31,74.17 77.28,74.14 76.97,74.14 76.92,74.15 76.88,74.18 76.75,74.31 76.68,74.3 76.63,74.31 76.59,74.34 76.58,74.36 75.5,74.36 75.38,74.48 75.38,75.25 75.39,75.25 75.39,76.24 75.43,76.29 76.61,76.29
GND on BOTTOM (solid shape): 182.85,81.66 182.85,76.57 182.39,76.12 180.78,76.12 180.45,76.44 180.45,78.44 180.09,78.81 179.07,78.81 178.95,78.93 178.95,80.45 178.8,80.6 177.56,80.6 177.31,80.35 177.31,79.26 176.84,78.79 176.22,78.79 176.05,78.62 176.05,75.82 176.26,75.62 176.26,74.6 175.92,74.27 173.84,74.27 173.64,74.47 173.64,75.57 173.65,75.57 173.65,76.46 174.36,77.18 174.36,79.48 174.45,79.56 174.86,79.56 175.32,80.03 175.32,82.93 175.66,83.27 181.23,83.27
GND on BOTTOM (solid shape): 50.95,141.31 50.95,140.73 50.95,140.73 50.95,140.61 51.01,140.54 51.61,140.54 51.64,140.51 51.64,140 51.54,139.9 51.01,139.9 50.95,139.84 50.95,138.93 51.05,138.82 51.24,138.82 51.24,138.83 51.51,138.83 51.58,138.75 51.58,137.6 51.54,137.51 51.46,137.47 51.18,137.47 50.97,137.25 50.97,136.75 51.22,136.5 51.48,136.5 51.7,136.29 51.7,136.16 51.52,135.98 50.05,135.98 49.85,136.18 49.85,141.41 49.93,141.49 50.77,141.49
GND on BOTTOM (solid shape): 55.67,75.23 55.67,75.15 57.97,75.15 58.07,75.05 58.07,74.83 57.23,73.99 52.65,73.99 52.6,74.02 52.58,74.05 52.15,74.28 51.76,73.99 51.71,73.93 51.64,73.91 51.33,73.91 51.1,74.14 51.1,75.82 51.14,75.91 51.23,75.94 54.96,75.94
GND on BOTTOM (solid shape): 67.16,119.98 67.41,119.9 67.67,119.98 67.71,120 68.12,120 68.21,119.97 68.24,119.88 68.24,116.93 68.17,116.85 66.7,116.85 66.7,116.85 64.49,116.85 64.4,116.89 64.36,116.98 64.36,117.19 64.38,117.22 64.45,117.47 64.38,117.72 64.36,117.75 64.36,119.88 64.4,119.97 64.49,120 67.12,120
GND on BOTTOM (solid shape): 62.28,79.82 62.28,79.21 61.59,78.52 61.59,78.04 62.01,77.63 63.94,77.63 64.03,77.54 64.03,76.69 64,76.69 64,76.58 63.97,76.52 63.95,76.48 63.9,76.43 63.83,76.41 63.57,76.41 63.56,76.41 63.47,76.42 63.39,76.41 63.38,76.41 63.12,76.41 62.8,76.08 61.3,76.08 61.23,76.16 61.23,76.61 61.17,76.67 61.17,76.72 61.06,76.97 60.8,77.09 60.75,77.09 60.52,77.32 60.51,77.4 60.53,77.44 60.59,77.74 60.46,78.03 60.46,78.44 60.54,78.52 60.54,79.15 60.52,79.27 60.47,79.39 60.46,79.42 60.46,79.85 60.46,79.89 60.49,79.94 60.53,79.97 61.73,79.97 61.73,79.97 62.13,79.97
GND on BOTTOM (solid shape): 70.17,74.23 70.26,74.19 70.3,74.1 70.3,73.59 70.55,73.34 71.15,73.34 71.35,73.54 71.35,73.9 71.39,73.99 71.48,74.03 72.67,74.03 72.76,74 72.8,73.92 72.8,73.91 72.8,73.55 72.78,73.5 72.29,73.5 72.01,73.22 72.01,72.7 71.97,72.66 71.93,72.64 71.87,72.63 71.83,72.63 71.34,72.63 71.11,72.86 69.1,72.86 69.05,72.87 69.01,72.9 68.98,72.93 68.98,73.05 69.04,73.19 69.16,73.26 69.23,73.26 69.53,73.26 69.81,73.54 69.81,74.18 69.86,74.23
GND on BOTTOM (solid shape): 68.99,68.2 68.99,67.55 68.96,67.47 68.95,67.42 68.98,67.19 69.11,67 69.15,66.92 69.13,66.83 69.06,66.68 69.06,66.52 69,66.31 68.81,66.22 68.68,66.22 68.57,66.11 68.2,66.11 68.06,65.98 67.4,65.98 67.36,65.99 67.32,66.01 67.26,66.05 67.2,66.11 67.2,66.31 67.22,66.35 67.31,66.58 67.22,66.82 67.2,66.85 67.2,67.07 67.22,67.11 67.31,67.35 67.22,67.58 67.2,67.62 67.2,67.86 67.44,68.11 67.48,68.11 67.58,68.14 67.67,68.19 67.7,68.22 68.96,68.22
GND on BOTTOM (solid shape): 74.47,148.58 75.5,148.58 75.69,148.4 75.72,148.31 75.69,148.22 75.58,148.05 75.54,147.86 75.54,147.77 75.09,147.32 75.08,147.32 75.08,147.31 75.05,147.28 75.05,147.16 74.28,146.39 74.21,146.33 74.16,146.26 74.08,146.19 74.02,146.15 73.94,146.16 73.86,146.18 73.78,146.18 73.61,146.23 73.51,146.38 73.33,146.38 73.17,146.54 70.6,146.54 70.36,146.3 68.64,146.3 68.44,146.5 68.44,147.06 68.87,147.49 69.1,147.56 69.28,147.4 70.04,147.23 69.87,147.98 69.71,148.17 69.78,148.4 69.97,148.59 74.45,148.59
GND on BOTTOM (solid shape): 60.65,159.48 60.68,159.43 60.68,159.37 60.68,159.25 60.7,159.13 60.71,159.11 60.71,158.41 60.7,158.39 60.68,158.25 60.7,158.11 60.71,158.1 60.71,156.32 60.7,156.3 60.67,156.14 60.7,155.98 60.71,155.96 60.71,154.57 60.7,154.55 60.67,154.39 60.7,154.23 60.71,154.21 60.71,153.53 60.7,153.51 60.68,153.37 60.7,153.24 60.71,153.22 60.71,152.28 60.7,152.27 60.68,152.13 60.7,151.99 60.71,151.97 60.71,151.24 60.7,151.22 60.67,151.06 60.7,150.9 60.71,150.88 60.71,150.81 60.3,150.4 52.86,150.4 52.4,150.86 52.4,153.39 52.42,153.42 52.51,153.7 52.42,153.99 52.4,154.02 52.4,154.85 52.42,154.88 52.52,155.18 52.42,155.47 52.4,155.5 52.4,156.31 52.5,156.47 52.53,156.65 52.53,158.71 52.83,159 57.63,159 57.77,159.14 58.19,159.14 58.21,159.13 58.37,159.11 58.53,159.13 58.55,159.14 59.06,159.14 59.44,159.53 60.6,159.53
GND on BOTTOM (solid shape): outline of 97 points within 74.12,131.23 83.14,139.23
GND on BOTTOM (solid shape): outline of 133 points within 178.41,89.58 184.15,94.23
GND on BOTTOM (solid shape): outline of 89 points within 168.95,148.36 177.25,157.62
GND on BOTTOM (solid shape): outline of 163 points within 36.21,104 49.62,118.3
GND on BOTTOM (solid shape): outline of 90 points within 70.48,80.01 93.95,83.02
GND on BOTTOM (solid shape): outline of 275 points within 112.03,85.8 122.03,100.8
GND on BOTTOM (solid shape): outline of 361 points within 31.03,171.8 43.03,188.8
GND on BOTTOM (solid shape): outline of 361 points within 31.03,15.8 43.03,32.8
GND on BOTTOM (solid shape): outline of 361 points within 181.03,171.75 193.03,188.75
GND on BOTTOM (solid shape): outline of 361 points within 181.03,15.75 193.03,32.75
GND on BOTTOM (solid shape): outline of 507 points within 180.09,113.34 195.63,124.8
GND on BOTTOM (solid shape): outline of 775 points within 59.15,43.69 68.81,69.16
GND on BOTTOM (solid shape): outline of 919 points within 74.87,21.15 100.55,24.87
GND on GND1 (solid shape): outline of 3247 points within -5.7,0.51 211.52,208.19
GND on IN1 (solid shape): 177.35,140.9 170.87,140.9 170.87,143.15 177.35,143.15
GND on IN1 (solid shape): 97.55,86.81 97.55,82.56 97.48,82.5 95.52,82.5 95.41,82.6 95.41,86.76 95.56,86.91 97.46,86.91
GND on IN1 (solid shape): 175.75,155.73 175.75,150.54 175.67,150.46 170.38,150.46 170.33,150.51 170.33,155.77 170.38,155.83 175.66,155.83
GND on IN1 (solid shape): 153.05,160.99 154.27,160.99 154.29,160.97 154.29,158.19 154.26,158.16 150.82,158.16 150.69,158.29 150.69,160.92 150.73,161.01 150.82,161.05 153,161.05
GND on IN1 (solid shape): 182.33,103.93 182.33,97.95 182.28,97.9 181.7,97.9 181.68,97.91 181.38,97.99 181.08,97.98 180.77,97.99 180.47,97.91 180.45,97.9 176.37,97.9 176.2,98.07 176.2,103.92 176.31,104.02 182.24,104.02
GND on VCC1 (solid shape): 119.29,156.84 119.29,153.09 119.25,153 119.16,152.96 115.59,152.96 115.53,152.9 113.65,152.9 113.57,152.95 113.55,152.98 113.55,153.06 113.33,153.28 111.42,153.28 111.33,153.32 111.29,153.41 111.29,158.78 112.18,159.67 116.46,159.67
GND on VCC1 (solid shape): 79.43,10 79.56,9.98 79.7,10 79.72,10.01 80.05,10.01 80.07,10 80.2,9.98 80.33,10 80.35,10.01 80.87,10.01 80.91,9.99 81.12,9.92 81.34,9.99 81.37,10.01 81.47,10.01 81.64,9.84 81.64,8.4 82,8.05 85.18,8.05 85.48,7.75 85.48,1.14 85.44,1.05 85.35,1.02 76.91,1.02 76.82,1.05 76.78,1.14 76.78,7.89 77.61,8.72 77.61,9.88 77.65,9.97 77.74,10.01 79.41,10.01
GND on VCC1 (solid shape): outline of 877 points within -5.19,1.02 9.02,207.68
GND on VCC2 (solid shape): 119.26,156.91 119.26,154.25 119.24,154.17 119.17,154.12 118.89,153.76 119.17,153.39 119.24,153.34 119.26,153.27 119.26,153.07 119.23,152.98 119.14,152.94 115.65,152.94 115.58,152.88 113.69,152.88 113.61,152.96 113.61,153.05 113.39,153.26 111.41,153.26 111.32,153.35 111.32,158.73 112.28,159.69 116.48,159.69
GND on VCC2 (solid shape): outline of 877 points within -5.19,1.02 9.02,207.68
GND on GND2 (solid shape): outline of 885 points within -5.7,0.51 9.52,208.19
GND on GND2 (solid shape): outline of 2095 points within 12.54,0.51 211.52,208.19
GND on IN2 (solid shape): 58.95,164.27 52.22,164.27 52.22,167.67 58.95,167.67
GND on IN2 (solid shape): 177.35,140.9 170.87,140.9 170.87,143.15 177.35,143.15
GND on IN2 (solid shape): 97.55,86.81 97.55,82.56 97.48,82.5 95.52,82.5 95.41,82.6 95.41,86.76 95.56,86.91 97.46,86.91
GND on IN2 (solid shape): 175.72,155.73 175.72,150.54 175.64,150.46 170.35,150.46 170.3,150.51 170.3,155.77 170.35,155.83 175.63,155.83
GND on IN2 (solid shape): 154.29,160.98 154.29,158.19 154.26,158.16 150.82,158.16 150.69,158.29 150.69,160.92 150.73,161.01 150.82,161.05 154.22,161.05
GND on IN2 (solid shape): 148.99,121.2 148.99,113.98 148.53,113.52 147.99,113.52 147.97,113.53 147.86,113.54 147.74,113.53 147.72,113.52 141.32,113.52 140.93,113.9 140.93,120.91 141.54,121.52 148.67,121.52
GND on IN2 (solid shape): 68.12,119.91 68.21,119.88 68.25,119.79 68.25,116.88 68.21,116.79 68.12,116.75 66.71,116.75 66.7,116.76 64.49,116.76 64.4,116.8 64.36,116.89 64.36,117.35 64.36,117.37 64.38,117.47 64.36,117.57 64.36,117.59 64.36,119.79 64.4,119.88 64.49,119.91
GND on IN2 (solid shape): outline of 289 points within 87.64,153.83 96.64,159.61
GND on IN3 (solid shape): 58.95,164.27 52.22,164.27 52.22,167.67 58.95,167.67
GND on IN3 (solid shape): 177.35,140.9 170.87,140.9 170.87,143.15 177.35,143.15
GND on IN3 (solid shape): 97.55,86.81 97.55,82.56 97.48,82.5 95.52,82.5 95.41,82.6 95.41,86.76 95.56,86.91 97.46,86.91
GND on IN3 (solid shape): 175.71,155.69 175.71,150.5 175.63,150.41 170.34,150.41 170.29,150.47 170.29,155.73 170.34,155.78 175.61,155.78
GND on IN3 (solid shape): 154.29,160.98 154.29,158.19 154.26,158.16 150.82,158.16 150.69,158.29 150.69,160.92 150.73,161.01 150.82,161.05 154.22,161.05
GND on IN3 (solid shape): 68.12,119.91 68.21,119.88 68.25,119.79 68.25,116.89 68.21,116.8 68.12,116.76 66.7,116.76 66.7,116.76 64.49,116.76 64.4,116.8 64.36,116.89 64.36,117.35 64.36,117.37 64.38,117.47 64.36,117.57 64.36,117.59 64.36,119.79 64.4,119.88 64.49,119.91
GND on IN3 (solid shape): outline of 388 points within 111.11,151.38 118.68,157.97
GND on GND3 (solid shape): outline of 885 points within -5.7,0.51 9.52,208.19
GND on GND3 (solid shape): outline of 2119 points within 12.54,0.51 211.52,203
GND on BOTTOM: 65.68,80.48 64.97,81.19 64.97,81.6 64.96,81.61 64.96,81.93 65,82.02 65.01,82.04 65.12,82.3 65.05,82.57 65.03,82.6 65.03,82.87 65.28,83.12 65.55,83.12 65.73,83.29 67.28,83.29 67.33,83.24 67.36,83.2 67.37,83.15 67.37,82.86 67.47,82.76 67.47,82.65 67.55,82.57 68.43,82.57 68.51,82.49 68.51,82.03 68.47,81.94 68.38,81.91 68.15,81.91 68.05,81.81 68.05,80 68.25,79.8 68.25,79.79 68.27,79.79 68.32,79.73 68.48,79.73 68.74,79.46 68.74,79.05 68.94,78.85 70.95,78.85 71.1,78.7 71.1,78.44 70.97,78.31 70.48,78.31 70.48,78.3 66.77,78.3 66.59,78.48 66.58,78.51 66.57,78.55 66.57,79.82 66.57,79.85 66.36,80.06 65.8,80.06 65.71,80.1 65.68,80.19
GNDA on BOTTOM (solid shape): outline of 640 points within 146.38,24.16 157.19,29.88
P0V75_BMC_VTTREF_NODE1 on BOTTOM (solid shape): 49.54,141.35 49.54,139.4 49.53,139.39 49.53,136.14 49.95,135.72 51.54,135.72 51.63,135.69 51.67,135.6 51.67,135.42 51.58,135.23 51.36,135.17 50.81,134.73 51.36,134.28 51.58,134.23 51.67,134.03 51.67,133.69 51.59,133.61 51.38,133.61 51.36,133.62 51.15,133.66 50.95,133.6 50.93,133.58 48.39,133.58 47.54,134.43 47.54,140.88 48.17,141.51 49.38,141.51
P0V75_BMC_VTTREF_NODE1 on BOTTOM (solid shape): 72.15,134.64 72.19,134.55 72.15,134.46 72.13,134.43 72.09,134.42 71.97,134.37 71.87,134.27 71.77,134.25 71.68,134.27 71.37,134.43 71.07,134.27 70.97,134.25 70.88,134.27 70.31,134.32 70.36,133.75 70.38,133.66 70.36,133.56 70.2,133.26 70.36,132.95 70.38,132.86 70.36,132.76 70.2,132.46 70.36,132.15 70.38,132.06 70.36,131.96 70.25,131.84 70.2,131.68 70.16,131.6 70.08,131.57 69.9,131.57 69.74,131.41 69.32,131.41 69.29,131.42 69.09,131.47 68.89,131.42 68.86,131.41 67.75,131.41 67.7,131.42 67.65,131.45 67.33,131.61 66.99,131.49 66.97,131.47 66.88,131.43 66.8,131.46 66.78,131.48 66.68,131.54 66.57,131.56 66.52,131.56 66.3,131.78 66.3,132.62 66.41,132.72 67.41,132.72 67.43,132.71 67.52,132.68 67.6,132.67 67.65,132.67 67.7,132.67 67.84,132.72 67.96,132.8 68.01,132.8 68.01,132.85 68.03,132.88 68.18,132.9 68.32,132.83 68.35,132.75 68.39,132.67 69.21,132.8 68.57,133.34 68.41,133.42 68.35,133.59 68.35,134.07 68.98,134.71 72.08,134.71
P0V75_BMC_VTTREF_NODE1 on IN3 (solid shape): outline of 1621 points within 48.05,123.61 70.38,140.27
P1V0_NODE1 on TOP (solid shape): 153.85,58.28 153.85,55.86 153.76,55.76 152.75,55.76 152.09,56.42 152.09,57.22 152.05,57.27 152.05,57.34 151.38,58 150.91,58.47 150.33,58.47 150.24,58.51 150.2,58.6 150.2,59.11 150.48,59.38 150.51,59.38 150.66,59.53 152.61,59.53
P1V0_NODE1 on TOP (solid shape): 179.79,85.75 179.79,84.54 178.97,83.72 175.5,83.72 175.01,83.23 175.01,80.11 174.73,79.83 174.35,79.83 174.11,79.58 174.09,79.57 174.09,77.48 174.1,77.47 174.1,77.26 174.09,77.24 173.01,77.24 173,77.25 172.78,77.25 172.06,77.25 171.76,76.94 171.01,76.94 170.88,77.06 170.88,77.15 167.19,77.15 166.42,77.92 166.42,84.48 167.18,85.24 167.36,85.31 167.54,85.24 168.09,85.12 168.41,85.59 168.41,85.69 168.44,85.78 168.53,85.81 175.52,85.81 176.08,86.37 179.17,86.37
P1V0_NODE1 on TOP (solid shape): outline of 1006 points within 138.93,137.02 152.35,150.27
P1V0_NODE1 on BOTTOM (solid shape): 143.59,143.2 143.59,142.6 143.46,142.47 141.28,142.47 141.23,142.51 141.23,143.21 141.3,143.27 143.53,143.27
P1V0_NODE1 on BOTTOM (solid shape): 179.79,85.75 179.79,84.54 178.97,83.72 175.5,83.72 175.01,83.23 175.01,80.11 174.73,79.83 174.35,79.83 174.11,79.58 174.09,79.57 174.09,77.54 173.8,77.24 173.01,77.24 173,77.25 172.78,77.25 172.06,77.25 171.76,76.94 171.01,76.94 170.88,77.06 170.88,77.15 167.19,77.15 166.42,77.92 166.42,84.48 167.18,85.24 167.36,85.31 167.54,85.24 168.09,85.12 168.41,85.59 168.41,85.69 168.44,85.78 168.53,85.81 175.52,85.81 176.08,86.37 179.17,86.37
P1V0_NODE1 on BOTTOM (solid shape): outline of 993 points within 138.08,133.66 154.37,152.1
P1V0_NODE1 on IN1 (solid shape): outline of 3773 points within 137.36,82.81 163.61,153.44
P1V0_NODE1 on IN2 (solid shape): outline of 1811 points within 138.23,136.14 160.43,151.13
P1V0_NODE1 on IN3 (solid shape): outline of 1305 points within 136.22,57.61 180.6,88.58
P1V0_NODE1 on IN3 (solid shape): outline of 1451 points within 139.76,133.33 153.65,151.83
P1V0_PCI_SW_A on BOTTOM (solid shape): outline of 219 points within 136.16,135.98 146.69,144.95
P1V0_SATA on TOP (solid shape): 156.43,58.49 156.43,58.49 156.66,58.26 158.04,58.26 158.41,57.89 158.41,56.2 157.86,55.66 154.67,55.66 154.54,55.79 154.54,57.61 154.28,57.87 154.28,58.64 154.77,59.13 155.8,59.13
P1V0_SATA on TOP (solid shape): 152,68.97 152,62.57 151.84,62.41 151.28,62.41 150.24,63.46 150.24,64.88 149.67,65.45 149.67,68.94 149.87,69.13 151.83,69.13
P1V0_SATA on BOTTOM (solid shape): outline of 1064 points within 148.66,56.02 163.13,71.78
P1V0_SATA on IN1 (solid shape): outline of 1526 points within 149.83,56.22 167.85,70.58
P1V5_CLK_NODE1 on TOP (solid shape): 153.89,120.88 153.89,119.39 153.58,119.08 150.28,119.08 149.95,119.4 149.95,121.01 150.06,121.11 153.66,121.11
P1V05_CLK_NODE1 on BOTTOM (solid shape): 143.07,122.84 143.15,122.63 143.01,122.44 142.99,121.77 143.57,122.11 143.64,122.3 143.82,122.38 146.77,122.38 147.05,122.1 147.05,121.38 146.76,121.09 142.37,121.09 142.35,121.07 141,121.07 140.11,120.18 140.11,118.42 140.09,118.39 140.2,117.72 140.88,117.76 141,117.88 141,117.88 141.05,117.93 141.46,117.93 141.5,117.89 141.5,117.47 141.32,117.29 139.61,117.29 138.97,117.93 138.97,119.19 138.98,119.22 138.94,119.62 138.6,119.84 138.52,119.88 138.49,119.96 138.49,123.49 138.66,123.66 142.25,123.66
P1V5_CLK_NODE1 on IN1 (solid shape): outline of 307 points within 140.05,117.71 153.18,123.69
P1V5_CLK_NODE1_R on TOP (solid shape): 155.64,123.22 155.64,121.62 155.6,121.57 152.55,121.57 152.55,121.58 152.34,121.58 152.23,121.69 152.23,123.24 152.43,123.45 155.42,123.45
P1V05_CLK_NODE1_R on BOTTOM (solid shape): 140.22,126.28 140.21,126.23 140.19,126.19 140.11,125.95 140.19,125.71 140.22,125.68 140.22,124.55 140.05,124.37 136.49,124.37 136.2,124.67 136.2,126.51 136.5,126.81 139.69,126.81
P1V05_LAN1 on BOTTOM (solid shape): outline of 901 points within 54.09,147.05 65.9,161.75
P1V05_LAN1 on IN1 (solid shape): outline of 1330 points within 50.67,148.45 63.15,161.31
P1V05_LAN2 on BOTTOM (solid shape): outline of 1125 points within 163.97,145.66 175.56,161.54
P1V05_LAN2 on IN1 (solid shape): outline of 688 points within 166.74,145.32 178.97,159.39
P1V05_LAN2 on IN3 (solid shape): outline of 703 points within 166.74,145.32 178.97,159.39
P1V5_NODE1 on TOP (solid shape): 52.2,114.62 52.2,112.9 51.98,112.68 50.64,112.68 50.53,112.72 50.41,112.73 49.58,112.73 49.48,112.72 49.38,112.69 49.35,112.68 48.34,112.68 48.28,112.74 48.28,114.6 48.32,114.64 52.17,114.64
P1V05_NODE1 on TOP (solid shape): 37.33,117.67 37.42,117.63 37.46,117.54 37.46,114.54 37.25,114.33 36,114.33 35.72,114.05 35.72,110.94 35.71,110.92 35.71,107.44 35.86,107.29 35.86,105.65 35.61,105.4 28.12,105.4 28.03,105.44 27.99,105.53 27.99,117.56 28.09,117.67
P1V05_NODE1 on TOP (solid shape): outline of 291 points within 92.05,73.4 108.02,80.08
P1V05_NODE1 on BOTTOM (solid shape): 103.36,79.75 103.36,79.53 103.23,79.4 101.05,79.4 100.95,79.49 100.95,80.99 101.05,81.09 102.03,81.09
P1V05_NODE1 on BOTTOM (solid shape): 138.15,123.63 138.15,122.54 137.93,122.32 136.99,122.32 136.82,122.49 136.82,123.68 136.97,123.83 137.95,123.83
P1V5_NODE1 on BOTTOM (solid shape): 52.2,114.62 52.2,112.9 51.98,112.68 50.64,112.68 50.53,112.72 50.41,112.73 49.58,112.73 49.48,112.72 49.38,112.69 49.35,112.68 48.34,112.68 48.28,112.74 48.28,114.6 48.32,114.64 52.17,114.64
P1V05_NODE1 on BOTTOM (solid shape): 39.78,117.72 39.78,114.43 39.68,114.33 36.22,114.33 35.72,113.84 35.72,110.94 35.71,110.92 35.71,107.44 35.86,107.29 35.86,105.65 35.61,105.4 28.12,105.4 28.03,105.44 27.99,105.53 27.99,117.56 28.09,117.67 29.95,117.67 30.53,118.25 39.25,118.25
P1V05_NODE1 on BOTTOM (solid shape): 63.11,80.1 63.2,80.06 63.24,79.97 63.24,79.25 63.48,79.01 65.02,79.01 65.05,79 65.23,78.96 65.42,79 65.44,79.01 65.56,79.01 65.65,79.1 65.65,79.24 65.65,79.26 65.67,79.33 65.68,79.4 65.68,79.76 65.72,79.81 66.26,79.81 66.31,79.75 66.31,78.29 66.61,78 67.05,78 67.1,77.95 67.1,77.31 67.05,77.26 66.45,77.26 66.18,77.54 65.89,77.54 65.61,77.82 64.96,77.82 64.57,78.21 64.42,78.21 64.42,78.21 64.15,78.21 63.84,77.9 62.09,77.9 61.85,78.15 61.85,78.41 62.54,79.1 62.54,79.99 62.65,80.1
P1V05_NODE1 on BOTTOM (solid shape): 77.42,72.34 77.42,71.73 77.42,71.72 77.42,71.53 77.39,71.44 77.3,71.4 77.05,71.29 76.94,71.03 76.94,70.98 76.87,70.91 76.87,70.23 76.75,70.12 76.4,70.12 76.32,70.15 76.29,70.24 76.29,70.97 76.11,71.15 72.96,71.15 72.96,71.15 72.19,71.15 72.11,71.07 72.06,71.07 71.96,70.96 71.96,70.94 71.94,70.89 71.9,70.86 71.9,70.33 71.87,70.24 71.78,70.2 71.42,70.2 71.33,70.29 71.35,70.3 71.35,72.26 71.37,72.29 71.85,72.29 71.93,72.21 71.93,71.88 72.03,71.78 73.85,71.78 73.88,71.77 74.03,71.74 74.19,71.77 74.21,71.78 75.43,71.78 75.52,71.69 76.28,71.69 76.4,71.71 76.52,71.76 76.55,71.78 76.68,71.78 76.76,71.85 76.76,72.34 76.83,72.41 77.34,72.41
P1V05_NODE1 on BOTTOM (solid shape): 68.84,81.52 69.4,81.52 69.44,81.47 69.45,81.42 69.45,81.06 69.7,80.81 70.1,80.81 70.23,80.68 70.23,79.88 70.35,79.75 73.46,79.75 73.53,79.69 73.53,78.92 73.52,78.91 73.52,78.36 73.51,78.31 73.47,78.26 73.42,78.23 73.35,78.23 73.18,78.24 73.02,78.2 73,78.19 72.16,78.19 71.43,77.46 71.29,77.46 71.15,77.59 70.58,77.59 70.56,77.57 70.52,77.54 70.47,77.54 68.19,77.54 68.12,77.46 67.52,77.46 67.39,77.59 67.39,78 67.44,78.05 70.74,78.05 70.74,78.05 71.07,78.05 71.36,78.34 71.36,78.81 71.06,79.11 69.12,79.11 69,79.24 69,79.57 68.9,79.67 68.86,79.76 68.9,79.85 68.97,79.88 69.05,79.87 69.5,80.47 68.9,80.02 68.92,79.98 68.91,79.89 68.88,79.86 68.79,79.83 68.7,79.86 68.58,79.98 68.43,79.98 68.3,80.11 68.3,81.43 68.3,81.57 68.38,81.65 68.71,81.65
P1V05_NODE1 on BOTTOM (solid shape): 75.13,76.25 75.13,75.36 75.13,75.35 75.13,74.37 75.23,74.27 75.23,74.22 75.29,74.16 75.33,74.08 75.31,74 75.56,73.43 76.01,73.86 76.1,73.97 76.24,74.01 76.69,74.01 76.7,74 76.7,73.97 76.73,73.97 76.81,73.89 76.83,73.89 77.57,73.89 77.6,73.85 77.6,72.82 77.56,72.73 77.47,72.69 75.23,72.69 75.16,72.77 75,72.77 74.97,72.78 74.88,72.81 74.78,72.83 74.01,72.83 73.96,72.77 72.31,72.77 72.27,72.81 72.27,73.11 72.4,73.24 72.45,73.25 72.88,73.25 73.05,73.41 73.05,73.9 73.05,73.96 73.09,74.05 73.18,74.09 73.48,74.09 73.71,74.32 73.76,74.31 73.8,74.29 74.41,74.55 73.89,74.95 73.74,75.04 73.68,75.2 73.68,75.59 73.81,75.71 74.29,75.71 74.47,75.89 74.47,76.12 74.64,76.29 75.09,76.29
P1V05_NODE1 on BOTTOM (solid shape): outline of 169 points within 63.27,71.09 72.61,76.49
P1V05_NODE1 on BOTTOM (solid shape): outline of 577 points within 51.33,70.27 62.15,79.44
P1V05_NODE1 on IN1 (solid shape): 138.2,123.24 138.2,122.5 138.02,122.32 136.77,122.32 136.72,122.37 136.72,123.19 136.83,123.3 138.14,123.3
P1V05_NODE1 on IN1 (solid shape): outline of 876 points within 173,95.17 185.08,106.63
P1V5_NODE1 on IN1 (solid shape): outline of 3210 points within 46.81,72.83 68.12,114.94
P1V05_NODE1 on VCC1 (solid shape): outline of 581 points within 13.05,70.09 78.16,118.5
P1V05_NODE1 on VCC2 (solid shape): outline of 100 points within 27.77,69.83 78.19,117.13
P1V05_NODE1 on IN2 (solid shape): outline of 11813 points within 56.45,60.62 186.42,109.03
P1V5_NODE1 on IN3 (solid shape): outline of 1005 points within 60.59,71.13 68.14,83.9
P1V05_NODE1 on IN3 (solid shape): outline of 1567 points within 67.47,71.15 77.82,81.11
P1V5_NODE1_DDR3_VREF_A_A on BOTTOM (solid shape): 82.97,31.39 82.97,29.8 82.73,29.56 79.02,29.56 78.95,29.63 78.95,31.41 79,31.46 82.9,31.46
P1V05_STB_NODE1_XDP_A on TOP (solid shape): 121.1,66.14 121.18,66.11 121.22,66.02 121.22,65.36 121.04,65.17 118.62,65.17 118.07,65.72 118.06,65.72 118.01,65.77 115.64,65.77 115.64,65.78 115.64,66.02 115.66,66.03 118.16,66.03 118.22,66.1 118.66,66.1 118.7,66.08 118.95,66 119.2,66.11 119.24,66.13 119.29,66.14
P1V05_STB_NODE1_XDP_B on TOP (solid shape): 126.64,66.8 126.64,65.12 126.53,65.01 125.35,65.01 124.81,65.55 124.27,65.55 124.22,65.56 124.18,65.59 124.05,65.71 124.03,65.71 124.03,65.99 124.18,66.13 124.37,66.13 124.41,66.18 124.64,66.18 125.4,66.94 126.51,66.94
P1V05_SUS_NODE1 on TOP (solid shape): 100.36,85.01 100.36,83.31 100.3,83.25 99.59,83.25 99.45,83.23 99.32,83.17 99.29,83.15 98.18,83.15 97.93,83.39 97.93,84.94 98.15,85.16 100.21,85.16
P1V05_SUS_NODE1 on TOP (solid shape): 111.14,138.15 111.14,137.31 111.64,136.81 111.64,135.89 111.23,135.49 110.16,135.49 109.84,135.8 107.36,135.8 107.34,135.83 107.34,137.46 107.23,137.58 107.23,137.99 107.4,138.16 107.41,138.16 107.48,138.23 111.05,138.23
P1V5_SUS_NODE1 on TOP (solid shape): 47.71,115.6 47.71,112.56 48.72,111.55 50.12,111.55 50.73,110.94 50.73,102.21 49.98,101.46 45.19,101.46 44.93,101.72 44.93,103.32 44.95,103.34 46.69,103.34 47.05,102.98 48.43,102.98 48.52,103.07 48.52,107.15 48.53,107.16 48.54,107.28 48.53,107.39 48.52,107.41 48.52,107.98 47.82,108.68 44.25,108.68 43.97,108.96 43.97,115.53 44.09,115.65 45.46,115.65 45.58,115.77 47.54,115.77
P1V5_SUS_NODE1 on BOTTOM (solid shape): 49.49,111.46 51.31,111.46 51.83,110.94 51.83,104.42 47.02,99.61 45.49,99.61 44.86,100.25 44.86,101.46 44.53,101.79 43.58,101.79 43.46,101.9 43.46,104.47 43.47,104.48 49.24,104.48 49.24,104.47 49.65,104.47 49.93,104.75 49.93,107.54 46.37,111.09 46.37,112.18 46.51,112.31 48.63,112.31
P1V05_SUS_NODE1 on BOTTOM (solid shape): outline of 268 points within 100.94,70.87 107.71,78.17
P1V05_SUS_NODE1 on BOTTOM (solid shape): outline of 1565 points within 104.63,108.2 111.46,138.85
P1V5_SUS_NODE1 on IN1 (solid shape): 50.87,104.28 50.87,101.68 49.55,100.36 45.43,100.36 45.05,100.73 45.05,104.41 45.14,104.51 50.64,104.51
P1V5_SUS_NODE1 on IN1 (solid shape): 49.05,113.72 49.05,109.05 48.82,108.82 44.58,108.82 44.39,109.01 44.39,114.62 44.58,114.81 47.96,114.81
