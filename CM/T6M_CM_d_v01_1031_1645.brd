# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VR_PVCCP_NODE1_FB: length 9.1
  TOP w0.178: 123.12,135.23 122.99,135.1 PU8.6
  TOP w0.254: PR66.2 126.61,136.02 126.25,136.37 PC110.2 v1(125.28,136.67) 124.31,135.71 PR68.2 123.6,135.71 123.12,135.23 ; PR66.2 128.04,137 PR67.1 ; PR66.2 PR69.1
VR_PVCCP_NODE1_FB_RC: length 1.9
  TOP w0.254: v1(129.64,138.07) PC103.1 128.82,138.05 PR67.2
VR_PVCCP_NODE1_FB_RR: length 1.9
  TOP w0.254: PR70.1 130.22,135.33 v1(129.89,135) 129.89,134.99 129.28,134.99 PR69.2
VR_PVCCP_NODE1_IBIAS: length 4.1
  TOP w0.178: PU8.19 118.1,137.93 117.56,138.48 116.66,138.48 PC115.1 PR78.2 v1(114.73,138.5)
VR_PVCCP_NODE1_ICCMAX: length 5.4
  TOP w0.178: 120.75,138.98 120.75,138.97 120.75,138.47 120.5,138.22 PU8.13
  TOP w0.254: PR64.2 120.51,142.01 120.22,141.72 120.22,140.32 120.6,139.94 PR65.2 v1(120.75,139.22) 120.75,138.98
VR_PVCCP_NODE1_ISEN1P_CC: length 6.7
  TOP w0.178: 123.38,133.63 123.28,133.63 123.02,133.9 PU8.3
  TOP w0.254: 123.38,133.63 123.94,133.63 124.75,132.82 PR55.1 PR58.1 125.77,132.42 v1(126.47,132.42) 126.47,132.37 126.72,132.37 PC98.1
VR_PVCCP_NODE1_ISEN1P_RR: length 44.9
  TOP w0.254: v1(127.07,129.56) PR59.1 127.07,130.88 126.34,131.61 PR58.2 ; v1(115.25,119.74) 115.76,119.22 PR56.1
  IN1 w0.254: v1(127.07,129.56) 127.07,131.13 128.9,132.96 131.32,132.96 132.8,131.48 132.8,119.74 131.64,118.58 124.29,118.58 122.28,116.57 119.74,116.57 116.57,119.74 v1(115.25,119.74)
VR_PVCCP_NODE1_LGATE1: length 1.4
  TOP w0.178: PU8.38 120.5,131.69 120.24,131.42 v1(120.24,131.12)
  vias: v1(116.33,123.35) v1(117.09,123.35) v1(119.95,130.54)
VR_PVCCP_NODE1_OCSET: length 3.7
  TOP w0.178: 119.08,138.9 119.3,138.68 PU8.16
  TOP w0.254: PR77.2 118.5,139.79 PR76.2 118.5,139.7 v1(119.08,139.12) 119.08,138.9
VR_PVCCP_NODE1_PHASE1: length 1.4
  TOP w0.178: 120.9,131 PU8.39
  vias: v1(123.21,120.98)
VR_PVCCP_NODE1_PVCC: length 1.6
  TOP w0.178: PU8.37 120.1,131.88 119.75,131.52 119.43,131.52 v1(119.23,131.33)
VR_PVCCP_NODE1_RGND: length 6.3
  TOP w0.102: PC109.1 v1(126.43,137.34)
  TOP w0.178: PU8.7 122.79,135.5 123.73,136.44 124.11,136.44 125.4,137.73 PJ15.1 125.42,137.99 PC109.1
VR_PVCCP_NODE1_SETINI: length 5.7
  TOP w0.178: 121.5,138 121.3,137.81 PU8.11
  TOP w0.254: 121.5,138 121.74,138.25 121.74,138.9 122.36,139.52 122.36,140.25 122.66,140.55 PR60.2 122.85,140.93 v1(123.24,141.32) 122.83,141.73 PR57.2
VR_PVCCP_NODE1_TEMPMAX: length 5.6
  TOP w0.178: PU8.12 120.9,138.09 121.37,138.55 121.37,139.04
  TOP w0.254: 121.37,139.04 121.37,139.43 121.85,139.91 PR62.2 121.57,139.94 121.29,140.22 121.29,141.12 v1(121.54,141.38) 121.8,141.63 PR61.2
VR_PVCCP_NODE1_TONSET: length 2.5
  TOP w0.178: PR42.1 v1(123.73,133.03) 123.2,133.03 122.73,133.5 PU8.2
VR_PVCCP_NODE1_TONSET_R: length 2.4
  TOP w0.254: PR43.1 PC95.1 123.73,130.57 123.73,130.58 v1(123.73,130.95) PR42.2
VR_PVCCP_NODE1_TSEN: length 6.4
  TOP w0.178: PU8.15 119.7,139.42 119.71,139.42
  TOP w0.254: PR73.2 118.51,141.99 PR74.1 118.51,141.84 v1(118.94,141.41) 119.11,141.24 119.11,140.2 119.36,139.95 PC111.2 119.69,139.44 119.71,139.42
VR_PVCCP_NODE1_TSEN_R: length 34.9
  TOP w0.254: v1(113.53,140.59) 113.53,142.53 115.23,144.23 119.48,144.23 119.81,143.9 PR72.2 119.69,143.67 PR73.1 ; PR75.2 116.41,119.86 115.39,120.88 114.72,120.88 112.24,123.37 112.24,128.09 113.42,129.27 v1(114.03,129.27)
  IN1 w0.254: v1(114.03,129.27) 114.19,129.44 114.19,139.51 113.91,139.8 113.91,139.83 113.53,140.21 v1(113.53,140.59)
VR_PVCCP_NODE1_UGATE1: length 0.6
  TOP w0.178: PU8.40 121.3,131.8
  vias: v1(121.58,130.61) v1(121.6,131.28) v1(125.04,123.26) v1(125.77,123.26)
VR_PVCCP_NODE1_VCC: length 56.2
  TOP w0.178: PU8.9 122.51,136.3 122.78,136.56 v1(122.78,137.09) ; v1(117.83,139.09) 118.29,139.09 118.9,138.48 PU8.17
  TOP w0.254: v1(114.26,128.5) 113.99,128.5 113,127.51 113,123.7 115.03,121.67 115.79,121.67 116.5,120.96 PR75.1 ; PR72.1 120.61,144.31 119.83,145.09 114.99,145.09 112.77,142.87 v1(112.77,139.52)
  TOP w0.381: PR72.1 120.76,143.65 PR64.1 121.8,142.81 PR61.1 122.82,142.81 PR57.1 123.76,142.82 124.13,142.45 v1(124.13,141.24)
  TOP w0.457: PR76.1 117.7,139.22 v1(117.83,139.09)
  IN1 w0.254: v1(114.26,128.5) 113.71,128.5 113.61,128.6 113.61,128.61 113.26,128.95 113.26,129.59 113.43,129.75 113.43,129.75 113.43,138.57 112.77,139.23 v1(112.77,139.52)
  IN1 w0.508: v1(124.13,141.24) 123.06,140.17 123.06,138.64 v1(122.32,137.9) 122.32,139.06 121.43,139.94 118.68,139.94 v1(117.83,139.09)
VR_PVCCP_NODE1_VSEN: length 7.2
  TOP w0.254: PR70.2 130.22,138.39 129.74,138.87 128.96,138.87 128.7,139.12 PJ14.1 128.11,138.14 PC103.2 127.65,138.07 v1(127.27,138.44) 126.92,138.79 PC109.2
VSENSE_HSC_NODE1: length 3.5
  TOP w0.254: U100.2 46.17,181.38 46.54,181.01 v1(47.13,181.01) 48.65,181.01
VSENSE_P1V05_NODE1_N: length 117.9
  TOP w0.254: PR27.2 PC65.1 27.84,133.42 v1(27.84,132.74) PU6.3
  IN1 w0.254: v1(40.03,91.63) 40.13,91.72 41.32,91.72 43.96,89.08 43.96,74.68 46.36,72.28 51.08,72.28 51.93,71.43 62.48,71.43 63.09,72.04 67.82,72.04 68.23,71.63 68.23,70.69 68.7,70.23 69.88,70.23 70.15,69.96 v1(70.15,69.65)
  BOTTOM w0.254: v1(40.03,91.63) 39.92,91.74 33.21,91.74 28.29,96.67 28.29,100.58 26.1,102.76 22.65,102.76 20.37,105.04 20.37,121.86 19.11,123.12 19.11,132.11 20.68,133.69 23.17,133.69 23.78,133.08 25.32,133.08 25.66,132.74 v1(27.84,132.74) ; v1(70.15,69.65) 69.87,69.93 PJ7.2
VSENSE_P1V05_NODE1_P: length 112.8
  TOP w0.254: PR29.1 25.07,132.82 25.07,132.58 v1(24.7,132.21) 25.07,131.84 PR30.2
  IN1 w0.254: v1(40.03,92.26) 40.16,92.13 41.49,92.13 44.37,89.25 44.37,74.85 46.53,72.69 51.25,72.69 52.1,71.84 62.32,71.84 62.93,72.45 67.98,72.45 68.64,71.79 68.64,70.86 68.87,70.63 70.05,70.63 70.56,70.13 70.56,69.97 v1(70.87,69.66)
  BOTTOM w0.254: v1(40.03,92.26) 39.92,92.15 33.38,92.15 28.69,96.84 28.69,100.75 26.27,103.17 22.82,103.17 20.78,105.21 20.78,122.03 19.52,123.29 19.52,131.95 20.85,133.28 23.01,133.28 23.61,132.67 24.23,132.67 v1(24.7,132.21) ; v1(70.87,69.66) 70.63,69.89 PJ8.2
VSENSE_PV_VDDR_NODE1_N: length 154.5
  TOP w0.178: PU7.1 48.04,11.1 47.73,11.4
  TOP w0.254: v1(46.34,13.59) 46.35,13.59 46.91,13.03 PR34.1 46.96,11.98 47.15,11.98 47.73,11.4
  IN3 w0.254: v1(119.13,58.01) 119.56,57.58 120.07,57.58 120.93,56.72 120.93,30.67 119.68,29.41 119.68,24.42 115.72,20.46 108.89,20.46 106.82,18.39 104.42,18.39 103.32,17.29 78.15,17.29 76.88,18.56 56.13,18.56 55.08,17.51 49.68,17.51 47.52,15.35 47.52,14.5 47.24,14.22 46.97,14.22 v1(46.34,13.59)
  BOTTOM w0.254: PJ11.1 85.78,63.39 86.43,63.39 92.24,57.58 118.7,57.58 v1(119.13,58.01)
VSENSE_PV_VDDR_NODE1_P: length 152.9
  TOP w0.178: 49.05,12.47 49.32,12.21 PU7.20
  TOP w0.254: 49.05,12.47 48.13,12.47 47.89,12.71 PR35.1 47.41,13.84 46.97,14.28 v1(46.97,14.8)
  IN3 w0.254: v1(119.13,56.74) 119.56,57.18 119.9,57.18 120.53,56.55 120.53,30.84 119.27,29.58 119.27,24.58 115.55,20.86 108.72,20.86 106.65,18.79 104.25,18.79 103.15,17.7 78.32,17.7 77.05,18.97 55.97,18.97 54.91,17.91 49.52,17.91 46.97,15.37 v1(46.97,14.8)
  BOTTOM w0.254: v1(119.13,56.74) 118.7,57.18 92.07,57.18 86.26,62.98 85.98,62.98 PJ12.1
VSENSE_VCC_CPU_NODE1: length 124
  TOP w0.254: PC104.2 126.92,140.59 v1(127.31,140.99) 127.68,140.99 128.05,140.62 PJ14.2 128.11,140.62 PR63.1 ; U2.AD41 73.65,77.4 v1(74.04,77.01)
  IN1 w0.254: v1(74.04,77.01) 74.54,76.5 75.07,76.5 75.44,76.87 75.44,77.65 77.36,79.56 77.36,79.57 77.57,79.78 79.22,79.78 79.63,80.2 90.04,80.2 90.35,80.5 95.62,80.5 96.29,81.17 100.35,81.17 101.44,82.26 101.44,85.19 102.22,85.98 105.49,85.98 106.13,86.62 106.13,100.11 102.99,103.25 102.99,105.38 104.61,106.99 104.61,122.32 105.44,123.15 105.44,126.55 106.27,127.39 106.82,127.39 107.38,127.96 109.27,127.96 111.29,129.98 111.29,140.6 114.14,143.45 127.32,143.45 128.2,142.57 128.2,140.83 127.94,140.56 127.77,140.56 127.75,140.56 127.45,140.56 127.31,140.7 v1(127.31,140.99)
VSENSE_VSS_CPU_NODE1: length 125.3
  TOP w0.254: U2.AF41 v1(73.23,77) ; PJ15.2 125.4,139.74 PR71.1 PC104.1 127.25,139.79 v1(127.33,139.72)
  IN1 w0.254: v1(127.33,139.72) 127.33,139.97 127.51,140.15 127.75,140.15 128.01,140.16 128.11,140.16 128.61,140.66 128.61,142.74 127.49,143.86 113.97,143.86 110.88,140.77 110.88,130.15 109.1,128.36 107.21,128.36 106.65,127.8 106.1,127.8 105.03,126.72 105.03,123.32 104.2,122.49 104.2,107.16 102.59,105.54 102.59,103.08 105.73,99.94 105.73,86.79 105.32,86.38 102.06,86.38 101.03,85.36 101.03,82.43 100.18,81.57 96.12,81.57 95.45,80.91 90.18,80.91 89.87,80.6 79.46,80.6 79.05,80.19 77.4,80.19 77.07,79.86 77.06,79.86 75.65,78.44 74.67,78.44 v1(73.23,77)
WDT_LED: length 4
  TOP w0.102: D25.A 80.88,176.78 82.44,176.78 v1(82.51,176.71) 82.92,176.71 83.51,176.12 U128.30
XDP_CPU_NODE1_PG_RST_R: length 6.2
  TOP w0.102: J3.41 118.9,66.41 v1(118.93,66.38)
  BOTTOM w0.102: R222.1 R220.2 118.39,65.15 118.93,65.68 v1(118.93,66.38)
XDP_CPU_NODE1_PRDY_L: length 49.1
  TOP w0.102: v1(114.55,74.22) 114.55,74.97 114.99,75.41 J3.5 ; R114.1 89.54,75.15 88.54,76.15 88.54,76.16 v1(88.28,76.42) ; v1(79.58,78.65) 79.19,78.26 U2.AC52
  IN1 w0.114: v1(79.58,78.65) 79.58,78.37 80.03,77.92 82.8,77.92 83.12,77.6 83.87,77.6 84.57,76.9 87.88,76.9 88.28,76.5 v1(88.28,76.42) 88.48,76.22 89.63,76.22 89.97,75.89 94.07,75.89 95.27,74.69 96.82,73.13 97.82,73.13 98.04,73.35 100.45,73.35 100.8,73 104.33,73 106.32,74.99 107.51,74.99 108.92,76.39 111.91,76.39 112.52,75.79 112.52,74.06 112.99,73.58 113.92,73.58 v1(114.55,74.22)
XDP_CPU_NODE1_PREQ_L: length 40.5
  TOP w0.102: U2.AE62 84.13,77.12 84.45,76.79 84.45,76.34 84.56,76.23 85.43,76.23 85.6,76.07 85.67,76.07 86.22,75.52 87.81,75.52 89.66,73.68 93.79,73.68 R113.1 94.96,73.8 v1(97.5,73.8) ; J3.3 114.56,75.91 113.13,74.48 v1(113.13,74.31)
  IN1 w0.114: v1(113.13,74.31) 113.13,74.31 113.13,76.3 112.25,77.19 109.12,77.19 107.34,75.41 106.14,75.41 104.15,73.42 101.14,73.42 99.81,74.76 98.45,74.76 97.5,73.81 v1(97.5,73.8)
XDP_CPU_NODE1_PWROK: length 107.8
  TOP w0.102: v1(190.99,112.88) 191.16,113.05 191.16,114.11 192.04,114.99 192.04,116.36 U102.A2
  IN3 w0.114: v1(127.3,73.49) 128.9,75.09 128.9,80.95 142.72,94.78 155.17,94.78 168.87,108.48 168.87,108.55 170.84,110.53 177.69,110.53 179.68,112.51 183.09,112.51 183.33,112.28 190.39,112.28 v1(190.99,112.88)
  BOTTOM w0.102: v1(127.3,73.49) 126.99,73.8 124.48,73.8 123.36,72.67 122.8,72.67 120.16,70.03 114.97,70.03 113.51,68.57 113.51,67.69 114.42,66.77 115.56,66.77 116.04,66.29 R219.2
XDP_CPU_NODE1_PWROK_R: length 4.5
  TOP w0.102: v1(118.35,66.98) 118.28,66.91 J3.39
  BOTTOM w0.102: R219.1 117.07,66.16 117.34,66.43 117.34,66.96 v2(118.01,67.64) 118.35,67.3 v1(118.35,66.98)
XDP_CPU_NODE1_PWROK_STALL_L: length 112.3
  TOP w0.102: J3.47 117.92,64.91 118.32,64.51 119.24,64.51 v1(119.35,64.4) ; U102.H7 v5(186.54,123.87)
  IN3 w0.114: v1(125.2,73.37) 125.37,73.54 125.37,81.71 141.88,98.22 153.18,98.22 167.62,112.66 167.62,118.37 172.01,122.76 174.36,122.76 174.73,123.13 178.29,123.13 179.46,124.29 185.87,124.29 186.3,123.87 v5(186.54,123.87)
  BOTTOM w0.102: v1(119.35,64.4) 119.35,65.78 119.44,65.86 119.44,66.99 118.18,68.24 R227.1 ; R227.1 R226.2 117.14,69.27 117.37,69.05 120.94,69.05 125.2,73.31 v1(125.2,73.37) ; R227.1 C184.2
XDP_CPU_NODE1_VISA0: length 59.5
  TOP w0.102: J3.4 120.51,75.91 118.89,77.52 115.09,77.52 111.16,73.59 111.16,67.9 112.2,66.85 v1(112.2,66.17) ; v1(79.95,71.22) 79.58,71.6 U2.AT53
  IN1 w0.114: v1(112.21,66.17) 112.37,66 112.37,65.47 111.23,64.34 103.41,64.34 102.88,64.87 97.55,64.87 92.47,69.94 87.9,69.94 87.42,70.42 86.1,70.42 84.26,72.25 80.83,72.25 79.95,71.37 v1(79.95,71.22)
XDP_CPU_NODE1_VISA1: length 55
  TOP w0.102: v1(79.54,73.04) 79.57,73.01 U2.AR53 ; J3.9 115.68,74.41 114.19,72.91 113.93,72.91 113.18,73.66 112.93,73.66 112.75,73.48 112.75,73.23 113.5,72.48 113.5,72.22 112.02,70.74 112.02,70.29 v1(111.73,70)
  IN1 w0.114: v1(111.73,70) 111.29,70 110.17,71.11 108.51,71.11 108.33,71.3 108.33,71.55 108.51,71.73 109.99,71.73 110.17,71.92 110.17,72.17 109.99,72.36 107.89,72.36 107.71,72.17 107.71,71.3 107.53,71.11 107.25,71.11 107.09,70.95 106.83,70.95 106.57,71.21 106.32,71.21 106.13,71.03 106.13,70.77 106.39,70.51 106.39,70.26 106.16,70.02 105.17,70.02 104.99,70.2 104.99,70.29 104.8,70.47 104.55,70.47 104.36,70.29 104.36,70.2 104.18,70.02 103.92,70.02 103.74,70.2 103.74,70.29 103.56,70.47 103.3,70.47 103.12,70.29 103.12,70.2 102.94,70.02 102.68,70.02 102.5,70.2 102.5,70.29 102.32,70.47 102.06,70.47 101.88,70.29 101.88,70.2 101.69,70.02 101.38,70.02 100.96,69.61 96.62,69.61 93.06,73.16 92.8,73.16 92.79,73.17 92.47,73.17 92.18,72.89 90.7,72.89 90.07,73.52 89.39,73.52 89.23,73.68 86.49,73.68 85.33,74.84 82.95,74.84 81.64,73.52 81.21,73.52 80.79,73.1 80.55,73.1 80.14,72.69 79.88,72.69 v1(79.54,73.04)
XDP_CPU_NODE1_VISA2: length 59.3
  TOP w0.102: J3.11 115.65,73.91 112.66,70.91 112.66,69.55 112.35,69.24 112.35,67.18 112.81,66.72 112.81,64.48 v1(113.19,64.09) ; v1(83,71.22) 82.62,71.6 U2.AT59
  IN1 w0.114: v1(113.19,64.09) 112.8,64.09 110.61,61.9 110.61,61.65 110.79,61.46 111.05,61.46 112.72,63.14 112.98,63.14 113.16,62.96 113.16,62.7 111.05,60.59 109.28,60.59 109.09,60.41 109.09,60.25 108.91,60.06 108.65,60.06 108.47,60.25 108.47,60.41 108.29,60.59 108.03,60.59 107.85,60.41 107.85,60.25 107.67,60.06 107.41,60.06 107.23,60.25 107.23,60.41 107.04,60.59 106.79,60.59 106.6,60.41 106.6,60.25 106.42,60.06 106.16,60.06 105.98,60.25 105.98,60.41 105.8,60.59 105.54,60.59 105.36,60.41 105.36,60.25 105.18,60.06 104.92,60.06 104.74,60.25 104.74,60.41 104.56,60.59 104.14,60.59 103.38,59.82 103.38,59.82 103.21,59.65 100.88,59.65 92.3,68.23 90.83,68.23 90.18,68.88 86.54,68.88 84.78,70.65 84.15,70.65 83.84,70.96 83.47,70.96 83.2,71.22 v1(83,71.22)
XDP_CPU_NODE1_VISA3: length 59.6
  TOP w0.102: v1(80.71,71.22) 80.34,71.6 U2.AT54 ; J3.15 115.28,72.91 112.99,70.61 112.99,69.41 112.68,69.1 112.68,67.47 113.53,66.62 v1(113.53,66.1)
  IN1 w0.114: v1(80.71,71.22) 80.71,71.4 81.28,71.97 83.55,71.97 83.62,72.04 84.17,72.04 86.73,69.48 92.33,69.48 101.28,60.53 102.86,60.53 105,62.67 109.72,62.67 109.91,62.86 109.91,63.11 109.72,63.3 105.81,63.3 105.63,63.48 105.63,63.74 105.81,63.92 111.43,63.92 112.84,65.32 112.84,65.6 113.35,66.1 v1(113.53,66.1)
XDP_CPU_NODE1_VISA4: length 55.2
  TOP w0.102: J3.17 115.27,72.41 113.54,70.68 113.54,69.91 v1(113.53,69.9) ; v1(80.73,72.69) 80.33,72.3 U2.AR54
  IN1 w0.114: v1(113.53,69.9) 113.23,70.21 112.86,70.21 112.39,69.74 112.39,68.84 112.12,68.57 111.32,68.57 111.04,68.86 111.04,69.36 110.8,69.6 110.54,69.6 110.35,69.78 110.35,70.34 110.17,70.52 109.91,70.52 109.73,70.34 109.73,69.78 109.55,69.6 109.29,69.6 109.11,69.78 109.11,70.49 108.93,70.67 108.67,70.67 108.49,70.49 108.49,69.78 108.3,69.6 108.05,69.6 107.86,69.78 107.86,70.51 107.68,70.69 107.42,70.69 107.24,70.51 107.24,69.78 107.06,69.6 104.8,69.6 103.56,68.36 102.65,68.36 102.47,68.54 102.47,68.8 102.65,68.98 102.96,68.98 103.14,69.16 103.14,69.42 102.96,69.6 102.03,69.6 101.85,69.42 101.85,68.54 101.66,68.36 101.09,68.36 100.9,68.54 100.9,68.9 100.72,69.08 100.46,69.08 100.28,68.9 100.28,68.54 100.1,68.36 99.84,68.36 99.66,68.54 99.66,68.9 99.48,69.08 99.22,69.08 99.04,68.9 99.04,68.54 98.85,68.36 98.6,68.36 98.41,68.54 98.41,68.9 98.23,69.08 97.97,69.08 97.79,68.9 97.79,68.54 97.61,68.36 97.27,68.36 93.35,72.28 91.56,72.28 91.56,72.28 90.78,72.28 89.76,73.29 86.42,73.29 85.13,74.58 83.11,74.58 81.67,73.14 81.22,73.14 80.77,72.69 v1(80.73,72.69)
XDP_CPU_NODE1_VISA5: length 59.3
  TOP w0.102: U2.AT60 83.44,71.54 83.44,70.71 v1(83.6,70.55) ; J3.27 115.59,69.91 115.36,70.14 114.61,70.14 113.17,68.7 113.17,67.51 114.27,66.41 114.27,64.44 v1(114.38,64.33)
  IN1 w0.114: v1(114.38,64.33) 114.21,64.16 114.21,63.15 111.72,60.66 111.72,60.4 111.9,60.22 112.16,60.22 114.92,62.98 115.18,62.98 115.36,62.8 115.36,62.54 114.4,61.58 114.4,61.33 114.48,61.25 114.48,61 114.29,60.81 114.04,60.81 113.96,60.89 113.71,60.89 113.52,60.7 113.52,60.45 113.6,60.37 113.6,60.12 113.41,59.93 113.16,59.93 113.08,60.01 112.83,60.01 112.46,59.64 103.81,59.64 103.41,59.23 100.7,59.23 92.31,67.63 90.81,67.63 89.92,68.52 88.87,68.52 88.73,68.66 85.48,68.66 83.6,70.54 v1(83.6,70.55)
XDP_CPU_NODE1_VISA6: length 59.4
  TOP w0.102: J3.29 115.59,69.41 115.19,69.81 114.74,69.81 113.5,68.57 113.5,67.69 114.84,66.36 v1(114.84,66.15) ; v1(82.23,71.22) 82.31,71.3 82.31,71.89 82.21,71.99 81.67,71.99 81.55,71.87 81.55,71.68 81.63,71.6 U2.AT57
  IN1 w0.114: v1(82.23,71.22) 82.65,71.64 83.52,71.64 83.71,71.82 84.06,71.82 86.74,69.14 90.59,69.14 90.95,68.77 92.35,68.77 101.05,60.07 103.04,60.07 103.97,61.01 110.05,61.01 110.23,61.19 110.23,61.45 110.05,61.63 105.62,61.63 105.44,61.81 105.44,62.07 105.62,62.25 110.36,62.25 112.83,64.72 113.84,64.72 114.84,65.72 v1(114.84,66.15)
XDP_CPU_NODE1_VISA7: length 59.2
  TOP w0.102: J3.33 115.48,68.41 115.3,68.59 114.48,68.59 v1(114.43,68.63) ; U2.AR57 81.85,72.31 81.49,72.67 v1(81.49,72.69)
  IN1 w0.114: v1(114.43,68.63) 114.47,68.59 115.55,68.59 115.6,68.54 115.6,67.91 115.7,67.81 116.26,67.81 116.41,67.96 116.41,69.64 116.16,69.89 114.41,69.89 114.2,69.67 114.2,69.45 114.03,69.29 113.32,69.29 112.81,68.78 112.81,68.43 112.48,68.11 110.97,68.11 110.8,67.94 105.38,67.94 105.2,68.12 105.2,68.38 105.38,68.56 110.29,68.56 110.47,68.74 110.47,69 110.29,69.18 105.05,69.18 104.57,68.7 104.57,68.12 104.39,67.94 97.1,67.94 93.32,71.71 90.15,71.71 89.41,72.45 87.69,72.45 87.64,72.4 86.81,72.4 86.48,72.73 86.48,72.89 85.06,74.31 83.18,74.31 81.56,72.69 v1(81.49,72.69)
XDP_CPU_NODE1_VISA8: length 58.5
  TOP w0.102: v1(83.61,73.86) 83.49,73.73 83.49,73.23 83.38,73.12 U2.AR60 ; J3.35 115.67,67.91 115.18,67.42 114.53,67.42 v1(114.04,67.91)
  IN1 w0.114: v1(114.04,67.91) 113.83,67.69 111.63,67.69 110.43,66.49 109.69,66.49 109.51,66.67 109.51,67.33 109.33,67.52 109.07,67.52 108.89,67.33 108.89,66.67 108.71,66.49 108.45,66.49 108.27,66.67 108.27,67.33 108.08,67.52 107.83,67.52 107.64,67.33 107.64,66.67 107.46,66.49 107.2,66.49 107.02,66.67 107.02,67.33 106.84,67.52 106.58,67.52 106.4,67.33 106.4,66.67 106.22,66.49 105.96,66.49 105.78,66.67 105.78,67.33 105.59,67.52 105.34,67.52 105.15,67.33 105.15,66.67 104.97,66.49 104.38,66.49 104.02,66.13 98.07,66.13 97.89,66.31 97.89,66.57 98.07,66.75 103.83,66.75 104.02,66.93 104.02,67.19 103.83,67.37 96.83,67.37 92.95,71.25 89.8,71.25 88.84,72.21 87.94,72.21 87.79,72.06 86.63,72.06 86.2,72.49 86.2,72.84 85.17,73.86 v1(83.61,73.86)
XDP_CPU_NODE1_VISA9: length 55.3
  TOP w0.102: v1(111.97,71.86) 111.97,73.9 115.1,77.03 118.85,77.03 120.48,75.41 J3.6 ; U2.AM53 80.3,73.94 v5(80.34,73.94)
  IN1 w0.114: v5(80.34,73.94) 80.48,73.94 80.74,74.2 80.74,75.12 81.45,75.83 86.35,75.83 86.88,75.3 89.33,75.3 90.08,74.54 93.54,74.54 97.21,70.87 100.44,70.87 101.31,71.74 104.85,71.74 106.84,73.73 108.04,73.73 108.85,74.54 109.24,74.54 109.42,74.72 109.42,74.9 109.61,75.08 109.86,75.08 110.05,74.9 110.05,74.72 110.23,74.54 110.51,74.54 110.82,74.85 111.08,74.85 111.26,74.67 111.26,74.41 110.7,73.85 110.7,73.59 111.97,72.32 111.97,71.87 v1(111.97,71.86)
XDP_CPU_NODE1_VISA10: length 56.3
  TOP w0.102: J3.10 121.42,74.41 121.05,74.77 119.45,74.77 v1(119,74.32) ; v5(78.81,74.64) 78.82,74.63 78.82,73.95 U2.AM52
  IN1 w0.114: v1(119,74.32) 118.46,74.32 117.82,74.96 116.27,74.96 115.26,73.96 115.26,73.69 114.74,73.16 112.82,73.16 112.1,73.88 112.1,75.52 111.65,75.97 109.09,75.97 107.69,74.57 106.49,74.57 104.5,72.58 100.84,72.58 99.99,71.73 97.63,71.73 96.06,73.3 96.06,73.3 93.94,75.42 89.92,75.42 89.48,75.86 87.22,75.86 86.76,76.32 81.33,76.32 80.71,75.71 77.52,75.71 77.25,75.44 77.25,75.01 77.51,74.75 78.7,74.75 v5(78.81,74.64)
XDP_CPU_NODE1_VISA11: length 58
  TOP w0.102: v1(120.61,74.24) 120.94,74.24 121.28,73.91 J3.12 ; U2.AR59 82.62,72.31 82.29,72.64 82.25,72.67 v1(82.25,72.69)
  IN1 w0.114: v1(120.61,74.24) 120.28,74.24 120.09,74.05 120.09,72.59 120.17,72.52 120.17,71.99 119.82,71.64 119.82,70.37 119.54,70.09 119.1,70.09 118.94,69.93 118.94,69.69 119.1,69.52 119.51,69.52 119.67,69.37 119.67,69.06 119.44,68.83 118.44,68.83 116.88,67.27 111.8,67.27 109.72,65.18 108.92,65.18 108.74,65.36 108.74,65.89 108.55,66.07 108.3,66.07 108.11,65.89 108.11,65.36 107.93,65.18 107.67,65.18 107.49,65.36 107.49,65.89 107.31,66.07 107.05,66.07 106.87,65.89 106.87,65.36 106.69,65.18 106.43,65.18 106.25,65.36 106.25,65.89 106.06,66.07 105.81,66.07 105.62,65.89 105.62,65.36 105.44,65.18 105.18,65.18 105,65.36 105,65.89 104.82,66.07 104.56,66.07 104.38,65.89 104.38,65.36 104.2,65.18 103.77,65.18 103.25,65.71 97.9,65.71 92.78,70.82 89.38,70.82 88.84,71.37 88.45,71.37 88.08,71.73 86.13,71.73 85.37,72.49 85.37,72.86 84.78,73.45 82.75,73.45 82.25,72.95 v1(82.25,72.69)
XDP_CPU_NODE1_VISA12: length 57.7
  TOP w0.102: v1(82.88,72.87) 82.23,73.51 U2.AM58 ; J3.16 120.79,72.91 v1(120.72,72.84)
  IN1 w0.114: v1(82.88,72.87) 84.36,72.87 84.54,73.04 84.88,73.04 85.12,72.8 85.12,72.02 86.38,70.75 87.84,70.75 88.2,70.4 91.02,70.4 91.02,70.4 92.61,70.4 97.72,65.29 103.07,65.29 103.6,64.76 110.44,64.76 110.98,65.3 110.98,65.85 111.98,66.85 115.24,66.85 115.5,66.6 115.5,65.72 115.61,65.61 117.09,65.61 117.28,65.79 117.28,66.05 117.09,66.23 116.38,66.23 116.2,66.41 116.2,66.67 116.38,66.85 117.28,66.85 118.39,67.96 118.39,68.18 118.61,68.41 119.75,68.41 119.93,68.59 120.4,68.59 120.56,68.74 120.56,69.34 120.24,69.66 120.24,70.38 120.54,70.68 121,70.68 121.27,70.95 121.27,71.95 121.11,72.11 121.11,72.38 121.27,72.54 121.27,73.45 121.18,73.55 121.13,73.59 120.74,73.59 120.53,73.38 120.53,73.03 v1(120.72,72.84)
XDP_CPU_NODE1_VISA13: length 55.1
  TOP w0.102: v1(119.52,72.29) 120.93,72.29 121.05,72.41 J3.18 ; v1(81.53,75.03) 81.8,74.76 81.8,73.91 U2.AM56
  IN1 w0.114: v1(81.53,75.03) 81.53,75.17 81.91,75.55 82.44,75.55 82.52,75.47 86.05,75.47 86.55,74.97 89.03,74.97 89.91,74.09 93.34,74.09 96.99,70.45 100.61,70.45 101.49,71.32 105.02,71.32 106.99,73.29 108.66,73.29 108.84,73.47 108.84,73.92 109.02,74.1 109.28,74.1 109.46,73.92 109.46,73.47 109.65,73.29 110.41,73.29 111.29,72.4 111.29,71.67 111.71,71.25 112.91,71.25 113.26,71.6 113.26,71.98 113.6,72.32 115.29,72.32 115.4,72.2 115.4,70.93 115.58,70.74 115.84,70.74 116.02,70.93 116.02,72.32 116.2,72.5 116.46,72.5 116.64,72.32 116.64,70.93 116.83,70.74 117.08,70.74 117.27,70.93 117.27,71.84 117.5,72.08 119.31,72.08 v1(119.52,72.29)
XDP_CPU_NODE1_VISA14: length 59.3
  TOP w0.102: v1(81.87,70.7) 81.47,70.31 U2.AW56 ; J3.28 v1(120.93,69.91)
  IN1 w0.114: v1(81.87,70.7) 81.87,70.7 82.76,69.8 83.47,69.8 85.09,68.19 88.07,68.19 88.58,67.68 89.28,67.68 90.26,66.7 92.04,66.7 100.44,58.3 115.51,58.3 115.82,58.62 115.82,58.88 115.2,59.5 115.2,59.76 116.27,60.82 116.53,60.82 116.71,60.64 116.71,60.38 116.08,59.76 116.08,59.5 116.26,59.32 116.52,59.32 117.7,60.5 117.7,63.68 120.18,66.15 120.18,66.87 120.5,67.19 120.76,67.19 121.03,67.46 121.03,69.81 v1(120.93,69.91)
XDP_CPU_NODE1_VISA15: length 56.1
  TOP w0.102: U2.AL53 79.95,74.29 v1(80.32,74.66) ; J3.30 121.12,69.41 121.09,69.37 120.54,69.37 120.3,69.61 120.3,70.65 118.71,72.24 118.71,72.46 v1(118.35,72.82)
  IN1 w0.114: v1(80.32,74.66) 80.52,74.86 80.52,75.21 81.36,76.05 86.53,76.05 87.01,75.57 89.4,75.57 89.98,74.99 93.76,74.99 97.46,71.29 100.26,71.29 101.14,72.16 104.68,72.16 106.67,74.15 107.86,74.15 109.21,75.5 111.02,75.5 111.68,74.84 111.68,73.69 112.63,72.74 115.7,72.74 115.88,72.92 115.88,73.77 116.06,73.95 116.32,73.95 116.32,73.95 116.5,73.76 116.5,73.07 116.68,72.89 116.94,72.89 117.12,73.07 117.12,74.3 117.3,74.48 117.56,74.48 117.74,74.3 117.74,72.81 117.9,72.65 118.19,72.65 v1(118.35,72.82)
XDP_CPU_NODE1_VISA16: length 55.7
  TOP w0.102: U2.AL52 79.19,74.31 v1(79.55,74.67) ; v1(119.15,70.9) 119.15,70.64 119.87,69.92 119.87,69.44 120.9,68.41 J3.34
  IN1 w0.114: v1(119.15,70.9) 118.66,70.41 117.88,70.41 117.56,70.09 117.56,68.77 117.38,68.59 117.12,68.59 116.94,68.77 116.94,70.09 116.72,70.31 115.16,70.31 114.98,70.5 114.98,71.49 114.75,71.71 113.97,71.71 113.08,70.83 111.54,70.83 110.83,71.54 110.83,72.27 110.23,72.87 107.3,72.87 105.33,70.9 101.66,70.9 100.79,70.03 96.81,70.03 93.24,73.61 90.29,73.61 90.15,73.74 89.69,73.74 88.84,74.59 86.32,74.59 85.77,75.14 82.85,75.14 81.75,74.04 81.02,74.04 80.51,73.53 80.11,73.53 79.55,74.09 v1(79.55,74.67)
XDP_CPU_NODE1_VISA17: length 59.3
  TOP w0.102: v1(120.32,67.83) 120.77,67.83 120.85,67.91 J3.36 ; U2.AW58 82.24,70.31 v1(82.63,70.7)
  IN1 w0.114: v1(82.63,70.7) 82.63,70.54 83.04,70.13 83.45,70.13 85.17,68.41 88.5,68.41 88.81,68.11 89.47,68.11 90.44,67.14 92.2,67.14 100.59,58.75 104.32,58.75 104.5,58.93 104.5,59.03 104.68,59.21 104.94,59.21 105.12,59.03 105.12,58.93 105.3,58.75 105.56,58.75 105.74,58.93 105.74,59.03 105.93,59.21 106.18,59.21 106.37,59.03 106.37,58.93 106.55,58.75 106.81,58.75 106.99,58.93 106.99,59.03 107.17,59.21 107.43,59.21 107.61,59.03 107.61,58.93 107.79,58.75 108.05,58.75 108.23,58.93 108.23,59.03 108.42,59.21 108.67,59.21 108.86,59.03 108.86,58.93 109.04,58.75 109.3,58.75 109.48,58.93 109.48,59.03 109.66,59.21 109.92,59.21 110.1,59.03 110.1,58.93 110.28,58.75 112.83,58.75 115.88,61.8 115.88,64.76 116.07,64.94 116.33,64.94 116.52,64.76 116.52,62.29 116.7,62.11 116.96,62.11 117.14,62.29 117.14,64.81 118.14,65.81 118.6,65.81 118.65,65.77 118.66,65.77 118.67,65.76 119.19,65.76 119.55,66.12 119.55,67 120.32,67.77 v1(120.32,67.83)
XDP_NODE1_P60: length 3.9
  TOP w0.102: R225.1 125.57,60.24 v1(124.61,61.2) 123.91,61.91 J3.60
XDP_SOC_CPU_NODE1_TCK: length 64
  TOP w0.102: R78.1 89.91,76.19 89.04,77.05 v1(89.04,77.29) 87.7,77.29 87.36,76.96 87.13,76.96 87.08,76.91 86.18,76.91 85.77,77.31 85.52,77.31 85.42,77.42 85.14,77.42 85.07,77.34 84.69,77.34 U2.AD62 ; J3.57 v1(118.43,62.41)
  IN1 w0.114: v1(89.04,77.29) 89.32,77.29 89.85,76.77 94.67,76.77 94.77,76.67 95.96,75.48 97.25,75.48 97.61,75.85 99.91,75.85 101.49,74.26 102.76,74.26 103.73,75.23 103.73,76.98 105.18,78.43 112.34,78.43 114.08,76.7 117.32,76.7 118.18,75.83 120.48,75.83 122.3,74.02 122.3,64.37 120.83,62.9 120.59,62.9 120.56,62.86 118.89,62.86 v1(118.43,62.41)
XDP_SOC_CPU_NODE1_TDI: length 65.2
  TOP w0.102: J3.56 120.53,62.91 119.97,62.35 v1(119.97,61.27) ; R76.2 90.44,78.19 89.81,78.83 v1(89.57,78.83) 89.14,78.4 88.52,78.4 87.82,79.1 86.42,79.1 U2.AA66
  IN1 w0.114: v1(119.97,61.27) 122.65,61.27 124.81,63.43 124.81,64.27 123.56,65.53 123.56,74.54 120.13,77.96 114.72,77.96 112.99,79.69 103.79,79.69 103.2,79.1 101.23,79.1 99.52,77.39 98.25,77.39 96.61,79.02 95.06,79.02 94.74,78.7 89.69,78.7 v1(89.57,78.83)
XDP_SOC_CPU_NODE1_TDO: length 59.4
  TOP w0.102: v1(88.69,78.84) 88.15,79.38 86.05,79.38 85.88,79.2 U2.AA64 ; R228.1 125.61,62.27 v1(124.19,63.69) 123.97,63.91 J3.52
  IN1 w0.114: v1(124.19,63.69) 124.19,64.1 123.14,65.15 123.14,74.36 119.96,77.54 114.55,77.54 112.81,79.27 104.83,79.27 102.74,77.19 102.74,75.49 102.35,75.1 101.84,75.1 100.12,76.82 98.02,76.82 97.07,77.77 89.76,77.77 v1(88.69,78.84)
XDP_SOC_CPU_NODE1_TMS: length 60
  TOP w0.102: 90.06,77.28 89.62,77.73 87.07,77.73 86.86,77.93 85.9,77.93 85.81,78.02 85.26,78.02 U2.AD63 ; 90.06,77.28 90.15,77.2 91.61,77.2 R74.2 ; 90.06,77.28 v1(90.06,77.27) ; J3.58 120.97,62.41 v1(120.85,62.28)
  IN1 w0.114: v1(90.06,77.27) 90.11,77.23 96.74,77.23 97.63,76.33 100.02,76.33 101.67,74.68 102.58,74.68 103.19,75.29 103.19,77.04 105,78.86 112.64,78.86 114.37,77.12 119.79,77.12 122.72,74.19 122.72,64.15 v1(120.85,62.28)
XDP_SOC_CPU_NODE1_TRST_L: length 61.7
  TOP w0.102: v1(83.62,78.96) 83.85,79.19 U2.AA62 ; v1(120.49,63.5) 120.59,63.41 J3.54 123.57,63.41 125.68,61.3 R229.2
  IN1 w0.114: v1(83.62,78.96) 83.99,78.96 85.13,77.81 87.6,77.81 88.72,76.69 89.55,76.69 89.91,76.33 94.38,76.33 95.65,75.06 97.42,75.06 97.78,75.43 99.73,75.43 101.32,73.84 103.98,73.84 105.97,75.83 107.17,75.83 109.35,78.02 112.17,78.02 113.91,76.28 117.15,76.28 118.01,75.41 120.31,75.41 121.69,74.03 121.69,64.54 120.65,63.5 v1(120.49,63.5)
XTAL_CLK_NODE1_X1: length 5.2
  TOP w0.102: Y1.1 142.24,109.26 C12.1 142.18,110.99 R4.1 142.18,112.57 v1(142.3,112.69) 142.79,113.18 U1.2
XTAL_CLK_NODE1_X2: length 7.6
  TOP w0.102: Y1.3 141.44,108.69 v1(141.44,110.19) 141.44,110.29 141.21,110.52 C13.1 141.38,111.09 R4.2 141.38,112.48 142.39,113.48 U1.1
XTAL_CPU_NODE1_X1PAD: length 12
  TOP w0.102: Y2.2 95.72,83.44 95.12,84.04 C24.1 93.6,84.04 R64.1 92.11,84.04 v1(91.93,84.22) 91.75,84.04 90.84,84.04 89.46,82.65 88.27,82.65 88.03,82.42 85.89,82.42 U2.R65
XTAL_CPU_NODE1_X2PAD: length 12.5
  TOP w0.102: Y2.1 96.02,85.94 95.12,85.04 C25.1 94.56,84.84 R64.2 93.19,84.84 v1(92.93,85.1) 92.67,84.84 90.77,84.84 89.54,83.61 88.45,83.61 87.61,82.77 86.02,82.77 U2.N65
N20512383: length 3.6
  TOP w0.102: J1.13 101.04,14.42 v1(100.8,14.66) R194.2
N20512395: length 4.4
  TOP w0.102: R193.2 v1(113.07,15.59) 113.07,14.93 113.04,14.9 J1.1
N20822523: length 9.4
  TOP w0.102: U14.E4 v1(83.37,141.26)
  BOTTOM w0.102: v1(83.37,141.26) 83.68,141.57 83.77,141.66 83.77,144.13 84.05,144.41 85.04,144.41 86.94,146.31 v2(86.94,146.98) R293.1
N21116716: length 14.4
  TOP w0.102: R653.2 145.3,62.18 146.26,63.14 146.26,65.9 145.97,66.19 U31.3 141.98,66.19 140.71,64.92 v1(140.09,64.92) U31.7
N21311590: length 5.2
  TOP w0.102: U35.45 54.35,160.06 54.15,160.26 54.15,162.54 v1(53.32,163.38)
  BOTTOM w0.102: TP1.1 53.46,163.53 v1(53.32,163.38)
N21311592: length 3.3
  TOP w0.102: U35.46 53.85,161.12 v1(53.32,161.65)
  BOTTOM w0.102: TP2.1 52.72,162.25 v1(53.32,161.65)
N21357353: length 5.3
  TOP w0.102: v1(176.34,144.64) 175.5,145.48 175.5,147.76 175.3,147.96 U37.45
  BOTTOM w0.102: TP3.1 176.21,144.51 v1(176.34,144.64)
N21357373: length 4.7
  TOP w0.102: v1(176.34,146.37) 175.8,146.9 U37.46
  BOTTOM w0.102: v1(176.34,146.37) 177.49,145.21 TP4.1
N21550241:
  vias: v1(124.95,46.75)
N21581283: length 19.1
  TOP w0.102: Q17.G 32.29,61.96 R631.2 33.46,61.8 34.06,61.2 35.51,61.2 37.1,59.61 v1(37.1,59.6) ; Q18.G v1(37.8,49.37)
  IN1 w0.114: v1(37.8,49.37) 37.8,55.71 38.21,56.13 38.21,57.8 37.1,58.91 v1(37.1,59.6)
N21581564:
  vias: v1(26.76,73.06)
N21624804: length 2.6
  TOP w0.102: U51.23 v1(163.15,32.48) 162.85,32.48 162.76,32.57 R649.2
N21624806: length 2.9
  TOP w0.102: R650.2 162.38,33.59 v1(162.64,33.84) 163.34,33.13 U51.22
N21624848: length 2.9
  TOP w0.102: U51.28 v1(164.46,28.59) 165.21,27.85 C533.1
N21624850: length 6.4
  TOP w0.102: U51.24 165.38,31.83 v1(165.72,31.49) 166.01,31.21 C533.2
N21624861: length 4.3
  TOP w0.102: v1(168.99,28.97) 168.99,28.98 ; 168.99,28.98 169.24,29.23 U51.1 ; 168.99,28.98 167.91,27.91 C534.1
N21624866: length 5.6
  TOP w0.102: C534.2 v1(167.11,27.35) 167.11,28.38 168.62,29.88 U51.2
N21624890: length 2.5
  TOP w0.102: C531.2 161.96,29.88 v1(162.64,29.88) U51.27
N21624894: length 6.8
  TOP w0.102: U51.3 v1(171.76,30.53) 171.76,27.31 171.04,26.59 C532.2
N21698757: length 9.1
  BOTTOM w0.102: R743.2 154.75,169.97 155.38,170.6 U66.2 159.21,170.6 159.65,170.16 159.65,169.52 159.09,168.96 157.6,168.96 v2(157.19,168.55)
N21698906: length 4.8
  TOP w0.102: U67.3 108.45,176.82 v1(107.96,176.34) 107.71,176.08 107.39,176.08 106.88,175.57 R739.1 R754.1
N21698939: length 4.3
  TOP w0.102: R738.1 R753.1 107.15,177.35 107.9,178.1 v1(107.96,178.1) 108.01,178.05 109.81,178.05 109.85,178.09 U67.2
N21698959: length 9
  BOTTOM w0.102: R750.1 v1(164.62,171.49) 164.21,171.9 U66.21 159.56,171.9 158.91,171.25 U66.3
N21698979: length 4.5
  BOTTOM w0.102: R704.2 118.42,175.36 v2(118.3,175.48) 118.09,175.27 116.31,175.27 115.99,174.94 U65.21
N21699069: length 2.9
  TOP w0.102: U60.15 v1(133.79,171.97) 134.09,171.97 134.45,171.6 R682.2
N21699285: length 2.9
  BOTTOM w0.102: U62.1 92.97,169.82 92.88,169.91 92.36,169.91 v2(92.34,169.89) 91.91,169.46 R685.2
N21699372: length 5.3
  BOTTOM w0.102: U64.21 133.56,175.58 134.26,174.88 v1(134.26,174.08) 134.95,173.39 R706.2
N21699571: length 4
  BOTTOM w0.102: R702.2 123.76,172.51 124.03,172.24 v2(124.53,172.24) 125.23,172.24 125.56,172.56 U64.1
N21699606: length 2.9
  BOTTOM w0.102: R719.1 107.89,173.14 v2(107.96,173.06) 108.54,173.64 U65.2
N21699710: length 10.1
  BOTTOM w0.102: R688.1 61.75,178.29 v2(62.06,177.98) 62.1,177.94 U63.21 66.98,177.94 68.28,179.24 U63.2
N21699716: length 6.1
  BOTTOM w0.102: R718.1 123.64,173.52 v1(123.97,173.85) 124.49,173.85 124.92,174.28 U64.2 126.72,174.28 126.84,174.4 126.84,174.82 126.73,174.93 U64.3
N21700156: length 3.2
  BOTTOM w0.102: U66.1 156.72,169.95 v1(155.59,168.81) 155.45,168.95 R734.2
N21700864: length 3.7
  BOTTOM w0.102: U63.3 71.53,178.59 v2(72.15,177.97) 72.78,178.6 R686.2
N21700927: length 12.3
  BOTTOM w0.102: U62.3 94.98,171.12 95.16,170.94 v1(95.16,170.79) ; R687.1 102.45,170.14 101.79,170.79 101.79,171.05 v2(101.37,171.46) 101.07,171.77 U62.21 99.04,171.77 98.64,172.17 98.4,172.17 97.95,172.62 96.98,172.62 v1(95.16,170.79) ; U62.2 95.03,170.47 95.16,170.59 v1(95.16,170.79)
N21700941: length 4
  TOP w0.102: R752.1 R737.1 106.89,179.38 v1(107.96,179.38) 108.01,179.33 109.82,179.33 109.85,179.36 U67.1
N21700943: length 4
  TOP w0.102: U67.7 117.22,178.09 v1(117.27,178.05) 117.35,177.97 R751.1 R735.1
N21701261: length 2.8
  BOTTOM w0.102: U65.3 108.69,174.29 108.65,174.33 v2(107.96,174.33) 107.39,174.33 107.21,174.16 R708.2
N21701263: length 4.7
  BOTTOM w0.102: U65.1 109.55,171.8 v2(109.79,171.56) 109.14,171.56 108.57,172.12 R701.2
N29180194: length 6.4
  TOP w0.203: v1(73.4,65.84) 73.43,65.84 73.78,65.49 U2.BH41
  BOTTOM w0.203: v1(73.4,65.84) 74.02,65.84 v2(74.14,65.71) 74.15,65.7 74.15,64.7 74.49,64.36 75.13,64.36 75.57,64.8 C14.1 R31.1 75.75,62.73 R27.2
N31328106: length 3.4
  TOP w0.102: D15.C 134.06,177.84 v3(133.24,177.02) 132.67,176.44 R796.1
N31328107: length 2.9
  TOP w0.102: D17.C 130.76,177.24 v3(130.57,177.05) 130.38,176.86 R798.1
N31328108: length 3.2
  TOP w0.102: R797.1 131.52,176.67 v3(131.86,177.01) 132.41,177.56 D16.C
N31341801: length 3
  TOP w0.102: D22.C v3(127.33,177.15) 127.97,176.52 R1048.1
N31341803: length 2.8
  TOP w0.102: D23.C 129.11,177.09 v3(129.19,177.01) 129.24,176.96 R805.1
N31348569: length 3.3
  TOP w0.102: R1058.1 126.79,175.83 125.68,176.94 v3(125.68,177.01) D24.C
N31521709: length 3.7
  TOP w0.102: R1057.2 155.23,160.19 v1(155.68,160.64) 155.68,160.72 155.23,161.17 153.99,161.17 153.63,160.8 OSC6.1
N31521711: length 2.3
  TOP w0.102: R1055.1 v1(150.06,158.99) 150.36,158.69 OSC6.3
N32265582: length 8.5
  TOP w0.102: U2.R62 84.24,82.15 84.6,81.79 v1(84.6,81.74)
  BOTTOM w0.102: v1(84.6,81.74) 84.76,81.89 84.76,82.86 85.08,83.18 86.05,83.18 v2(86.16,83.07) 86.48,82.75 C32.1 88.7,83.44 88.7,84.57 89.07,84.93 R143.1
N34379705: length 10.1
  TOP w0.102: U32.2 174.82,103.74 174.5,104.06 174.5,104.74 173.45,105.79 169.69,105.79 R274.2 169.1,106.95 168.8,107.24 v1(168.56,107.24) 168.07,106.75 R273.2
N37284163: length 5.9
  TOP w0.102: U51.7 171.82,33.13 172.14,32.81 172.56,32.81 172.83,33.09 R656.2 172.28,33.59 172.09,33.79 v1(171.73,33.79) U51.8
N41777073: length 3.1
  TOP w0.102: 183.51,133.23 Q41.E ; 183.51,133.23 183.51,133.08 184.28,132.3 R93.2 ; 183.51,133.23 v1(183.49,133.24)
N41777080: length 2.2
  TOP w0.102: R1122.1 183.58,134.92 v1(184.03,134.47) 184.69,135.13 Q41.B
N43448372: length 2.4
  TOP w0.102: R1151.1 36.41,95.67 v1(36.4,95.67) U134.7
N45787194: length 2.2
  TOP w0.102: R1215.1 105.22,82.92 105.29,82.99 Q42.B v1(106,82.03)
N46114787:
  vias: v1(129.58,46.61)
N47241340: length 6
  TOP w0.254: R1105.2 177.86,72.31 PJ3.2 176.82,72.32 C852.1 176.82,73.71 177.13,74.02 v1(177.13,75.29) 177.38,75.55 177.38,76.08 177.1,76.36 U130.6
N49382752: length 9.7
  TOP w0.102: v1(152.33,155.96) 151.55,156.74 R1226.2 ; v1(152.33,155.96) 152.33,155.43 152.52,155.25 U13.2 155.48,155.25 155.63,155.09 155.63,154.17 155.43,153.98 U13.3 ; v1(152.33,155.96) 152.88,156.52 U13.1
N52410978: length 6.9
  TOP w0.102: C887.2 124.74,153.55 R802.1 124.6,154.97 U107.D 123.53,155.21 v1(123.06,155.68) 122.35,156.4 U108.G
N52410998: length 7
  TOP w0.102: U104.D 103.12,159.82 103.85,160.56 104.67,160.56 105.01,160.23 R800.1 105.37,161.46 C886.2 106.45,161.47 v1(106.83,161.09) U105.G
N52411040: length 3.5
  TOP w0.102: U105.D 108.86,162.25 v1(109.21,161.9) 109.28,161.83 R655.1 R1127.2
N52411069: length 2.3
  TOP w0.102: Q44.1 112.42,163.21 v1(112.21,163.42) 111.71,163.42 111.21,162.93 R1127.1
N52411102: length 3.9
  TOP w0.102: Q44.2 114.06,160.82 114.39,160.49 v1(115.18,160.49) R1129.2
N52411159: length 2.3
  TOP w0.102: R1130.2 120.72,151.97 v1(121.08,151.61) 121.59,152.11 Q45.2
N52411212: length 2.8
  TOP w0.102: R657.1 R1128.2 121.8,154.02 v1(121.64,154.19) 121.33,154.49 U108.D
N52411214: length 2
  TOP w0.102: R1128.1 v1(122.6,152.43) 122.65,152.38 Q45.1
N52998261: length 6.3
  TOP w0.102: R1059.1 129.52,155.75 v1(129.45,155.68) 128.98,155.21 U110.D ; R1059.1 130.61,155.24 131.2,154.65 U111.G ; R1059.1 130.74,155.88 C934.2
N52998325: length 2.5
  TOP w0.102: Q46.2 131.7,149.42 v1(131.09,148.82) 130.67,149.24 R1249.2
N52998343: length 3.6
  TOP w0.102: U111.D 131.05,151.2 v1(131.38,151.53) 131.52,151.67 R1039.1 R1250.2
N52998345: length 2.2
  TOP w0.102: Q46.1 133.64,149.68 134.29,150.33 v1(134.29,150.7) 134.12,150.87 R1250.1
N53103066: length 2.1
  TOP w0.102: U114.G 55.37,170.42 v1(54.66,169.71) 54.3,170.06 R1070.1
N53313175: length 1.8
  TOP w0.102: TP175.1 94.07,118.64 U115.11
N53313289: length 1.5
  TOP w0.102: U115.25 105.7,118.14 TP173.1
N53313325: length 0.9
  TOP w0.102: U115.1 95.85,124.5 TP174.1
N53313389: length 2.2
  TOP w0.102: U115.35 105.47,123.14 TP172.1
N53313464: length 3.9
  TOP w0.102: R1253.2 96.49,129.64 94.88,131.26 v1(94.88,131.67) 94.37,132.17 D32.C
N53313479: length 4
  TOP w0.102: D33.C 95.9,132.23 96.78,131.35 97.17,131.35 v1(97.34,131.19) 97.63,130.89 R1254.2
N53313501: length 3.6
  TOP w0.102: D34.C 97.42,132.09 98.78,130.74 v1(98.78,130.16) R1255.2
N53313513: length 3.5
  TOP w0.102: D35.C 98.95,132.45 v1(100.01,131.39) 99.92,131.3 R1256.2
N53313558: length 25
  TOP w0.102: v1(101.11,131.16) 100.47,131.8 D36.C ; R1258.2 108.84,118.64 v1(108.87,118.66)
  IN3 w0.114: v1(108.87,118.66) 101.6,118.66 99.21,121.06 99.21,123.8 98.1,124.91 98.1,128.35 100.17,130.42 100.36,130.42 v1(101.11,131.16)
N53313577: length 24.8
  TOP w0.102: v1(101.68,131.58) 101.99,131.89 D37.C ; R1257.2 102.4,113.37 v1(102.14,113.11)
  IN3 w0.114: v1(101.68,131.58) 101.68,131.58 101.62,131.64 100.94,131.64 100,130.7 99.98,130.7 97.7,128.42 97.7,124.63 98.77,123.56 98.77,120.57 100.98,118.36 100.98,113.79 101.66,113.11 v1(102.14,113.11)
N53313596: length 4.4
  TOP w0.102: D38.C 103.52,131.91 102.07,130.47 101.45,130.47 v1(101.16,130.18) 101.06,130.08 R1259.2
N53313646: length 4.7
  TOP w0.102: R1260.2 94.12,129.45 v1(93.33,130.23) 92.88,130.69 D31.C
N53608934: length 2.4
  TOP w0.102: D18.2 32.19,7.96 R808.1
N53608970: length 3.5
  TOP w0.102: R813.1 191.66,9.11 192.03,8.74 D19.2
N54065132: length 6.9
  TOP w0.508: v1(24.24,157.79) 24.52,158.08 25.43,158.08 26.07,158.71 C540.1 ; R1273.1 v1(25.3,156.19) ; v1(25.69,165.62) R1276.1 R1275.1 v1(25,163.56) ; R1274.1 v1(25,157.33)
N54134271: length 5.8
  TOP w0.102: C541.1 200.24,162.98 R1277.1 R1278.1 200.48,164.04 v1(201.01,164.57) 200.52,165.06 R1279.1 R1280.1
N54251449: length 5.4
  TOP w0.102: v1(24.1,27.79) 23.92,27.61 U52.8 ; v1(24.1,27.79) 23.92,27.97 R654.2 ; v1(24.1,27.79) 24.57,27.32 U52.7
N54251487: length 3.6
  TOP w0.102: U52.23 25.22,17.72 v1(25.07,17.57) 24.98,17.48 R651.2
N54251489: length 3.9
  TOP w0.102: R652.2 23.97,17.57 23.86,17.67 v1(23.86,18.77) 24.57,19.48 U52.22
N54251517: length 10.9
  TOP w0.102: C546.1 v1(26,15.09) 26.56,14.53 29.59,14.53 29.79,14.72 29.79,18.2 28.47,19.52 U52.28
N54251519: length 3.7
  TOP w0.102: U52.24 25.87,18.96 v1(25.77,18.86) 26,18.64 C546.2
N54251527: length 3.5
  TOP w0.102: U52.1 28.47,28.26 v1(28.26,28.47) 27.73,29 C547.1
N54251529: length 3.6
  TOP w0.102: U52.2 27.82,27.16 v1(27.72,27.26) 27.72,27.99 26.93,28.77 C547.2
N54251539: length 4
  TOP w0.102: U52.27 27.82,19.02 v1(28.34,18.5) 29.05,17.79 C544.2
N54251541: length 3.9
  TOP w0.102: C545.2 25.93,29.25 25.93,29.25 25.93,28.71 v1(26.06,28.58) 27.17,27.47 U52.3
N54258454: length 3.6
  TOP w0.102: U55.8 18.54,166.19 v1(18.17,166.56) 17.92,166.81 R1297.2
N54258474: length 3.8
  TOP w0.102: U55.23 v1(19.84,156.95) 19.84,155.46 20.23,155.07 R1299.2
N54258476: length 3.7
  TOP w0.102: R1298.2 19.19,154.56 v1(19.19,155.47) U55.22
N54258513: length 4.2
  TOP w0.102: U55.28 23.09,157.68 v1(24.09,156.68) 24.29,156.48 C549.1
N54258515: length 9.4
  TOP w0.102: U55.24 20.49,156.4 20.88,156.01 20.88,153.49 21.73,152.64 v1(22.03,152.64) 23.74,152.64 24.29,153.2 C549.2
N54258523: length 3.6
  TOP w0.102: C542.1 23.07,165.66 v1(23.37,165.36) 23.09,165.08 U55.1
N54258525: length 3.4
  TOP w0.102: C542.2 22.27,166.92 22.44,166.75 v1(22.44,166.72) U55.2
N54258535: length 4
  TOP w0.102: U55.27 22.44,156.96 22.94,156.46 v1(22.94,155.57) 23.28,155.24 C551.2
N54258537: length 3.6
  TOP w0.102: U55.3 21.79,165.44 v1(21.66,165.56) 21.66,166.31 21.17,166.8 C548.2
N54310531: length 2.9
  TOP w0.102: R1300.2 19.17,151.33 v1(19.17,150.3) U56.8
N54310543: length 3.6
  TOP w0.102: U56.23 v1(20.47,141.31) 20.47,140.17 20.7,139.94 R1302.2
N54310545: length 3.6
  TOP w0.102: R1301.2 19.69,139.88 v1(19.82,140.02) U56.22
N54310590: length 4
  TOP w0.102: C554.1 v1(24.77,139.85) 24.77,139.98 23.72,141.02 U56.28
N54310592: length 9.9
  TOP w0.102: U56.24 21.12,140.49 21.35,140.26 21.35,137.25 21.84,136.77 v1(22.08,136.77) 23.74,136.77 24.77,137.79 C554.2
N54310596: length 3.5
  TOP w0.102: C552.1 24.11,151.68 v1(24.11,149.6) 23.72,149.21 U56.1
N54310598: length 3.4
  TOP w0.102: C552.2 v1(23.34,150.9) 23.34,150.13 23.07,149.87 U56.2
N54310604: length 3.8
  TOP w0.102: C562.2 23.75,139.92 23.07,140.59 v1(23.07,141.21) U56.27
N54310606: length 3.4
  TOP w0.102: U56.3 v1(22.42,149.78) 22.42,150.2 22.28,150.34 C553.2
N54365542: length 8.5
  TOP w0.102: U57.8 176.17,176.15 176.08,176.06 176.08,175.59 176.18,175.5 U57.7 178.83,175.5 v1(179,175.33) ; v1(179,175.33) 179.01,175.31 179.01,174.16 179.21,173.97 R1303.2 ; v1(179,175.33) 178.52,174.85 U57.6
N54365554: length 5.5
  TOP w0.102: U57.23 169.96,174.85 169.7,174.58 167.96,174.58 v1(167.69,174.86) 167.58,174.97 166.22,174.97 166.2,174.96 R1305.2
N54365556: length 4
  TOP w0.102: R1304.2 168.87,175.68 169.42,176.23 v1(169.63,176.23) 169.82,176.23 170.55,175.5 U57.22
N54365601: length 8.6
  TOP w0.102: C912.1 166.25,172.24 166.25,171.21 168.08,169.38 v1(168.48,169.38) 170.34,169.38 171.41,170.45 U57.28
N54365603: length 5.8
  TOP w0.102: U57.24 168.41,174.2 167.94,173.73 167.94,173.37 v1(167.65,173.09) 167.62,173.05 167.37,173.05 167.34,173.07 166.28,173.07 C912.2
N54365611: length 5.3
  TOP w0.102: U57.1 177.25,170.49 178.51,169.23 v1(179.67,169.23) C563.1
N54365613: length 5.1
  TOP w0.102: C563.2 179.48,170.03 179.18,170.34 v3(179.18,170.72) 179.18,171.3 178.22,172.25 U57.2
N54365623: length 4.8
  TOP w0.102: C914.2 169.02,170.51 169.2,170.33 v1(169.55,170.33) 169.92,170.7 169.92,171.72 170.45,172.25 U57.27
N54365625: length 4.4
  TOP w0.102: U57.3 178.51,172.9 v3(179.26,172.15) 180.26,171.15 C564.2
N54365764: length 9.2
  BOTTOM w0.102: 170.33,175.16 170.33,174.98 170.45,174.85 U59.6 ; 170.33,175.16 170.33,175.38 170.45,175.5 U59.7 172.32,175.5 172.49,175.68 172.49,175.93 172.27,176.15 U59.8 ; 170.33,175.16 169.52,175.16 168.71,175.97 v2(168.37,175.97) 168.03,175.97 167.76,176.24 R1306.2
N54365772: length 15.6
  BOTTOM w0.102: R1308.2 176.89,185.17 177.38,185.67 177.38,186.18 177.28,186.28 v2(177.17,186.28) 177.11,186.28 175.93,185.1 175.93,184.61 175.09,183.78 175.09,182.49 174.78,182.18 174.78,176.37 176.3,174.85 U59.23
N54365776: length 11.1
  BOTTOM w0.102: U59.22 176.15,175.5 175.03,176.62 175.03,182.08 175.35,182.39 175.35,183.3 v2(175.6,183.55) 176.12,184.07 R1307.2
N54365821: length 5.6
  BOTTOM w0.102: C916.1 v2(178.12,169.92) 177.99,170.04 177.99,170.73 178.35,171.08 178.35,171.41 178.15,171.6 U59.28
N54365823: length 8.5
  BOTTOM w0.102: U59.24 180.36,174.2 182.16,172.4 182.16,171.1 v2(182.01,170.95) 181.78,170.72 C916.2
N54365827: length 6.5
  BOTTOM w0.102: U59.1 171.41,170.17 v2(171.12,169.89) 170.96,169.73 169.3,169.73 169.14,169.89 167.96,169.89 167.44,169.36 C915.1
N54365829: length 5.5
  BOTTOM w0.102: U59.2 170.44,172.25 169.82,171.64 168.66,171.64 v2(168.5,171.49) 168.12,171.1 168.04,171.1 167.22,170.29 167.22,170.29 167.1,170.16 C915.2
N54365835: length 4.8
  BOTTOM w0.102: U59.27 178.32,172.25 179.22,171.36 v2(179.22,170.64) 179.65,170.64 179.9,170.88 C919.2
N54365837: length 3.8
  BOTTOM w0.102: C917.2 168.81,172.5 169.01,172.29 v2(169.56,172.29) 169.56,172.29 170.17,172.9 U59.3
N3975090755: length 2.2
  TOP w0.102: v5(81.77,141.26) U14.G3
  BOTTOM w0.102: TP8.1 81.77,142.82 v5(81.77,141.26)
N3975090765: length 2.2
  TOP w0.102: U14.B5 v5(85.77,139.66)
  BOTTOM w0.102: TP5.1 87.03,139.66 v5(85.77,139.66)
N3975090766: length 2.5
  TOP w0.102: U14.A4 v1(86.97,140.86)
  BOTTOM w0.102: TP6.1 87.4,141.29 v1(86.97,140.86)
N3975090767: length 1.6
  TOP w0.102: U14.E6 v5(83.37,139.66)
  BOTTOM w0.102: TP7.1 83.74,139.66 v5(83.37,139.66)

## Copper pours and planes (outline as drawn)
AGND_HSC_NODE1 on TOP (solid shape): 45.58,187.93 45.58,186.86 45.08,186.36 45.08,183.92 44.9,183.75 44.37,183.75 44.16,183.96 44.16,184.11 44.18,184.11 44.18,184.36 44.18,185.2 44.16,185.2 44.16,185.33 44,185.49 43.21,185.49 43.13,185.56 43.13,186.48 43.17,186.57 43.26,186.6 43.9,186.6 44.36,187.07 44.36,187.76 44.55,187.95 45.57,187.95
AGND_PVCCP_NODE1 on TOP (solid shape): 118.01,142.25 118.01,140.61 117.88,140.49 117.37,140.49 117.1,140.22 117.1,139.21 116.99,139.09 115.44,139.09 115.33,139.21 115.33,139.72 115.63,140.03 115.63,141.33 115.53,141.43 115.53,142.3 115.56,142.33 117.93,142.33
AGND_PVCCP_NODE1 on TOP (solid shape): 124.74,138.26 124.74,137.71 123.81,136.78 123.59,136.78 123.44,136.64 123.33,136.64 123.24,136.68 123.21,136.77 123.21,136.93 123.22,136.93 123.22,137.35 123.21,137.35 123.21,137.39 123.1,137.5 123.1,138.27 123.12,138.29 124.72,138.29
AGND_PVCCP_NODE1 on BOTTOM (solid shape): outline of 789 points within 115.52,128.14 127.8,142.24
AGND_PVCCP_NODE1 on IN3 (solid shape): outline of 831 points within 115.29,128.14 127.8,142.59
GND on TOP (solid shape): 47.86,130.05 46.65,130.05 46.57,130.13 46.57,131.44 47.86,131.44
GND on TOP (solid shape): 28.91,131.04 28.91,129.54 28.85,129.48 27.33,129.48 27.29,129.52 27.29,131.09 28.86,131.09
GND on TOP (solid shape): 51.21,13.58 50.59,12.97 50.46,12.97 50.46,14.36 50.57,14.47 51.21,14.47
GND on TOP (solid shape): 75.26,111.97 75.26,105.32 75.19,105.25 72.39,105.25 72.21,105.43 72.21,112.14 75.09,112.14
GND on TOP (solid shape): 98.96,8.12 98.96,1.97 98.72,1.72 96.5,1.72 96.32,1.9 96.32,8.61 98.47,8.61
GND on TOP (solid shape): 152.68,160.92 152.68,160 152.5,159.82 150.82,159.82 150.82,160.98 150.86,161.02 152.58,161.02
GND on TOP (solid shape): 159.14,66.23 159.14,62.46 159.1,62.42 155.29,62.42 155.19,62.52 155.19,66.32 159.04,66.32
GND on TOP (solid shape): 24.9,125.91 24.9,121.09 24.82,121 22.95,121 22.88,121.07 22.88,125.79 23.06,125.97 24.84,125.97
GND on TOP (solid shape): 63.19,100.86 63.19,98.95 63.13,98.88 61.19,98.88 61.12,98.95 61.12,100.93 61.14,100.95 63.11,100.95
GND on TOP (solid shape): 76.62,6.33 76.62,1.97 76.2,1.55 65.39,1.55 65.15,1.79 65.15,6.18 65.55,6.58 76.36,6.58
GND on TOP (solid shape): 106.17,139 106.17,137.74 106.15,137.72 104.57,137.72 104.55,137.74 104.55,138.97 104.65,139.07 106.1,139.07
GND on TOP (solid shape): 108.75,129.78 108.75,128.42 108.58,128.26 106.61,128.26 106.3,128.57 106.3,129.69 106.49,129.88 108.64,129.88
GND on TOP (solid shape): 121.24,136.64 121.24,133.16 121.21,133.14 117.84,133.14 117.78,133.2 117.78,136.63 117.8,136.66 121.22,136.66
GND on TOP (solid shape): 131.18,123.62 131.18,120.63 131.02,120.47 126.4,120.47 126.27,120.6 126.27,123.74 126.3,123.77 131.03,123.77
GND on TOP (solid shape): 139.37,55.75 139.37,55.13 139.26,55.01 138.08,55.01 137.82,55.27 137.82,55.79 137.96,55.93 139.19,55.93
GND on TOP (solid shape): 175.76,155.76 175.76,150.48 175.66,150.39 170.47,150.39 170.38,150.47 170.38,155.76 170.44,155.81 175.7,155.81
GND on TOP (solid shape): 189.71,150.85 189.71,141.91 189.32,141.52 187.59,141.52 187.21,141.89 187.21,149.56 188.73,151.08 189.48,151.08
GND on TOP (solid shape): 200.41,29.34 200.41,26.05 199.97,25.61 196.25,25.61 195.89,25.97 195.89,29.4 196.22,29.73 200.02,29.73
GND on TOP (solid shape): 203.78,167.92 203.78,165.62 203.56,165.41 201.09,165.41 201.04,165.46 201.04,167.83 201.19,167.99 203.71,167.99
GND on TOP (solid shape): 43.32,121.5 43.32,119.77 43,119.45 41.74,119.45 41.69,119.51 41.69,121.39 42.1,121.8 43.03,121.8
GND on TOP (solid shape): 46.32,126.95 46.32,124.98 46.17,124.84 45.32,124.84 44.9,125.26 44.9,126.93 45,127.03 46.24,127.03
GND on TOP (solid shape): 88.91,149.46 88.87,149.42 85.11,149.42 84.83,149.7 84.83,151.94 85.06,152.17 88.91,152.17
GND on TOP (solid shape): 100.03,158.52 100.03,151.8 98.52,151.8 97.46,152.86 97.46,154.41 97.41,154.46 97.41,158.48 97.63,158.69 99.86,158.69
GND on TOP (solid shape): 112.43,149.49 112.39,149.45 109.06,149.45 108.74,149.77 108.74,151.92 109.02,152.21 112.43,152.21
GND on TOP (solid shape): 56.24,114.06 56.24,112.65 56.22,112.63 55.19,112.63 55.13,112.68 55.13,114.11 55.15,114.12 56.17,114.12
GND on TOP (solid shape): 63.05,114.79 63.05,112.86 62.75,112.55 59.84,112.55 59.84,115.26 59.88,115.3 62.54,115.3
GND on TOP (solid shape): 76.72,158.97 76.72,152.74 76.68,152.74 76.54,152.59 76.54,152.57 73.66,152.57 73.49,152.75 73.49,158.72 73.91,159.14 76.54,159.14
GND on TOP (solid shape): 80.47,10.53 80.47,9.11 80.45,9.09 79.43,9.09 79.37,9.15 79.37,10.57 79.39,10.59 80.41,10.59
GND on TOP (solid shape): 117.13,152.07 117.13,150.65 117.12,150.63 116.09,150.63 116.03,150.7 116.03,152.11 116.05,152.13 117.08,152.13
GND on TOP (solid shape): 126.79,18.28 126.79,18.01 126.79,18.01 126.79,17.21 126.69,17.12 125.11,17.12 124.93,17.3 124.93,18.37 125.05,18.5 126.57,18.5
GND on TOP (solid shape): 129.71,31.8 129.71,29.44 129.62,29.34 121.98,29.34 121.71,29.61 121.71,31.9 122.29,32.47 129.04,32.47
GND on TOP (solid shape): 88.25,13.45 88.25,9.5 87.77,9.02 84.08,9.02 84.08,13.84 84.25,14.01 87.69,14.01
