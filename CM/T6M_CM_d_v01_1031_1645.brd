# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C_PSU1_R_SDA: length 20.9
  TOP w0.102: R818.2 65.99,186.09 66.55,186.65 66.55,187.98 66.01,188.53 C587.1 65.99,192.39 64.41,193.97 v1(64.41,195.98) 64.41,196.43 64.05,196.79 J35.B43
I2C_PSU1_SCL: length 95.2
  TOP w0.102: U116.D 138.12,157.49 136.77,158.84 136.77,160.38 136.58,160.57 135.55,160.57 R643.1 133.7,161.24 133.11,161.83 132.67,161.83 132.49,161.65 131.04,161.65 130.78,161.91 130.78,162.27 130.8,162.28 130.8,163.4 130.42,163.78 130.42,164.94 130.12,165.24 130.12,166.62 129.64,167.1 v1(129.64,167.9) ; R820.1 67.14,184.52 68.25,183.41 v1(68.25,183.06)
  IN1 w0.114: v1(68.25,183.06) 68.25,183.04 68.94,182.34 73.66,182.34 79.07,176.92 79.82,176.92 80.08,176.67 80.08,174.99 81.5,173.56 82.24,173.56 86.47,169.33 88.47,169.33 89.39,168.42 89.39,168.26 89.65,168 89.76,167.89 91.32,167.89 92.39,166.83 93.23,166.83 94.89,165.17 95.57,165.17 95.72,165.32 97.33,165.32 97.96,165.96 98.73,165.96 100.44,167.66 100.44,168.2 101.19,168.95 103.39,168.95 103.84,168.5 104.21,168.5 104.56,168.86 107.4,168.86 108.49,169.94 112.48,169.94 112.89,170.36 120.63,170.36 120.83,170.16 124.45,170.16 124.74,170.45 125.11,170.45 126.66,168.9 128.33,168.9 128.37,168.86 129.75,168.86 129.79,168.9 130.15,168.9 130.41,168.65 130.41,168.28 130.03,167.9 v1(129.64,167.9)
I2C_PSU1_SCL_MOS: length 30.1
  TOP w0.102: v1(138.61,159.41) 138.29,159.72 U116.S 137.58,160.26 R665.2 136.6,161.24 R643.2 ; v1(125.61,171.09) 125.85,171.32 U60.3
  IN2 w0.114: v1(125.61,171.09) 125.61,169.58 126.06,169.13 126.06,165.76 124.63,164.33 124.63,163.51 125.16,162.97 129.38,162.97 129.76,163.36 130.68,163.36 131.14,162.9 131.55,162.9 132.39,162.06 132.39,161.28 133.73,159.93 138.09,159.93 v1(138.61,159.41)
I2C_PSU1_SDA: length 103.8
  TOP w0.102: U117.D 133.42,153.42 133.34,153.5 R644.1 132.65,153.46 131.74,152.55 130.68,152.55 130.27,152.97 130.27,153.73 129.75,154.24 127.92,154.24 127.66,154.5 127.66,156.14 128.15,156.63 128.15,161.87 130.11,163.83 130.11,164.82 129.81,165.12 129.81,166.42 129.21,167.03 129.21,168.08 129.59,168.47 v1(129.97,168.47) ; R818.1 65.99,184.63 66.29,184.34 66.29,183.04 66.21,182.96 v1(66.21,182.64)
  IN1 w0.114: v1(129.97,168.47) 128.98,168.47 128.55,168.03 125.57,168.03 125.3,168.31 124.74,168.31 124.04,169.01 121.98,169.01 121.47,169.52 121.11,169.52 120.79,169.2 120.08,169.2 119.3,169.99 113.08,169.99 112.3,169.2 111.75,169.2 111.03,168.49 109.94,168.49 109.92,168.51 108.24,168.51 107.55,167.82 105.82,167.82 105.68,167.95 104.35,167.95 104.23,168.07 101.36,168.07 100.93,167.65 100.93,167.63 98.89,165.59 98.18,165.59 97.46,164.88 95.93,164.88 95.85,164.8 94.73,164.8 93.07,166.46 92.23,166.46 91.71,166.99 89.65,166.99 89.38,167.26 89.38,167.72 88.89,168.2 87.92,168.2 87.37,168.75 86.52,168.75 85.71,169.56 85.35,169.56 85.3,169.52 84.52,169.52 82.85,171.19 82.93,171.19 78.92,175.2 78.92,176.56 75.05,180.42 67.41,180.42 66.46,181.37 66.46,182.4 v1(66.21,182.64)
I2C_PSU1_SDA_MOS: length 33.4
  TOP w0.102: R644.2 132.65,154.45 U117.S 134.8,156.59 135.42,156.59 135.61,156.78 135.61,158.28 135.24,158.66 135.24,159.79 134.36,160.67 133.62,160.67 v1(132.89,161.4) ; R666.2 125.75,170.59 125.83,170.67 U60.4 128.01,170.67 v1(128.57,171.23)
  IN2 w0.114: v1(132.89,161.4) 132.89,161.93 131.33,163.49 131.04,163.49 130.9,163.62 129.04,163.62 128.65,163.24 125.27,163.24 124.94,163.58 124.94,164.26 126.88,166.2 126.88,169.54 v1(128.57,171.23)
I2C_PSU2_R_SCL: length 21.6
  TOP w0.102: R824.2 96.32,186.14 96.32,188.32 96.53,188.53 C593.1 96.85,191.15 99.59,193.89 v1(99.59,199.59) 99.05,200.13 J35.B10
I2C_PSU2_R_SDA: length 21.4
  TOP w0.102: R822.2 95.19,186.12 95.19,188.32 95.4,188.53 C591.1 95.71,192.59 97.83,194.71 v1(97.83,196.77) 98.37,197.3 98.37,202.67 98.05,202.99 J35.B11
I2C_PSU2_SCL: length 62.1
  TOP w0.102: R646.1 120.02,162.63 120.02,160.58 U126.D 122.85,160.4 123.25,160.8 123.25,162.47 123.06,162.66 v1(123.06,163.52) ; R824.1 96.85,184.34 v1(97.03,184.16)
  IN1 w0.114: v1(124.47,182.75) 121.85,182.75 121.8,182.7 120.88,182.7 120.66,182.92 118.11,182.92 117.12,181.93 107.06,181.93 106.85,182.15 106.21,182.15 106.15,182.22 103.87,182.22 103.1,182.98 102.11,182.98 101.81,182.68 98.51,182.68 v1(97.03,184.16)
  IN2 w0.114: v1(123.06,163.52) 123.06,163.93 123.86,164.73 123.86,167.2 125.61,168.95 v1(125.62,168.95)
  BOTTOM w0.102: v1(124.47,182.75) 125.2,182.02 127.37,182.02 127.8,181.59 127.8,181.23 127.31,180.75 127.31,171.65 125.62,169.96 v1(125.62,168.95)
I2C_PSU2_SCL_MOS: length 16.4
  TOP w0.102: R667.2 124.74,170.01 v1(124.92,170.01) 125.29,170.01 125.93,169.37 U60.6 ; v1(122.44,163.23) U126.S 121.12,161.41 120.82,161.7 R646.2
  IN2 w0.114: v1(122.44,163.23) 122.25,163.23 121.37,164.11 121.37,164.64 122.82,166.08 122.95,166.08 123.32,166.45 123.32,168.41 v1(124.92,170.01)
I2C_PSU2_SDA: length 66
  TOP w0.102: U118.D 134.12,157.49 132.51,159.1 R645.1 131.44,159.1 129.9,160.64 v1(129.9,161) ; R822.1 95.71,184.01 v1(95.75,183.97)
  IN1 w0.114: v1(98.48,162.07) 99.16,161.39 101.09,161.39 101.31,161.61 106.18,161.61 107.3,162.73 108.8,162.73 109.14,163.07 110.86,163.07 112.04,164.25 114.39,164.25 115.29,163.35 119.07,163.35 119.3,163.12 120.48,163.12 121.11,162.49 121.18,162.42 123.85,162.42 124.13,162.7 127.17,162.7 128.86,161 v1(129.9,161)
  IN3 w0.114: v1(95.75,183.97) 96.39,183.32 96.39,180.48 95.8,179.88 95.8,172.34 97.66,170.48 97.66,167.65 97.74,167.57 97.74,166.06 99,164.8 99,162.99 98.48,162.47 v1(98.48,162.07)
I2C_PSU2_SDA_MOS: length 21.5
  TOP w0.102: U118.S 133.13,159.73 v1(133.02,159.84) 132.95,159.9 R645.2 132.18,160 R668.2 ; v1(125.13,167.85) 125.19,167.85 126.06,168.72 U60.7
  IN2 w0.114: v1(133.02,159.84) 131.66,161.2 131.66,162.27 131.4,162.52 130.92,162.52 130.36,161.96 129.38,161.96 129.17,161.75 125.24,161.75 124.25,162.74 124.25,166.72 125.13,167.6 v1(125.13,167.85)
I2C_PSU3_R_SCL: length 21.7
  BOTTOM w0.102: J18.A32 v2(166.05,199.49) 166.05,197.67 169,194.71 169,188.64 C597.1 169.48,188.16 169.57,188.16 169.92,187.81 169.92,186.17 169.37,185.62 R828.2
I2C_PSU3_R_SDA: length 21.6
  BOTTOM w0.102: J18.A33 v2(165.05,197.73) 165.05,196.95 168.23,193.77 C595.1 168.79,187.71 168.79,186.58 168.23,186.02 R826.2
I2C_PSU3_SCL: length 53.3
  TOP w0.102: U139.D 140.99,157.52 140.35,158.16 140.35,160.9 140.15,161.1 R648.1 139.89,161.24 139.74,161.39 139.74,162.58 140.37,163.21 v1(140.5,163.21)
  IN3 w0.114: v1(140.5,163.21) 140.65,163.35 141.27,163.35 141.93,164.01 144.92,164.01 145.25,163.68 151.92,163.68 153.03,164.8 156.32,164.8 157.61,166.08 158.78,166.08 160.5,167.81 160.93,167.81 161.4,168.28 161.4,169.76 162.94,171.3 162.94,177.23 163.45,177.74 163.45,179.03 162.95,179.52 162.95,180.39 163.78,181.21 164.97,181.21 166.04,182.29 v1(167.92,182.29)
  BOTTOM w0.102: R828.1 169.37,184.05 169.08,183.75 169.08,182.76 168.6,182.29 v1(167.92,182.29)
I2C_PSU3_SCL_MOS: length 15.8
  TOP w0.102: U139.S 140.95,159.93 R648.2 140.95,161.54 140.8,161.69 140.39,161.69 140.15,161.93 R669.2 140.15,162.25 140.59,162.69 140.6,162.69 140.93,163.03 140.93,163.38 140.68,163.64 139.57,163.64 v1(139.53,163.59) ; U60.10 133.41,168.72 134.4,167.73 v1(135.15,167.73)
  BOTTOM w0.102: v1(139.53,163.59) 138.67,163.59 137.47,164.8 136.9,164.8 136.05,165.65 136.05,166.83 v1(135.15,167.73)
I2C_PSU3_SDA: length 48.7
  TOP w0.102: v1(157.27,164.29) 156.57,163.59 156.57,158.61 155.68,157.71 150.81,157.71 149.97,158.55 R647.1 148.88,158.93 148.63,159.18 147.24,159.18 146.5,159.92 U127.D
  IN3 w0.114: v1(157.27,164.29) 162.04,164.29 166.76,169.01 166.76,169.33 167.36,169.93 167.36,170.96 168.12,171.72 168.12,177.53 168.83,178.24 169.15,178.24 170.09,179.18 v1(170.09,179.96)
  BOTTOM w0.102: R826.1 168.23,184.15 167.41,183.33 167.41,182.08 168.93,180.56 168.95,180.56 169.55,179.96 v1(170.09,179.96)
I2C_PSU3_SDA_MOS: length 23.5
  TOP w0.102: v1(145.71,158.4) 145.71,157.94 145.97,157.68 U127.S 146.87,157.54 R671.2 R647.2 ; U60.11 133.63,169.37 134.07,168.93 v1(137.2,168.93)
  BOTTOM w0.102: v1(145.71,158.4) 145.11,159 145.11,160.89 143.47,162.53 143.47,162.76 141.93,164.3 141.55,164.3 139.05,166.79 138.21,166.79 137.2,167.8 v1(137.2,168.93)
I2C_SCL_FANCTRL1_R: length 3.2
  TOP w0.102: U69.1 108.59,174.1 108.2,173.71 v3(108.07,173.71) 107.73,173.71 107.31,173.29 R764.1
I2C_SCL_FANCTRL2_R: length 20
  TOP w0.102: U70.1 111.25,168.34 111.62,168.7 115.68,168.7 115.98,169 117.21,169 117.49,168.72 117.49,168.71 v1(117.5,168.71)
  BOTTOM w0.102: R773.1 127.15,165.78 126.83,166.1 123.44,166.1 123.43,166.09 119.54,166.09 119.4,166.23 119.24,166.23 117.5,167.97 117.5,168.71 v1(117.5,168.71)
I2C_SDA_FANCTRL1_R: length 3
  TOP w0.102: U69.16 117.05,174.1 v1(117.23,174.28) 117.24,174.28 R765.1
I2C_SDA_FANCTRL2_R: length 12.5
  TOP w0.102: v1(116.68,167.71) 116.41,167.98 116.26,167.98 115.9,168.34 U70.16
  BOTTOM w0.102: v1(116.68,167.71) 119.03,165.36 123.99,165.36 124.5,164.85 125.68,164.85 R774.1
I2C_SDC_SCL: length 5.6
  BOTTOM w0.102: v2(104.73,162.33) 102.83,162.33 102.45,162.71 R781.1 101.4,162.85 100.54,163.7 U73.8
I2C_SDC_SDA: length 3.1
  BOTTOM w0.102: U73.7 100.49,164.35 101.22,163.62 v2(101.37,163.62) 101.62,163.87 R780.1
I2C_VIDREAR_5V_SCL: length 11.5
  TOP w0.102: D7.3 32.2,67 32.08,67 31.65,66.57 v1(31.65,66.25) 31.33,65.92 31.33,65.05 31.01,64.73 30.09,64.73 28.79,63.43 Q17.D 28.22,62.98 27.73,62.49 R635.2 R636.1
I2C_VIDREAR_5V_SDA: length 14.3
  TOP w0.102: R639.1 29.26,45.92 v1(29.27,45.91) R634.2 30.47,45.91 31,45.38 32.68,45.38 33.28,45.98 Q18.D 36.78,45.23 36.18,44.63 D8.3
IN3_85OHM: length 215.3
  TOP w0.102: v1(3.94,185.77) 3.15,186.57 J25.3 ; J25.2 2.7,186.56 v1(1.91,185.77)
  IN3 w0.102: -0.38,84.34 -0.09,84.34
  IN3 w0.114: v1(1.91,185.77) 2.79,184.89 ; 3.08,184.91 v1(3.94,185.77)
  IN3 w0.127: -0.38,84.34 -0.38,84.76 -1.3,89.96 0.52,100.3 -0.92,108.45 -1.53,111.88 -1.17,113.87 1.22,127.41 -0.89,139.37 0.69,148.41 0.18,151.27 -0.34,154.18 2.22,168.8 1.12,175.02 2.79,184.5 2.79,184.89 ; -0.09,84.34 -0.09,84.79 -1.01,89.97 0.81,100.3 -0.63,108.45 -1.23,111.88 -0.88,113.87 1.52,127.41 -0.59,139.37 0.99,148.41 -0.04,154.18 2.51,168.8 1.41,175.02 3.08,184.47 3.08,184.91
IRQ_CPU_NODE1_SERIAL: length 234.6
  TOP w0.102: R179.1 v1(104.24,3.28)
  IN1 w0.114: v1(107.69,103.64) 107.69,103.3 109.93,101.06 109.93,98.27 111.72,96.49 111.72,93.32 117.07,87.97 121.88,87.97 132.31,77.54 132.31,55.56 126.74,49.98 126.69,49.98 124.24,47.53 124.24,33.93 125.46,32.71 125.46,29.34 124.65,28.53 124.65,19.43 v1(124.4,19.18)
  IN3 w0.114: v1(132.32,45.18) 132.69,45.18 134.33,43.54 134.33,35.82 124.57,26.06 124.57,21.38 123.71,20.52 v1(123.71,17.79) ; v1(107.69,103.64) 107.45,103.64 106.39,102.59 86.78,102.59 85.69,101.49 78.2,101.49 76.58,99.87 73.62,99.87 v1(73.36,99.61)
  BOTTOM w0.102: R95.1 132.78,45.63 v1(132.32,45.18) ; v1(123.71,17.79) 123.71,17.66 122,15.95 122,11.16 113.56,2.71 104.81,2.71 v1(104.24,3.28) 113.2,3.28 121.2,11.29 121.2,15.99 v1(124.4,19.18) ; R66.1 75.24,97.14 75.24,98.75 R70.2 73.88,98.79 73.56,99.11 73.56,99.27 73.36,99.47 v1(73.36,99.61)
IRQ_CPU_NODE1_SERIAL_R: length 12.7
  TOP w0.102: v1(76.83,85.15) 76.68,85 U2.J46
  BOTTOM w0.102: v1(76.83,85.15) 77,85.15 77.24,85.39 77.24,86.68 76.97,86.95 76.42,89.09 76.42,90.51 76.42,90.51 76.42,91.05 75.99,92.54 75.99,94.75 v2(75.82,94.93) 75.2,95.54 R66.2
IRQ_CPU_NODE1_SERIAL_SIO: length 2.4
  TOP w0.102: U43.39 134.48,45.77 v1(134.71,45.99)
  BOTTOM w0.102: v1(134.71,45.99) 134.53,45.82 R95.2
IRQ_LVC3_CPU_NODE1_WAKE_L: length 356.3
  TOP w0.102: v1(164.61,104.85) 165.86,103.59 R520.1 ; R263.2 157.82,137.37 158.77,136.42 v1(160.34,136.42) 160.34,131.05 162.32,129.08 v1(164.09,129.08) ; v1(168.42,158.89) 169.09,158.89 169.3,158.68 U37.16 ; U2.T56 81.83,81.88 82.41,81.88 82.66,82.14 v1(82.66,82.76) ; U35.16 60.35,149.69 61.67,148.36 v1(62.55,148.36) ; v1(164.06,83.7) 163.88,83.89 163.88,95.67 163.13,96.42 v1(163.13,100.35) ; R255.1 81.07,119.96 81.07,119.27 82.72,117.63 87.66,117.63 88.88,118.84 v1(90.21,118.84) 89.77,118.39 89.77,109.52 90.24,109.05 91.16,109.05 91.67,109.55 v1(91.67,110.86) ; v1(180.34,127.21) 182.2,127.21 U102.K10 ; R513.2 155.22,72.71 154.85,73.08 154.23,73.08 v1(153.57,72.42)
  IN1 w0.114: v1(82.66,82.76) 82.66,82.8 83.26,83.4 83.77,83.4 84.71,84.34 85.16,84.34 86.67,85.85 88.09,85.85 90.59,88.34 90.59,90.28 92.54,92.24 94.86,92.24 95.88,93.26 95.88,104.45 93.91,106.42 93.91,107.01 91.8,109.12 91.8,110.73 v1(91.67,110.86) ; v1(90.21,118.84) 90.27,118.89 90.34,118.89 91.42,119.97 91.42,133.66 90.55,134.53 90.55,145.44 88.15,147.85 85.27,147.85 84.75,148.37 79.84,148.37 79.3,148.92 77.28,148.92 76.62,149.58 74.42,149.58 74.21,149.36 63.55,149.36 v1(62.55,148.36) ; v1(164.09,129.08) 164.61,128.56 v1(164.61,104.85) 163.88,104.12 163.88,101.1 v1(163.13,100.35) ; v1(164.06,83.7) 160.98,83.7 153.57,76.29 v1(153.57,72.42)
  IN2 w0.114: v1(82.66,82.76) 82.66,82.94 83.15,83.43 84.29,83.43 84.52,83.2 84.87,83.2 86.39,84.73 87.25,84.73 89.43,86.91 v1(89.96,86.91) 89.96,87.34 92.11,89.49 95.58,89.49 96.4,90.3 98.17,90.3 98.3,90.18 99.58,90.18 100.53,91.13 103.47,91.13 107.01,87.6 147.86,87.6 160.51,100.24 163.02,100.24 v1(163.13,100.35) ; v1(164.09,129.08) 165.33,127.84 179.71,127.84 v1(180.34,127.21)
  IN3 w0.114: v1(168.42,158.89) 162.76,158.89 160.64,156.77 160.64,149.81 162.95,147.5 162.95,139.03 v1(160.34,136.42)
  BOTTOM w0.102: v1(89.96,86.91) 89.41,87.46 R144.1
IRQ_LVC3_CPU_NODE1_WAKE_R_L: length 5.9
  TOP w0.102: U14.J22 79.77,126.15 79.34,125.72 79.34,125.18 v1(79.07,124.91) 79.34,124.63 79.34,123.84 80.36,122.82 80.36,121.47 R255.2
IRQ_LVC3_SATA_NODE1_WAKE_L: length 3.2
  TOP w0.102: R513.1 155.38,71.79 155.36,71.77 v1(155.36,70.97) 155.46,70.86 155.46,69.72 155.56,69.62 U30.52
ISENSE_PVCCP_NODE1_ISEN1N: length 47.8
  TOP w0.178: 123.5,134.19 123.39,134.3 PU8.4
  TOP w0.254: PR56.2 118.05,118.6 119.07,117.58 120.83,117.58 v1(120.93,117.68) PL8.1B ; PR59.2 127.87,130.76 128.41,131.3 128.41,132.15 PC98.2 126.96,133.6 v1(126.67,133.6) 126.54,133.73 126.54,133.95 126.2,134.29 125.55,134.29 125.11,133.85 PC101.2 124.67,133.67 124.16,134.19 123.5,134.19
  IN2 w0.254: v1(120.93,117.68) 121.42,118.17 131.76,118.17 132.55,118.96 132.55,131.49 130.73,133.3 128.53,133.3 127.83,132.6 127.39,132.6 126.67,133.32 v1(126.67,133.6)
ISENSE_PVCCP_NODE1_ISEN1P: length 34.6
  TOP w0.254: PL8.2B v1(120.93,119.07) ; v1(126.18,130.94) 125.42,130.94 PR55.2
  IN2 w0.254: v1(126.18,130.94) 126.18,131.28 127.1,132.19 128,132.19 128.7,132.89 130.56,132.89 132.14,131.32 132.14,119.13 131.59,118.58 121.42,118.58 v1(120.93,119.07)
JTAG_CPLD1_TCK: length 159.4
  TOP w0.102: v5(190.49,122.87) 190.98,123.37 U102.H3 ; v1(198.17,124.32) 198.62,123.86 R1033.2 199.19,124.44 R1287.2
  IN1 w0.114: v5(190.49,122.87) 191.93,124.32 v1(198.17,124.32)
  IN2 w0.114: J20.1 155.44,12.34 169.61,12.34 177.35,20.08 177.35,46.66 179.42,48.73 179.42,50.32 180.37,51.27 180.37,54.74 181.38,55.74 181.38,67.67 205.13,91.42 205.13,118 201.03,122.1 200.39,122.1 v1(198.17,124.32)
JTAG_CPLD1_TDI: length 162.7
  TOP w0.102: R1285.2 199.21,121.65 R1035.2 198.35,121.66 v1(196.37,123.64) 196.1,123.91 192.59,123.91 U102.H2
  IN2 w0.114: v1(196.37,123.64) 196.56,123.64 201.28,118.92 201.28,89.43 177.9,66.05 177.9,49.17 175.94,47.21 175.94,20.53 169.13,13.72 146.65,13.72 J20.9
JTAG_CPLD1_TDO: length 158.9
  TOP w0.102: R1286.2 197.03,128.03 197.03,128.02 196.44,128.02 195.68,127.26 195.68,125.6 v1(194.95,124.87) 192.55,124.87 U102.J2
  IN2 w0.114: J20.3 153.33,12.78 169.44,12.78 176.86,20.2 176.86,46.84 178.95,48.93 178.95,54.33 180.96,56.34 180.96,67.89 203.07,89.99 203.07,118.57 196.77,124.87 v1(194.95,124.87)
JTAG_CPLD1_TMS: length 158.6
  TOP w0.102: R1034.2 198.18,122.84 197.36,123.66 v1(197.36,123.66) ; v1(197.36,123.66) 196.65,124.37 U102.J1 ; v1(197.36,123.66) 197.6,123.9 197.6,125.45 197.81,125.66 R1272.2
  IN2 w0.114: v1(197.36,123.66) 202.65,118.37 202.65,90.18 180.54,68.08 180.54,56.52 178.43,54.41 178.43,49.07 176.41,47.06 176.41,20.39 169.23,13.21 151.22,13.21 J20.5
JTAG_CPLD2_TCK: length 370.6
  TOP w0.102: v1(86.53,178.69) U128.24 86.53,181.63 86.33,181.83 84.95,181.83 R1074.2
  IN1 w0.114: v1(175.9,136.07) 172.41,136.07 169.26,139.22 169.26,147.61 168.26,148.62 168.26,154.58 159.44,163.4 156.94,163.4 156.35,163.99 153.77,163.99 152.4,165.36 150.15,165.36 146.09,169.42 146.09,170.2 146.31,170.41 146.31,173.43 146.78,173.9 146.78,174.61 146.22,175.17 138.78,175.17 137.8,174.19 136.13,174.19 135.64,174.68 127.77,174.68 126.36,173.27 122.86,173.27 121.65,172.07 121.29,172.07 121.23,172.13 120.45,172.13 119.84,172.73 118.16,172.73 116.93,173.97 115.3,173.97 113.68,172.35 108.89,172.35 108.6,172.06 106.11,172.06 105.55,171.5 104.6,171.5 104.12,171.01 97.03,171.01 95.73,172.31 94.07,172.31 92.16,174.22 90.24,176.14 89.12,176.14 86.57,178.69 v1(86.53,178.69)
  IN2 w0.114: v1(175.9,136.07) 178.91,136.07 181.28,138.44 189.34,138.44 190.75,137.04 190.75,135.13 192.77,133.11 193.25,133.11 197.6,128.77 197.6,128 205.55,120.05 205.55,84.75 205.04,84.25 200.42,84.25 183.42,67.25 183.42,47.41 180.94,44.93 180.94,36.1 179.24,34.4 179.24,19.45 169.64,9.86 J26.1
  BOTTOM w0.102: R1119.2 146.79,42.92 147.27,43.39 149.78,43.39 150.3,42.87 150.86,42.87 151.55,42.18 152.1,42.18 152.55,42.64 158.15,42.64 158.6,43.09 160.27,43.09 161.07,42.29 161.07,40.31 164.37,37.01 164.37,30.22 164.97,29.61 164.97,25.55 164.02,24.6 164.02,20.19 164,20.17 164,17.4 161.16,14.55 159.25,14.55 156.99,12.29 156.99,7.44 158.64,5.79 166.64,5.79 167.63,6.78 167.63,8.64 J26.1
JTAG_CPLD2_TDI: length 398.2
  TOP w0.102: R1076.2 87.4,182.43 v1(87.44,182.39) 87.03,181.97 87.03,180.73 87.03,180.73 U128.23
  IN1 w0.114: v1(183.51,190.32) 183.99,189.84 187.88,189.84 197.25,180.47 197.25,169.54 210.91,155.88 210.91,90.35 205.62,85.05 v1(204.92,85.05)
  IN2 w0.114: v1(87.44,182.39) 90.07,185.02 97.39,185.02 97.45,184.96 100.82,184.96 102.24,183.54 103.96,183.54 104.14,183.36 106.33,183.36 106.37,183.4 108.51,183.4 109.34,182.56 112.58,182.56 113.04,182.1 114.53,182.1 115.05,182.62 115.43,182.62 116.35,183.54 116.35,183.57 117.29,184.51 123.26,184.51 124.59,183.19 124.65,183.19 124.95,182.89 135.03,182.89 135.35,183.21 139.32,183.21 139.67,182.87 142.38,182.87 143.26,183.75 143.26,183.81 145.25,185.8 145.46,185.8 145.71,186.06 145.71,186.94 146.55,187.77 173.59,187.77 173.96,188.14 175.56,188.14 176.04,187.65 183,187.65 184.05,188.71 184.05,189.78 v1(183.51,190.32) ; v1(204.92,85.05) 204.64,85.33 204.64,85.71 204.11,86.24 200.56,86.24 181.81,67.49 181.81,55.38 181.52,55.09 181.52,51.31 179.97,49.76 179.97,48.68 177.86,46.57 177.86,19.98 169.79,11.91 160.74,11.91 J26.9
  BOTTOM w0.102: R1081.2 142.53,39.48 142.53,41.22 143.15,41.83 144.19,41.83 146.74,44.38 150.16,44.38 150.52,44.75 152.3,44.75 152.59,44.45 152.59,44.09 152.95,43.73 157.72,43.73 158.07,44.08 161.16,44.08 166.35,38.89 166.35,23.09 165.1,21.83 165.1,16.89 161.54,13.34 161.54,13.34 158.68,10.48 J26.9
JTAG_CPLD2_TDO: length 397.2
  TOP w0.102: v1(86.03,181.32) U128.25
  IN1 w0.114: v1(182.85,190.29) 182.85,190.27 182.46,189.89 182.46,189.36 183.32,188.51 186.95,188.51 196.21,179.25 196.21,169.29 197.53,167.97 197.53,167.94 198.96,166.52 198.96,165.75 210.05,154.66 210.05,90.86 205.28,86.08 204.56,86.08 204.28,85.8 v1(203.93,85.8)
  IN2 w0.114: v1(203.93,85.8) 204.2,85.53 204.2,84.92 203.95,84.67 200.23,84.67 182.95,67.39 182.95,47.68 180.44,45.17 180.44,36.22 178.8,34.59 178.8,19.71 170.12,11.02 167.47,11.02 J26.3 ; v1(86.03,181.32) 86.09,181.39 86.09,184.31 87.64,185.85 97.74,185.85 97.8,185.79 102.5,185.79 103.1,185.19 104.38,185.19 104.5,185.3 107.91,185.3 109.03,184.19 112.38,184.19 113.63,182.94 114,182.94 114.26,183.2 114.26,183.47 116.45,185.66 140.07,185.66 143.08,188.67 172.26,188.67 172.41,188.82 172.41,188.82 173.68,190.09 176.47,190.09 177.77,188.8 181.37,188.8 182.85,190.27 v1(182.85,190.29)
  BOTTOM w0.102: R1080.2 148.94,41.51 148.03,40.6 145.65,40.6 145.35,40.9 145.35,41.94 147.13,43.72 149.91,43.72 150.44,43.2 152.1,43.2 152.22,43.07 158.11,43.07 158.46,43.42 160.88,43.42 164.73,39.57 164.73,30.5 165.3,29.93 165.3,25.26 164.35,24.31 164.35,17.27 161.31,14.22 159.4,14.22 157.32,12.14 157.32,9.25 158.18,8.38 164.83,8.38 J26.3
JTAG_CPLD2_TMS: length 393.4
  TOP w0.102: R1075.2 87.91,182.17 87.53,181.79 v1(87.53,181.74) U128.22
  IN1 w0.114: v1(203.76,85.1) 204.22,85.1 204.72,85.6 205.53,85.6 210.48,90.55 210.48,155.72 196.74,169.46 196.74,180.14 187.7,189.18 183.27,189.18 v1(182.9,189.54)
  IN2 w0.114: v1(87.53,181.74) 87.47,181.74 87,182.21 87,183.91 88.53,185.44 97.56,185.44 97.62,185.38 101.12,185.38 102.16,184.34 107.72,184.34 107.82,184.43 108.19,184.43 109.64,182.98 112.75,182.98 113.22,182.52 114.3,182.52 115.08,183.3 115.52,183.3 115.78,183.56 115.78,183.59 117.12,184.93 138.73,184.93 138.92,184.75 140.6,184.75 144.09,188.25 172.99,188.25 173.25,188.5 173.25,188.52 173.55,188.82 176.27,188.82 176.85,188.25 181.61,188.25 182.9,189.54 v1(182.9,189.54) ; v1(203.76,85.1) 200.03,85.1 182.5,67.57 182.5,49.6 179.97,47.06 179.97,36.43 178.28,34.74 178.28,19.79 169.97,11.48 165.39,11.48 J26.5
  BOTTOM w0.102: J26.5 162.75,8.84 158.23,8.84 157.65,9.42 157.65,11.96 159.58,13.89 161.46,13.89 164.77,17.2 164.77,22.09 166.02,23.34 166.02,29.89 165.07,30.83 165.07,39.7 161.02,43.75 158.32,43.75 157.98,43.4 152.36,43.4 152.07,43.69 150.41,43.69 150.05,44.05 146.89,44.05 144.32,41.48 143.38,41.48 142.94,41.04 R1079.2
JTAG_CPLD3_TCK: length 251.7
  TOP w0.102: J27.1 184.73,9.87 R1212.2 R1200.2 ; v1(143.55,180.65) 143.55,180.33 144.06,179.82 U129.24
  IN1 w0.114: v1(179.38,184.76) 181.15,182.99 181.15,176.02 182.29,174.88 182.29,170.97 181.93,170.61 181.93,168.91 182.36,168.48 183.23,168.48 183.59,168.12 183.61,168.12 185.09,166.64 196.29,166.64 208.76,154.17 208.76,91.69 204.95,87.88 204.18,87.88 201.92,85.62 v1(201.92,82.18)
  IN2 w0.114: J27.1 181.65,12.95 181.65,34.17 182.66,35.17 182.66,43.49 186.57,47.41 186.57,56.6 187.79,57.81 187.79,69.15 200.81,82.18 v1(201.92,82.18) ; v1(179.38,184.76) 178.84,184.76 178.69,184.61 172.31,184.61 171.21,185.7 159.73,185.7 159.38,185.34 149.28,185.34 146.59,182.65 145.55,182.65 v1(143.55,180.65)
JTAG_CPLD3_TDI: length 260.7
  TOP w0.102: v1(142.71,181.98) 143.28,182.55 143.64,182.55 144.16,182.03 144.16,180.28 144.56,179.88 U129.23 ; R1198.2 R1214.2 175.6,10.87 J27.9
  IN1 w0.114: v1(178.66,186.03) 179.32,186.03 182.21,183.14 182.21,182.6 182.75,182.07 182.75,176.3 183.37,175.68 183.37,173.44 186.05,170.76 186.05,169.18 187.75,167.48 197.31,167.48 198.54,166.25 198.54,165.58 209.62,154.5 209.62,91.16 205,86.54 204.05,86.54 203.33,85.82 203.33,84.12 203.35,84.1 v1(203.35,83.38)
  IN2 w0.114: v1(178.66,186.03) 178.66,186.18 178.28,186.56 177.25,186.56 176.91,186.22 175.43,186.22 174.5,187.15 173.93,187.15 173.73,187.35 147.43,187.35 146.2,186.12 146.2,185.78 144.53,184.11 144.53,183.81 143.02,182.3 143.02,182.29 v1(142.71,181.98) ; J27.9 174.58,11.29 179.69,16.4 179.69,34.01 181.38,35.7 181.38,44.56 184.32,47.5 184.32,50.45 183.97,50.8 183.97,67.16 200.37,83.56 203.17,83.56 v1(203.35,83.38)
JTAG_CPLD3_TDO: length 251.6
  TOP w0.102: J27.3 182.21,9.86 R1199.2 ; U129.25 143.56,179.62 143.12,180.06 143.12,180.84 143.46,181.18 v1(143.46,182.12)
  IN1 w0.114: v1(202.71,82.24) 202.71,85.8 203.93,87.02 204.82,87.02 209.19,91.39 209.19,154.33 196.46,167.06 187.58,167.06 185.63,169.01 185.63,170.59 182.82,173.4 182.82,175.01 181.58,176.25 181.58,183.18 179.23,185.53 v1(179.06,185.53)
  IN2 w0.114: v1(179.06,185.53) 174.03,185.53 173.63,185.93 172.05,185.93 171.8,186.18 159.56,186.18 159.3,185.93 157.9,185.93 157.3,186.54 156.96,186.54 156.36,185.93 147.63,185.93 144.77,183.07 144.41,183.07 v1(143.46,182.12) ; J27.3 181.2,10.86 181.2,34.3 182.24,35.35 182.24,43.84 186.15,47.76 186.15,68.13 200.64,82.61 202.33,82.61 v1(202.71,82.24)
JTAG_CPLD3_TMS: length 247.1
  TOP w0.102: U129.22 145.06,180.42 v1(144.84,180.64) ; R1213.2 R1197.2 179.66,9.86 J27.5
  IN1 w0.114: v1(179.47,183.25) 180.28,182.44 180.28,175.9 180.94,175.23 180.94,174.35 180.28,173.69 180.28,170.84 181.4,169.72 181.4,168.66 182.03,168.02 182.82,168.02 184.63,166.22 195.32,166.22 198.37,163.17 198.47,163.17 206.85,154.79 206.85,146.18 207.54,145.49 207.54,91.39 204.69,88.54 204.23,88.54 201.32,85.63 v1(201.32,83.12)
  IN2 w0.114: v1(144.84,180.64) 144.84,180.62 145.18,180.62 149.47,184.91 159.71,184.91 160.04,185.24 171.04,185.24 172.15,184.12 177.95,184.12 178.73,183.34 179.38,183.34 v1(179.47,183.25) ; J27.5 180.74,10.94 180.74,34.44 181.82,35.52 181.82,44.2 185.73,48.11 185.73,68.32 200.54,83.12 v1(201.32,83.12)
LAN1_AUX_PWR: length 8.6
  TOP w0.102: U35.39 57.35,160.86 58.97,162.48 v1(58.96,162.48) 58.97,162.49 59.53,162.49 60.23,163.19 60.23,165.8 59.99,166.04 R541.2
LAN1_CTRL_P1V9:
  vias: v1(45.25,151.29) v1(45.96,149.46) v1(47.91,149.4) v1(49,149.37) v1(49.89,149.36)
LAN1_CTRL_P1V9_R:
  vias: v1(42.59,145.42)
LAN1_DIS_REG10: length 10.7
  TOP w0.102: U35.59 50.77,153.67 v1(50.23,153.13)
  IN1 w0.114: v1(50.23,153.13) 50.23,151.31 51.18,150.35 v1(51.18,146.77)
  BOTTOM w0.102: R551.2 R552.2 51,146.58 v1(51.18,146.77)
LAN1_DISABLE_N: length 116.7
  TOP w0.102: v1(91.18,109.86) 91.18,120.07 v1(90.87,120.38) ; R596.2 64.24,157.98 63.46,157.2 v1(62.78,157.2) 62.35,157.2 61.82,156.67 U35.28 ; U2.B55 80.79,88.51 80.79,89.94 v1(80.47,90.26)
  IN1 w0.114: v1(62.78,157.2) 63.17,156.8 63.17,149.82 62.11,148.76 62.11,148.18 62.37,147.92 63.72,147.92 64.8,149 70.9,149 71.24,148.66 75.62,148.66 75.88,148.41 78.9,148.41 79.42,147.88 84.54,147.88 84.96,147.46 88.15,147.46 90.12,145.5 90.12,133.73 90.87,132.98 v1(90.87,120.38) ; v1(80.47,90.26) 83.24,90.26 83.37,90.13 89.56,90.13 92.33,92.9 94.76,92.9 95.35,93.48 95.35,103.55 93.65,105.25 93.65,106.83 91.18,109.3 v1(91.18,109.86)
LAN1_LED_ACT_N: length 5.3
  TOP w0.102: U35.30 61.83,157.67 63.36,159.2 63.36,159.45 v1(64.16,160.25) 64.39,160.01 C517.1
LAN1_LED_LINK_100_N: length 5.6
  TOP w0.102: C518.1 64.07,161.03 62.93,159.89 v1(62.93,159.79) 62.93,159.18 61.92,158.17 U35.31
LAN1_LED_LINK_1000_N: length 6.3
  TOP w0.102: C519.1 64.53,162.05 64.02,161.54 63.52,161.54 62.57,160.59 v1(60.83,160.59) 60.35,160.1 U35.33
LAN1_MDI0_DN: length 14
  TOP w0.104: U35.57 51.48,154.67 51.44,154.63 49.85,154.63 49.46,154.25 v4(45.92,154.25) 39.51,154.25 39.09,154.66 U137.2
LAN1_MDI0_DP: length 14
  TOP w0.104: U137.1 39.09,153.39 39.51,153.81 v4(41.28,153.81) 49.64,153.81 50.03,154.2 51.47,154.2 51.5,154.17 U35.58
LAN1_MDI1_DN: length 15.3
  TOP w0.104: U35.54 51.75,156.17 51.74,156.16 50.6,156.16 50.46,156.02 43.85,156.02 40.54,159.33 v4(40.1,159.33) 39.51,159.33 39.09,159.74 U137.6
LAN1_MDI1_DP: length 15.3
  TOP w0.104: U137.5 39.09,158.47 39.51,158.89 40.36,158.89 43.67,155.58 v4(48.38,155.58) 50.64,155.58 50.78,155.72 51.56,155.72 51.61,155.67 U35.55
LAN1_MDI2_DN: length 15.8
  TOP w0.104: U35.52 51.54,157.17 51.52,157.15 48.78,157.15 47.5,158.43 v4(46.89,158.43) 45.23,158.43 44.18,159.48 41.8,161.87 39.51,161.87 39.09,162.28 U137.8
LAN1_MDI2_DP: length 15.8
  TOP w0.104: U137.7 39.09,161.01 39.51,161.43 v4(40.8,161.43) 41.62,161.43 44.61,158.43 44.61,158.43 45.05,157.99 47.32,157.99 48.6,156.71 51.53,156.71 51.58,156.67 U35.53
LAN1_MDI3_DN: length 17.3
  TOP w0.104: U137.12 39.09,167.36 39.18,167.28 39.51,166.95 v4(40.26,166.95) 41.03,166.95 49.33,158.65 51.45,158.65 51.48,158.67 U35.49
LAN1_MDI3_DP: length 17.3
  TOP w0.104: U137.11 39.09,166.09 39.51,166.51 40.85,166.51 49.15,158.21 v4(50.22,158.21) 51.45,158.21 51.49,158.17 U35.50
LAN1_NC_SI_CLK_IN: length 4.9
  TOP w0.102: U35.2 53.35,149.14 52.37,148.16 v1(51.78,148.16)
  BOTTOM w0.102: R554.2 51.19,147.58 v1(51.78,148.16)
LAN1_NC_SI_CRS_DV: length 4.8
  TOP w0.102: R557.2 52.27,146.45 53,147.17 v1(53,147.72) 53,148.04 53.85,148.89 U35.3
LAN1_NC_SI_RXD0: length 4.6
  TOP w0.102: U35.6 55.35,148.22 54.43,147.3 v1(54.43,146.92) 54.36,146.85 R548.2
LAN1_NC_SI_RXD1: length 4.8
  TOP w0.102: U35.5 54.85,148.81 v1(54.34,148.3) 53.71,147.67 53.71,147.09 53.35,146.73 R550.2
LAN1_NC_SI_TDX0: length 4.4
  TOP w0.102: R544.2 57.57,147.85 v1(57.2,148.22) 56.85,148.57 U35.9
LAN1_NC_SI_TDX1: length 4.2
  TOP w0.102: U35.8 56.35,147.16 v1(56.57,146.95) 56.55,146.93 R546.2
LAN1_NC_SI_TX_EN: length 4.3
  TOP w0.102: U35.7 55.85,148.37 v1(55.83,148.34) 55.83,147.89 55.45,147.51 R556.2
LAN1_NVM_CS_N_R: length 31.9
  TOP w0.102: R543.2 v1(65.36,148.56) ; v1(69.21,151.75) 69,151.96 U36.1
  BOTTOM w0.102: v1(69.21,151.75) 69.93,152.48 69.93,156.37 69.75,156.55 69.5,156.55 69.5,156.55 69.32,156.37 69.32,152.55 69.14,152.37 68.89,152.37 68.71,152.55 68.71,154.47 68.36,154.83 67.12,154.83 66.8,154.51 66.8,149.33 66.6,149.13 66.6,149.13 66.34,149.13 66.19,149.28 66.19,153.22 66.01,153.39 65.76,153.39 65.58,153.22 65.58,149.11 65.36,148.89 v1(65.36,148.56)
LAN1_NVM_HOLD_N: length 3.6
  TOP w0.102: U36.7 70.27,159.74 v1(70.02,159.99) 69.23,160.78 R553.1
LAN1_NVM_SI_R: length 4.6
  TOP w0.102: R547.2 70.25,160.98 71.36,159.87 72.01,159.87 v1(72.17,159.7) 72.81,159.07 U36.5
LAN1_NVM_SK_R: length 30.2
  TOP w0.102: U36.6 71.54,157.39 71.17,157.02 68.22,157.02 68.04,156.84 68.04,156.59 68.22,156.41 71.36,156.41 71.54,156.23 71.54,155.98 71.36,155.8 68.22,155.8 68.04,155.62 68.04,155.37 68.22,155.19 71.36,155.19 71.36,155.19 71.54,155.01 71.54,154.53 70.88,153.87 70.88,151.02 69,149.15 67.71,149.15 67.19,148.63 67.19,146.75 65.96,145.51 v1(65.69,145.51) R545.2
LAN1_NVM_SO_R: length 35.5
  TOP w0.102: R549.2 v1(65.38,146.53) ; U36.2 v1(70.27,151.81)
  BOTTOM w0.102: v1(65.38,146.53) 65.78,146.93 65.78,147.6 69.54,151.36 69.78,151.36 69.96,151.18 69.96,150.92 66.22,147.18 66.22,146.92 66.22,146.92 66.4,146.74 66.65,146.74 69.63,149.72 72,149.72 72.41,150.14 72.41,151.36 71.96,151.81 71.67,151.81 71.49,151.99 71.49,156.58 71.31,156.76 71.06,156.76 70.88,156.58 70.88,151.99 70.7,151.81 v1(70.27,151.81)
LAN1_NVM_WP_N: length 5
  TOP w0.102: 73.71,151.74 73.97,151.48 R555.1 ; 73.71,151.74 73.13,151.16 72.01,151.16 71.54,151.64 U36.3 ; 73.71,151.74 v1(73.71,151.74)
LAN1_P1_N: length 55.7
  TOP w0.104: v1(31.18,154.66) 30.76,154.25 30.56,154.25 30.15,154.66 30.15,154.66 U137.23
  BOTTOM w0.104: J35.A73 34.05,202.94 34.33,202.66 34.33,199.65 29.73,183.4 29.73,177.65 30.35,174.41 30.79,169.73 30.86,169.04 30.89,168.73 30.72,168.52 30.74,168.21 30.95,168.04 30.98,167.73 30.81,167.52 30.84,167.21 31.04,167.04 31.07,166.73 30.9,166.53 30.93,166.21 31.14,166.04 31.17,165.73 31,165.53 31.03,165.22 31.23,165.05 31.26,164.73 31.09,164.53 31.12,164.22 31.33,164.05 32.15,155.29 31.97,154.41 31.88,154.25 31.6,154.25 v1(31.18,154.66)
LAN1_P1_P: length 55.6
  TOP w0.104: v1(31.18,153.39) 30.76,153.81 30.56,153.81 30.14,153.39 U137.24
  BOTTOM w0.104: J35.A72 35.05,202.94 34.76,202.66 34.76,199.59 30.16,183.34 30.16,177.69 30.79,174.47 32.59,155.27 32.39,154.25 32.14,153.81 31.6,153.81 v1(31.18,153.39)
LAN1_P1_R: length 2.7
  TOP w0.102: U137.22 v1(28.18,155.93) 27.93,156.19 R1273.2
LAN1_P2_N: length 50.3
  TOP w0.104: v1(27.58,159.73) 27.99,159.33 28.3,159.33 28.71,159.74 U137.19
  BOTTOM w0.104: v1(27.58,159.73) 28,159.32 28.22,159.32 28.9,160 29.1,161.06 29.07,161.66 28.92,161.8 28.91,162.11 29.05,162.26 29.03,162.57 28.88,162.71 28.87,163.02 29.01,163.18 29,163.49 28.84,163.63 28.83,163.94 28.97,164.09 28.92,165.37 28.75,165.52 28.73,165.84 28.89,166.01 28.88,166.32 28.71,166.47 28.69,166.79 28.85,166.95 28.84,167.27 28.81,167.9 28.42,177.12 28.42,177.29 28.42,183.24 30.59,192.27 30.99,194.53 31.32,197.76 31.33,199.8 31.33,202.66 31.05,202.94 J35.A76
LAN1_P2_P: length 50.3
  TOP w0.104: U137.20 28.71,158.47 28.3,158.89 28.01,158.89 v1(27.58,158.46)
  BOTTOM w0.104: J35.A75 32.05,202.94 31.76,202.66 31.76,199.8 31.75,197.74 31.42,194.47 31.02,192.18 28.85,183.19 28.85,177.29 28.85,177.13 29.53,161.08 29.53,160.98 29.3,159.78 28.4,158.88 28,158.88 v1(27.58,158.46)
LAN1_P2_R: length 2.7
  TOP w0.102: U137.21 v1(28.19,157.2) 28.06,157.33 R1274.2
LAN1_P3_N: length 49.6
  TOP w0.104: U137.17 30.14,162.28 30.56,161.87 30.91,161.87 30.97,161.96 31.51,162.75 31.75,163.71 31.64,163.89 31.71,164.19 31.89,164.3 31.97,164.61 31.86,164.79 31.93,165.09 32.12,165.2 32.18,165.47 32.18,166.01 32.01,166.18 32.01,166.5 32.18,166.67 32.18,168.27 31.79,170.73 29.95,176.16 29.93,176.3 v4(29.93,179.83) 29.93,184.72 32.52,192.27 33.11,192.56 34.05,192.24 34.31,192.37 34.54,193.03 34.41,193.3 33.48,193.62 33.19,194.21 33.43,194.91 33.43,195.03 33.7,196.34 33.6,196.5 33.66,196.8 33.82,196.9 33.88,197.21 33.78,197.36 33.85,197.67 34,197.77 34.06,198.08 33.96,198.23 34.03,198.54 34.18,198.64 34.33,199.33 34.33,199.55 34.33,202.66 34.05,202.94 J35.B73
LAN1_P3_P: length 49.6
  TOP w0.104: J35.B72 35.05,202.94 34.76,202.66 34.76,199.55 34.76,199.28 33.86,194.99 33.86,194.84 33.66,194.24 33.79,193.97 34.72,193.65 35.01,193.06 34.66,192.06 34.08,191.77 33.14,192.09 32.88,191.96 30.36,184.65 v4(30.36,176.86) 30.36,176.33 30.38,176.27 32.21,170.83 32.62,168.3 32.62,165.42 31.91,162.58 31.33,161.71 31.14,161.43 30.56,161.43 30.14,161.01 U137.18
LAN1_P3_R: length 3.7
  TOP w0.102: R1275.2 26.67,163.56 27.44,164.33 v1(28.2,164.33) 28.2,164.06 28.71,163.55 U137.16
LAN1_P4_N: length 49.8
  TOP w0.104: J35.B76 31.05,202.94 31.33,202.66 31.33,195.92 30.34,191.91 30.09,191.76 28.27,192.21 27.71,191.87 27.46,190.83 27.79,190.27 29.62,189.83 29.77,189.57 29.6,188.89 29.35,188.74 27.53,189.19 26.97,188.85 26.71,187.81 27.05,187.25 28.87,186.81 29.03,186.55 28.74,185.4 28.73,185.3 v4(28.73,182.16) 28.73,175.54 29.66,172.67 29.55,172.45 29.65,172.15 29.87,172.04 29.96,171.74 29.85,171.52 29.95,171.22 30.17,171.11 30.27,170.81 30.15,170.59 30.25,170.29 30.47,170.18 30.6,169.78 30.65,169.49 30.54,169.34 30.6,169.03 30.74,168.93 30.79,168.62 30.69,168.47 30.74,168.17 30.88,168.06 30.95,167.64 30.95,167.17 30.73,166.95 30.56,166.95 30.14,167.36 U137.13
LAN1_P4_P: length 49.9
  TOP w0.104: U137.14 30.14,166.09 30.56,166.51 30.91,166.51 31.39,166.99 31.39,167.68 31.03,169.88 29.16,175.61 v4(29.16,184.68) 29.16,185.27 29.17,185.32 29.49,186.62 29.15,187.18 27.33,187.63 27.18,187.88 27.35,188.57 27.6,188.72 29.42,188.27 29.98,188.61 30.24,189.64 29.9,190.2 28.07,190.65 27.92,190.9 28.09,191.59 28.34,191.74 30.16,191.29 30.72,191.63 31.76,195.86 31.76,202.66 32.05,202.94 J35.B75
LAN1_P4_R: length 4.1
  TOP w0.102: R1276.2 26.49,164.82 v1(27.68,166.02) 28.87,164.82 U137.15
LAN1_RST: length 2.8
  TOP w0.102: U35.48 52.54,159.47 52.16,159.85 v1(52.16,160.97) R559.2
LAN1_TEST_EN: length 4.8
  TOP w0.102: U35.29 61.71,157.17 63.04,158.5 v1(63.47,158.5) 63.97,159 R558.2
LAN1_XTAL_IN: length 7.3
  TOP w0.102: U35.43 55.35,160.48 55.19,160.63 v1(55.19,161.37) 55.19,163.46 C399.1 55.1,164.36 Y4.1
LAN1_XTAL_OUT: length 7.3
  TOP w0.102: U35.42 v1(55.85,162.5) 55.85,163.21 C400.1 56.2,164.49 Y4.2
LAN2_AUX_PWR: length 6.6
  TOP w0.102: U37.39 172.3,147.13 v1(170.75,145.58) 168.86,143.69 R571.2
LAN2_CTRL_P1V9:
  vias: v1(179.57,158.44) v1(180.58,158.75) v1(193.18,148.09) v1(193.21,147.06)
LAN2_CTRL_P1V9_R:
  vias: v1(193.07,150.65)
LAN2_DIS_REG10: length 5.7
  TOP w0.102: R582.2 180.14,156.83 180.14,156.67 179.41,155.94 v1(179.41,154.95) 178.81,154.35 U37.59
  BOTTOM w0.102: R581.2 179.56,154.8 v1(179.41,154.95)
LAN2_DISABLE_N: length 139.6
  TOP w0.102: v1(84.68,90.54) 84.65,90.5 82.66,90.5 81.7,89.54 81.7,88.91 81.96,88.65 81.96,88.19 81.64,87.88 U2.D57 ; U37.28 167.83,151.35 167.4,150.92 v1(165.78,150.92) 165.33,150.92 165.09,150.69 R597.2
  IN1 w0.114: v1(109.5,111.01) 109.5,104.32 v1(111.03,102.8)
  IN3 w0.114: v1(109.5,111.01) 111.58,111.01 111.87,110.73 130.42,110.73 133.76,114.07 133.76,115.36 135.45,117.05 135.45,118.44 135.77,118.76 135.77,127.87 140.07,132.16 140.39,132.16 140.97,132.74 157.28,132.74 164.26,139.72 164.26,149.4 v1(165.78,150.92) ; v1(111.03,102.8) 109.9,101.68 97.08,101.68 95.24,99.84 88.53,99.84 87.68,98.99 v1(86.53,98.99)
  BOTTOM w0.102: v1(86.53,98.99) 86.53,97.74 85.41,96.62 85.41,94.77 85.53,94.64 85.53,91.39 v1(84.68,90.54)
LAN2_LED_ACT_N: length 4.3
  TOP w0.102: C527.1 165.46,148.06 v1(165.78,148.37) 167.75,150.35 U37.30
LAN2_LED_LINK_100_N: length 5.6
  TOP w0.102: C528.1 166.67,147.04 v1(166.73,147.1) 166.72,147.1 166.72,148.84 167.73,149.85 U37.31
LAN2_LED_LINK_1000_N: length 5.6
  TOP w0.102: C529.1 166.7,146.03 168.11,147.43 v1(168.82,147.43) 169.3,147.92 U37.33
LAN2_MDI0_DN: length 19.2
  TOP w0.104: U138.2 184.34,158.33 183.92,157.91 183.92,157.52 184.03,157.41 185.81,157.41 186.35,156.87 186.35,155.61 185.87,155.13 183.81,155.13 183.63,154.95 183.63,153.47 183.17,153.01 182.08,153.01 181.62,153.47 181.62,154.8 181.42,155 180.78,155 180.57,154.8 180.57,153.84 180.11,153.38 v4(178.98,153.38) 178.15,153.38 178.12,153.35 U37.57
LAN2_MDI0_DP: length 19.1
  TOP w0.104: U138.1 183.07,158.33 183.49,157.91 183.49,157.34 183.85,156.98 183.98,156.98 184.11,156.85 184.42,156.85 184.55,156.98 184.86,156.98 184.99,156.85 185.3,156.85 185.43,156.98 185.63,156.98 185.91,156.69 v4(185.91,156.21) 185.91,155.79 185.69,155.56 185.29,155.56 185.17,155.67 184.86,155.67 184.75,155.56 184.44,155.56 184.33,155.67 184.02,155.67 183.91,155.56 183.63,155.56 183.2,155.13 183.2,153.65 182.99,153.44 182.26,153.44 182.05,153.65 182.05,154.15 182.17,154.27 182.17,154.58 182.05,154.71 182.05,154.98 181.6,155.44 180.6,155.44 180.14,154.98 180.14,154.02 179.93,153.81 179.75,153.81 179.59,153.97 179.28,153.97 179.12,153.81 178.12,153.81 178.08,153.85 U37.58
LAN2_MDI1_DN: length 18.4
  TOP w0.104: U37.54 178.1,151.85 178.14,151.88 181.92,151.88 182.4,151.41 184.07,151.41 184.77,152.11 184.77,153.65 185.08,153.96 187.16,153.96 187.8,154.6 v4(187.8,155.1) 187.8,155.51 187.55,155.76 187.55,156.55 187.81,156.82 188.56,156.82 189,157.27 189,157.7 189,157.91 189.42,158.33 U138.6
LAN2_MDI1_DP: length 18.4
  TOP w0.104: U37.55 178.08,152.35 178.11,152.32 179,152.32 179.16,152.47 179.47,152.47 179.62,152.32 179.93,152.32 180.08,152.47 180.39,152.47 180.55,152.32 v4(181.69,152.32) 182.1,152.32 182.58,151.84 182.92,151.84 183.09,152.01 183.4,152.01 183.57,151.84 183.89,151.84 184.33,152.29 184.33,152.53 184.16,152.7 184.16,153.01 184.33,153.18 184.33,153.83 184.9,154.4 185.24,154.4 185.38,154.54 185.69,154.54 185.83,154.4 186.15,154.4 186.29,154.54 186.6,154.54 186.74,154.4 186.98,154.4 187.36,154.78 187.36,155.33 187.11,155.58 187.11,156.73 187.63,157.25 188.38,157.25 188.57,157.45 188.57,157.91 188.15,158.33 U138.5
LAN2_MDI2_DN: length 19.4
  TOP w0.104: U138.8 191.96,158.33 191.54,157.91 191.54,156.62 187.66,152.74 187.13,152.74 184.69,150.29 v4(183.52,150.29) 179.43,150.29 178.84,150.88 178.13,150.88 178.1,150.85 U37.52
LAN2_MDI2_DP: length 19.4
  TOP w0.104: U138.7 190.69,158.33 191.11,157.91 191.11,156.8 190.92,156.61 190.68,156.61 190.46,156.38 190.46,156.15 190.24,155.92 190,155.92 189.78,155.7 189.78,155.46 189.56,155.24 189.32,155.24 189.09,155.02 189.09,154.78 188.87,154.56 188.63,154.56 188.41,154.34 188.41,154.1 187.48,153.17 186.95,153.17 186.69,152.91 186.44,152.91 186.22,152.69 186.22,152.43 184.51,150.72 v4(181.32,150.72) 179.61,150.72 179.02,151.31 178.14,151.31 178.11,151.35 U37.53
LAN2_MDI3_DN: length 24.1
  TOP w0.104: U37.49 178.05,149.35 178.09,149.39 178.74,149.39 179.53,148.6 v4(181.79,148.6) 184.82,148.6 187.32,151.1 195.98,156.92 196.33,157.26 196.62,157.56 196.62,157.91 197.04,158.33 U138.12
LAN2_MDI3_DP: length 24.1
  TOP w0.104: U37.50 178.04,149.85 178.06,149.82 178.92,149.82 179.71,149.03 180.65,149.03 180.81,149.19 181.12,149.19 181.28,149.03 181.59,149.03 181.76,149.19 182.07,149.19 182.23,149.03 182.54,149.03 182.7,149.19 183.01,149.19 183.17,149.03 183.49,149.03 183.65,149.19 183.96,149.19 184.12,149.03 184.64,149.03 v4(186.08,150.48) 187.04,151.43 193.93,156.07 193.97,156.26 194.23,156.44 194.42,156.4 194.68,156.58 194.72,156.77 194.98,156.94 195.17,156.91 195.7,157.26 196.02,157.57 196.19,157.74 196.19,157.91 195.77,158.33 U138.11
LAN2_NC_SI_CLK_IN: length 4.5
  TOP w0.102: U37.2 176.3,158.85 176.62,159.17 176.99,159.17 v1(178.2,160.38) 178.45,160.62 R584.2
LAN2_NC_SI_CRS_DV: length 4
  TOP w0.102: U37.3 175.8,158.74 176.92,159.86 v1(176.92,159.99) 177.38,160.44 R587.2
LAN2_NC_SI_RXD0: length 3.8
  TOP w0.102: U37.6 174.3,159.76 v1(174.91,160.37) 175.29,160.75 R578.2
LAN2_NC_SI_RXD1: length 4.3
  TOP w0.102: R580.2 176.3,159.85 175.78,159.32 v1(175.77,159.32) 175.19,159.32 174.8,158.93 U37.5
LAN2_NC_SI_TDX0: length 3.7
  TOP w0.102: U37.9 172.8,158.85 v1(172,159.65) 172.09,159.74 R574.2
LAN2_NC_SI_TDX1: length 3.4
  TOP w0.102: U37.8 173.3,160.16 v1(173.1,160.36) R576.2
LAN2_NC_SI_TX_EN: length 3.5
  TOP w0.102: R586.2 174.2,160.84 173.8,160.43 173.8,159.29 v1(173.8,159.28) U37.7
LAN2_NVM_CS_N_R: length 2.8
  TOP w0.102: R573.2 167.53,167.79 v1(167.79,168.04) 168.17,167.66 U38.1
LAN2_NVM_HOLD_N: length 2.7
  TOP w0.102: R583.1 176.34,166.39 v1(176.26,166.31) 176.19,166.39 U38.7
LAN2_NVM_SI_R: length 3
  TOP w0.102: U38.5 175.94,163.85 v1(176.36,163.44) 176.77,163.85 R577.2
LAN2_NVM_SK_R: length 2.7
  TOP w0.102: U38.6 176.52,165.12 v1(176.59,165.05) 176.66,165.12 R575.2
LAN2_NVM_SO_R: length 2.7
  TOP w0.102: R579.2 167.58,166.52 v1(167.72,166.66) 167.99,166.39 U38.2
LAN2_NVM_WP_N: length 2.9
  TOP w0.102: R585.1 167.46,165.25 v1(167.94,164.77) 168.28,165.12 U38.3
LAN2_P1_N: length 48.6
  TOP w0.104: v1(196.67,197.74) 197.09,198.15 197.09,199.11 197.33,199.35 197.33,202.66 197.05,202.94 J18.B3 ; U138.23 184.34,168.71 183.92,169.12 183.92,169.36 v1(184.34,169.78)
  IN3 w0.104: v1(196.67,197.74) 197.13,198.19 197.13,198.44 197.01,198.56 196.6,198.56 196.53,198.54 196.18,198.38 196.12,198.2 195.83,198.07 195.65,198.13 195.37,198 195.3,197.82 195.02,197.69 194.84,197.75 194.71,197.69 194.64,197.65 194.25,197.25 194.25,197.08 194.03,196.86 193.86,196.86 193.66,196.66 193.61,196.52 193.68,196.38 193.57,196.09 193.43,196.02 193.33,195.73 193.4,195.59 193.29,195.29 193.15,195.23 193.09,195.05 193.09,193.84 193.2,193.73 193.2,193.42 193.09,193.3 193.09,192.99 193.2,192.88 193.2,192.56 193.09,192.45 193.09,176.3 190.56,173.77 190.08,173.31 189.78,173.16 189.26,172.9 188.99,172.76 188.93,172.58 188.65,172.44 188.47,172.5 188.19,172.36 188.13,172.17 187.85,172.03 187.67,172.09 186.97,171.74 186.57,171.74 185.97,171.52 185.9,171.39 185.61,171.28 185.47,171.35 185.17,171.24 185.11,171.1 184.81,171 184.67,171.07 184.38,170.96 183.89,170.47 183.89,170.23 v1(184.34,169.78)
LAN2_P1_P: length 48.7
  TOP w0.104: J18.B2 198.05,202.94 197.77,202.66 197.77,199.17 197.52,198.93 197.52,198.15 v1(197.94,197.74) ; v1(183.07,169.78) 183.49,169.36 183.49,169.12 183.07,168.71 U138.24
  IN3 w0.104: v1(183.07,169.78) 183.53,170.23 183.53,170.62 184.18,171.27 186.51,172.1 186.88,172.1 189.87,173.61 190.31,174.02 192.73,176.45 192.73,195.11 193.35,196.86 194.41,197.92 194.51,197.99 194.51,198 196.42,198.88 196.43,198.88 196.56,198.92 197.16,198.92 197.49,198.59 197.49,198.19 v1(197.94,197.74)
LAN2_P1_R: length 16.5
  TOP w0.102: U138.22 185.61,166.96 188.19,164.38 193.32,164.38 194.68,163.03 196.9,163.03 v1(196.9,163.02) R1277.2
LAN2_P2_N: length 44.5
  TOP w0.104: J18.B6 194.05,202.94 194.33,202.66 194.33,199.55 194.38,199.5 194.38,194.87 v1(193.96,194.46) ; v1(189.42,169.48) 189.17,169.48 189,169.31 189,169.12 189.42,168.71 U138.19
  IN3 w0.104: v1(193.96,194.46) 194.41,194.91 194.41,195.29 194.81,195.68 195.65,195.68 196.4,194.93 196.4,193.21 194.47,176.01 188.97,170.5 188.97,169.94 v1(189.42,169.48)
LAN2_P2_P: length 44.5
  TOP w0.104: J18.B5 195.05,202.94 194.77,202.66 194.77,199.73 194.81,199.68 194.81,194.87 v1(195.23,194.46) ; U138.20 188.15,168.71 188.57,169.12 188.57,169.27 188.36,169.48 v1(188.15,169.48)
  IN3 w0.104: v1(195.23,194.46) 194.77,194.91 194.77,195.14 194.95,195.32 195.5,195.32 196.04,194.78 196.04,193.23 195.99,192.84 195.8,192.69 195.76,192.37 195.92,192.18 195.88,191.87 195.69,191.71 195.65,191.4 195.81,191.2 195.77,190.89 195.58,190.73 195.54,190.42 195.7,190.22 195.67,189.91 195.47,189.75 195.43,189.44 195.59,189.24 195.56,188.93 195.36,188.78 195.32,188.46 195.48,188.27 195.45,187.96 195.25,187.8 195.21,187.49 195.37,187.29 195.34,186.98 195.14,186.82 195.1,186.51 195.26,186.31 195.23,186 195.03,185.84 194.99,185.53 195.15,185.33 195.12,185.02 195.04,184.36 194.13,176.17 188.61,170.65 188.61,169.94 v1(188.15,169.48)
LAN2_P2_R: length 14.6
  TOP w0.102: R1278.2 v1(198.27,164.04) 194.81,164.04 193.37,165.49 188.65,165.49 186.88,167.26 U138.21
LAN2_P3_N: length 43.2
  TOP w0.104: U138.17 191.96,168.71 191.54,169.12 191.54,169.7 v1(191.96,170.12)
  BOTTOM w0.104: v1(191.96,170.12) 191.54,169.7 191.54,169.49 191.72,169.32 192.35,169.32 193.07,169.61 193.14,169.79 193.43,169.91 193.61,169.83 193.9,169.95 194.91,170.96 195.47,172.65 195.37,172.85 195.47,173.14 195.66,173.24 195.76,173.54 195.76,174.17 195.55,174.38 195.55,174.7 195.76,174.91 195.76,175.22 195.55,175.44 195.55,175.75 195.76,175.97 195.76,176.28 195.55,176.5 195.55,176.81 195.76,177.03 195.76,177.34 195.55,177.55 195.55,177.87 195.76,178.08 195.76,178.39 195.55,178.61 195.55,178.92 195.76,179.14 195.76,179.45 195.55,179.67 195.55,179.98 195.76,180.2 195.76,195.15 195.61,196.69 195.61,197.81 196.33,200.42 196.33,202.66 196.05,202.94 J18.A4
LAN2_P3_P: length 43.3
  TOP w0.104: U138.18 190.69,168.71 191.11,169.12 191.11,169.7 v1(190.69,170.12)
  BOTTOM w0.104: v1(190.69,170.12) 191.11,169.7 191.11,169.31 191.54,168.88 192.43,168.88 194.14,169.58 195.29,170.72 196.2,173.47 196.2,195.18 196.04,196.71 196.04,197.75 196.77,200.36 196.77,202.66 197.05,202.94 J18.A3
LAN2_P3_R: length 8
  TOP w0.102: R1279.2 v1(197.12,165.06) 195.07,165.06 193.23,166.89 U138.16
LAN2_P4_N: length 43.2
  TOP w0.104: U138.13 197.04,168.71 196.62,169.12 196.62,169.56 194.21,171.36 194.1,171.55 194.1,171.7 v1(194.52,172.12)
  BOTTOM w0.104: J18.A7 193.05,202.94 193.33,202.66 193.33,199.43 192.93,197.31 192.85,195.38 192.9,194.83 193.6,189.7 193.6,176.45 192.12,172.61 192.17,171.49 192.71,170.95 193.66,170.95 194.09,171.37 194.09,171.69 v1(194.52,172.12)
LAN2_P4_P: length 43.1
  TOP w0.104: v1(193.25,172.12) 193.67,171.7 193.67,171.42 193.88,171.07 196.19,169.34 196.19,169.12 195.77,168.71 U138.14
  BOTTOM w0.104: J18.A6 194.05,202.94 193.77,202.66 193.77,199.39 193.67,198.87 193.76,198.74 193.7,198.43 193.57,198.34 193.51,198.03 193.6,197.89 193.54,197.58 193.41,197.49 193.36,197.26 193.33,196.41 193.44,196.28 193.43,195.97 193.3,195.86 193.28,195.39 193.33,194.88 194.03,189.73 194.03,181.3 194.21,181.13 194.21,180.82 194.03,180.64 194.03,180.33 194.21,180.15 194.21,179.84 194.03,179.66 194.03,179.35 194.21,179.18 194.21,178.86 194.03,178.69 194.03,178.38 194.21,178.2 194.21,177.89 194.03,177.71 194.03,177.4 194.21,177.23 194.21,176.91 194.03,176.74 194.03,176.37 193.93,176.1 194.01,175.9 193.9,175.61 193.71,175.52 193.59,175.23 193.68,175.03 193.57,174.74 193.37,174.65 193.26,174.36 193.35,174.16 193.24,173.87 193.04,173.78 192.56,172.53 192.59,171.67 192.89,171.38 193.48,171.38 193.65,171.55 193.65,171.72 v1(193.25,172.12)
LAN2_P4_R: length 6.3
  TOP w0.102: U138.15 194.5,166.94 195.37,166.07 v1(198.1,166.07) R1280.2
LAN2_RST: length 2.6
  TOP w0.102: R589.2 v1(177.5,147.05) 177.5,147.31 176.8,148.01 U37.48
LAN2_TEST_EN: length 4.4
  TOP w0.102: U37.29 167.84,150.85 166.99,150 v1(165.8,150) 165.8,149.53 165.34,149.07 R588.2
LAN2_XTAL_IN: length 7.3
  TOP w0.102: U37.43 174.3,147.27 174.51,147.06 v1(174.51,146.53) 174.51,144.51 C437.1 174.56,143.66 Y5.1
LAN2_XTAL_OUT: length 7.3
  TOP w0.102: U37.42 v1(173.8,145.12) 173.8,144.81 C438.1 173.45,143.53 Y5.2
LED_CPU_NODE1_CPLD: length 11.4
  TOP w0.102: D21.C 176.6,129.85 v1(178.1,128.35) 179.74,126.72 181.26,126.72 183.6,124.37 U102.J10
LED_CPU_NODE1_CPLD_D: length 2.2
  TOP w0.102: R1032.2 173.43,131.22 D21.A v1(172.6,129.85)
LED_PWR_GD: length 6.1
  TOP w0.102: D19.3 193.3,10 192.8,10.5 R817.2
LED_PWR_NODE1_L: length 163.3
  TOP w0.102: U102.H10 183.27,123.37 182.25,124.39 180.18,124.39 179.55,123.77 R1031.2 178.59,124.32 177.75,124.32 177.17,124.9 v1(177.17,125.56) ; R817.1 v1(192.8,12.96)
  IN1 w0.114: v1(199.52,127.7) 199.41,127.59 189.1,127.59 v1(187.93,128.75)
  IN2 w0.114: v1(199.52,127.7) 199.93,127.7 207.11,120.52 207.11,83.69 204.22,80.8 201.16,80.8 189.63,69.27 189.63,52.93 189.98,52.59 189.98,45.87 188.92,44.82 188.92,33.63 192.87,29.69 192.87,13.03 v1(192.8,12.96)
  IN3 w0.114: v1(177.17,125.56) 177.74,125.56 178.94,126.77 185.8,126.77 185.81,126.77 185.95,126.77 v1(187.93,128.75)
LED_SATA_NODE1_GPIO0: length 4.5
  TOP w0.102: D5.C 153.51,71.25 v1(153.56,71.2) 153.56,70.74 154.76,69.54 U30.54
LED_SATA_NODE1_R: length 1.6
  TOP w0.254: D5.A v1(150.52,70.33) 150.51,70.32 R501.1
LPC_CLK_AST: length 4.3
  TOP w0.102: U14.B20 v5(85.77,127.66)
  BOTTOM w0.102: R258.2 88.6,128.36 87.9,127.66 v5(85.77,127.66)
LPC_CPU_NODE1_CLK0_DS: length 9.3
  TOP w0.102: R170.1 91.35,82.9 v1(91.21,82.76) 91.2,82.78 90.75,82.78 89.88,81.9 87.45,81.9 87.23,82.12 86.07,82.12 85.84,81.89 85.51,81.89 85.2,82.2 U2.R63
  BOTTOM w0.102: v1(91.21,82.76) 91.35,82.9 R170.1
LPC_CPU_NODE1_CLKOUT0: length 137.6
  TOP w0.102: v1(79.2,97.74) 79.27,97.66 R73.2 ; R193.1 113.19,16.39 v1(113.97,15.61)
  IN1 w0.114: v1(109.11,98.57) 109.11,98.45 111.3,96.26 111.3,93.15 116.89,87.55 120.49,87.55 130.93,77.1 130.93,67.67 131.18,67.43 131.18,56.1 127.37,52.29 127.37,52.01 126.33,50.97 126.28,50.97 123.24,47.94 123.24,22.01 116.84,15.61 v1(113.97,15.61)
  IN3 w0.114: v1(79.2,97.74) 79.21,97.74 80.03,96.92 97.09,96.92 99.67,99.51 104.04,99.51 104.35,99.82 105.39,99.82 105.71,99.51 108.18,99.51 v1(109.11,98.57)
LPC_CPU_NODE1_CLKOUT1: length 106.8
  TOP w0.102: R625.1 130.76,48.56 130.17,49.14 129.12,49.14 v1(126.5,51.76) ; v1(79.82,98.59) 79.82,98.09 80.29,97.62 R72.2
  IN1 w0.114: v1(126.5,51.76) 126.5,52.01 130.76,56.28 130.76,67.25 130.52,67.5 130.52,76.93 120.31,87.13 116.72,87.13 110.88,92.97 110.88,96.08 108.67,98.29 108.67,98.99 v1(109.22,99.54)
  IN3 w0.114: v1(79.82,98.59) 79.9,98.68 84.72,98.68 84.87,98.53 87.84,98.53 88.35,99.04 94.29,99.04 95.38,97.95 97.52,97.95 99.5,99.92 103.86,99.92 104.27,100.34 105.47,100.34 105.89,99.92 108.83,99.92 v1(109.22,99.54)
