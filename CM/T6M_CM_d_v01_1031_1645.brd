# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Nets (continued)
PCIE_SW_P0_CTCDIS: R277.2 U125.18(P0_CTCDIS)
PCIE_SW_P0_ERR: R234.2 R299.2 U2.E55(GPIOCORE6)
PCIE_SW_P0_ERR_R: R234.1 U125.45(PORTERR0)
PCIE_SW_P1_CTCDIS: R278.2 U125.32(P1_CTCDIS)
PCIE_SW_P2_CTCDIS: R279.2 U125.33(P2_CTCDIS)
PCIE_SW_PRSNT1: R1228.1 U125.128(PRSNT1)
PCIE_SW_PRSNT2: R1229.1 U125.7(PRSNT2)
PCIE_SW_PWR_SAV: R275.2 R276.2 U125.17(PWR_SAV)
PCIE_SW_RST_N: R231.2 U125.43(PERST_L)
PCIE_SW_SCAN_EN: R297.2 U125.56(SCAN_EN)
PCIE_SW_SLOTCLK: R305.1 U125.127(SLOTCLK)
PCIE_SW_TEST1: R285.2 U125.31(TEST1)
PCIE_SW_TEST2: R283.2 U125.66(TEST2)
PCIE_SW_TEST3: R286.2 U125.12(TEST3)
PCIE_SW_TEST4: R284.2 U125.11(TEST4)
PCIE_SW_TEST5: R288.2 U125.10(TEST5)
PCIE_SW_TEST6: R289.2 U125.126(TEST6)
PCIE_SW_TEST7: R287.2 U125.38(TEST7)
PCIE_SW_TMS: R296.2 U125.63(JTG_TMS)
PCIE_SW_TRST: R295.2 U125.65(JTG_TRST_L)
PCIE_SW_WAKE_N: R263.1 U125.6(WAKE_L)
PCIE_SW_WP_N: R1227.1 U13.7(WP)
PD_BMC_LPC: R1230.2 U14.A21(LFRAME#) U14.A22(LAD1) U14.B21(LAD0) U14.C19(LAD3) U14.E17(LSIRQ#) U14.F19(LAD2)
PD_BMC_NODE1_PEREXT: R256.1 U14.D20(PEREXT)
PD_CPU_NODE1_AJ23: R42.1 U2.AJ23(TESTLO_11)
PD_CPU_NODE1_AL5: R38.1 U2.AL5(TESTLO_05)
PD_CPU_NODE1_AM23: R39.1 U2.AM23(TESTLO_07)
PD_CPU_NODE1_AN5: R37.1 U2.AN5(TESTLO_06)
PD_CPU_NODE1_BOOTDEVSEL: R151.1 R154.1 U2.E52(BOOTDEVSEL)
PD_CPU_NODE1_BRD_ID1: R152.1 R155.2 U2.M46(GPIOCORE9)
PD_CPU_NODE1_DFX_GPIO_GRP0_0: R497.2 U2.D30(DFX_GPIO_GRP0_0)
PD_CPU_NODE1_DFX_GPIO_GRP0_1: R84.2 U2.D28(DFX_GPIO_GRP0_1)
PD_CPU_NODE1_DFX_GPIO_GRP0_2: R83.2 U2.B28(DFX_GPIO_GRP0_2)
PD_CPU_NODE1_DFX_GPIO_GRP0_3: R82.2 U2.B30(DFX_GPIO_GRP0_3)
PD_CPU_NODE1_DFX_GPIO_GRP0_4: R81.2 U2.H32(DFX_GPIO_GRP0_4)
PD_CPU_NODE1_DFX_GPIO_GRP0_6: R80.2 U2.E28(DFX_GPIO_GRP0_6)
PD_CPU_NODE1_DFX_GPIO_GRP0_7: R79.2 U2.J30(DFX_GPIO_GRP0_7)
PD_CPU_NODE1_DFX_GPIO_GRP1_0: R56.1 U2.C33(DFX_GPIO_GRP1_0)
PD_CPU_NODE1_DFX_GPIO_GRP1_1: R55.1 U2.D33(DFX_GPIO_GRP1_1)
PD_CPU_NODE1_DFX_GPIO_GRP1_2: R54.1 U2.G34(DFX_GPIO_GRP1_2)
PD_CPU_NODE1_DFX_GPIO_GRP1_4: R52.1 U2.B35(DFX_GPIO_GRP1_4)
PD_CPU_NODE1_DFX_GPIO_GRP1_7: R50.1 U2.G32(DFX_GPIO_GRP1_7)
PD_CPU_NODE1_HVMGEAR_SEL: R159.1 R162.2 U2.AD52(HVMGEAR_SEL)
PD_CPU_NODE1_MEM_SPEED1: R164.1 R167.2 U2.AD53(MEM_SPEED1)
PD_CPU_NODE1_NODE_ID: R157.1 R160.1 U2.D55(GPIOCORE7)
PD_CPU_NODE1_PUNIT_ST_ADDR0: R165.1 R168.2 U2.AG48(PUNIT_ST_ADDR0)
PD_CPU_NODE1_PUNIT_ST_ADDR1: R172.1 R174.2 U2.AH48(PUNIT_ST_ADDR1)
PD_CPU_NODE1_RP1_PERN: R46.1 U2.AF2(TESTLO_08_1) U2.AH1(TESTLO_08_2) U2.AH4(TESTLO_08_3) U2.AL4(TESTLO_08_4) U2.AN2(TESTLO_08_5) U2.AR2(TESTLO_08_6) U2.AT5(TESTLO_08_7) U2.AU1(TESTLO_08_8)
PD_CPU_NODE1_RP1_PERP: R45.1 U2.AF4(TESTLO_16_1) U2.AG5(TESTLO_16_2) U2.AH3(TESTLO_16_3) U2.AL2(TESTLO_16_4) U2.AN4(TESTLO_16_5) U2.AR4(TESTLO_16_6) U2.AU3(TESTLO_16_7) U2.AV2(TESTLO_16_8)
PD_CPU_NODE1_RP2_PERN: R44.1 U2.AB4(TESTLO_12_6) U2.AD4(TESTLO_12_7) U2.AD5(TESTLO_12_8) U2.N2(TESTLO_12_1) U2.R2(TESTLO_12_2) U2.R5(TESTLO_12_3) U2.U2(TESTLO_12_4) U2.W4(TESTLO_12_5)
PD_CPU_NODE1_RP2_PERP: R43.1 U2.AB2(TESTLO_17_6) U2.AB5(TESTLO_17_7) U2.AD2(TESTLO_17_8) U2.N4(TESTLO_17_1) U2.N5(TESTLO_17_2) U2.R4(TESTLO_17_3) U2.U4(TESTLO_17_4) U2.V5(TESTLO_17_5)
PD_CPU_NODE1_SPD_EN_L: R158.1 R161.2 U2.AD49(SPD_EN#)
PD_CPU_NODE1_W1: R41.1 U2.W1(TESTLO_09)
PD_CPU_NODE1_Y2: R40.1 U2.Y2(TESTLO_10)
PD_NODE1_DM0: J2.11(DM0) R212.2
PD_NODE1_DM1: J2.28(DM1) R211.2
PD_NODE1_DM2: J2.44(DM2) R210.2
PD_NODE1_DM3: J2.59(DM3) R209.2
PD_NODE1_DM4: J2.140(DM4) R208.2
PD_NODE1_DM5: J2.157(DM5) R207.2
PD_NODE1_DM6: J2.172(DM6) R206.2
PD_NODE1_DM7: J2.189(DM7) R205.2
PD_NODE1_DM8: J2.76(DM8) R204.2
PD_NODE1_NTB_CLKINN: R99.1 U2.H14(TESTLO_01)
PD_NODE1_NTB_CLKINP: R97.1 U2.J14(TESTLO_02)
PD_NODE1_NTB_PERN: R108.1 U2.B12(TESTLO_04_1) U2.B19(TESTLO_04_2) U2.B21(TESTLO_04_3) U2.B26(TESTLO_04_4) U2.D10(TESTLO_04_5) U2.D12(TESTLO_04_6) U2.D15(TESTLO_04_7) U2.D17(TESTLO_04_8) U2.D26(TESTLO_04_9) U2.E21(TESTLO_04_10) U2.E23(TESTLO_04_11) U2.F5(TESTLO_04_12) U2.G9(TESTLO_04_13) U2.H10(TESTLO_04_14) U2.K3(TESTLO_04_15) U2.L2(TESTLO_04_16)
PD_NODE1_NTB_PERP: R107.1 U2.B10(TESTLO_15_1) U2.B17(TESTLO_15_2) U2.C15(TESTLO_15_3) U2.C24(TESTLO_15_4) U2.D19(TESTLO_15_5) U2.D21(TESTLO_15_6) U2.D23(TESTLO_15_7) U2.D24(TESTLO_15_8) U2.E10(TESTLO_15_9) U2.E12(TESTLO_15_10) U2.E19(TESTLO_15_11) U2.G5(TESTLO_15_12) U2.H9(TESTLO_15_13) U2.K4(TESTLO_15_14) U2.K10(TESTLO_15_15) U2.L4(TESTLO_15_16)
PD_NODE1_NTB_RCOMP: R102.1 U2.AA23(TESTLO_03)
PE_SW_BMC_PERST_L: R272.1 R281.2 U125.96(DWNRST1_L)
PE_SW_USB_PERST_L: R273.1 R280.2 U125.97(DWNRST2_L)
PECIVDD: U14.V19(PECIVDD)
PLT_RST_LAN1_N: R560.2 U35.17(P\E\_\R\S\T\)
PLT_RST_LAN2_N: R590.2 U37.17(P\E\_\R\S\T\)
PMBUS1_EN: R1282.2 U116.G(GATE) U117.G(GATE)
PMBUS2_EN: R1283.2 U118.G(GATE) U126.G(GATE)
PMBUS3_EN: R1284.2 U127.G(GATE) U139.G(GATE)
PORT80_LOUT0: R1260.1 U115.2(A5)
PORT80_LOUT1: R1253.1 U115.48(A4)
PORT80_LOUT2: R1254.1 U115.47(A3)
PORT80_LOUT3: R1255.1 U115.46(A2)
PORT80_LOUT4: R1256.1 U115.45(A1)
PORT80_LOUT5: R1258.1 U115.26(B5)
PORT80_LOUT6: R1257.1 U115.22(B2)
PORT80_LOUT7: R1259.1 U115.44(A0/GOE0)
POWER_SW1_PWR_CTR_12V: Q44.3(C) R1003.2 R1072.1 R1292.1 R1293.1 R1294.1 R1295.1 R1296.1
POWER_SW1_PWR_CTR_12V_R: C592.1 J18.A11(PWRGD) R1072.2 R1292.2 R1293.2 R1294.2 R1295.2 R1296.2
POWER_SW1_PWR_CTR_N: R801.1 U65.15(P1_2) U104.G(GATE)
POWER_SW2_PWR_CTR_12V: Q45.3(C) R1004.2 R1073.1 R1312.1 R1313.1 R1314.1 R1315.1 R1316.1
POWER_SW2_PWR_CTR_12V_R: C594.1 J18.A10(3.3V_2) R1073.2 R1312.2 R1313.2 R1314.2 R1315.2 R1316.2
POWER_SW2_PWR_CTR_N: R803.1 U65.16(P1_3) U107.G(GATE)
POWER_SW3_PWR_CTR_12V: Q46.3(C) R1038.2 R1271.1 R1317.1 R1318.1 R1319.1 R1320.1 R1321.1
POWER_SW3_PWR_CTR_12V_R: C596.1 J18.A9(3.3V_1) R1271.2 R1317.2 R1318.2 R1319.2 R1320.2 R1321.2
POWER_SW3_PWR_CTR_N: R1060.1 U65.17(P1_4) U110.G(GATE)
PSU1_AC_OK: C600.1 R831.2 U63.4(P0_0)
PSU1_AC_OK_R: J35.B45(HSOP7+) R831.1 R845.1
PSU1_DC_OK: U63.10(P0_6) U84.4(Y)
PSU1_DC_OK_R: J35.A45(GND16) R832.1 R853.1
PSU1_DC_OK_R_BUF: C601.1 R832.2 U84.2(A) U94.G(GATE)
PSU1_HUB_EN: R1243.2 U60.5(EN1) U61.1(GPIO0)
PSU2_AC_OK: C602.1 R833.2 U63.5(P0_1)
PSU2_AC_OK_R: J35.B46(HSOP7-) R833.1 R848.1
PSU2_DC_OK: U63.11(P0_7) U88.4(Y)
PSU2_DC_OK_R: J35.A46(GND17) R834.1 R854.1
PSU2_DC_OK_R_BUF: C603.1 R834.2 U88.2(A) U97.G(GATE)
PSU2_HUB_EN: R1244.2 U60.9(EN2) U61.2(GPIO1)
PSU3_AC_OK: C605.1 R836.2 U63.6(P0_2)
PSU3_AC_OK_R: J35.B47(GND51) R836.1 R849.1
PSU3_DC_OK: U63.13(P1_0) U86.4(Y)
PSU3_DC_OK_R: J35.A47(HSIP7+) R837.1 R855.1
PSU3_DC_OK_R_BUF: C606.1 R837.2 U86.2(A) U95.G(GATE)
PSU3_HUB_EN: R1245.2 U60.12(EN3) U61.5(GPIO2)
PSU4_AC_OK: C608.1 R839.2 U63.7(P0_3)
PSU4_AC_OK_R: J35.B48(PRSNT2_N-3) R839.1 R850.1
PSU4_DC_OK: U63.14(P1_1) U89.4(Y)
PSU4_DC_OK_R: J35.A48(HSIP7-) R840.1 R856.1
PSU4_DC_OK_R_BUF: C609.1 R840.2 U89.2(A) U98.G(GATE)
PSU5_AC_OK: C611.1 R842.2 U63.8(P0_4)
PSU5_AC_OK_R: J35.B49(GND52) R842.1 R851.1
PSU5_DC_OK: U63.15(P1_2) U85.4(Y)
PSU5_DC_OK_R: J35.A49(GND18) R843.1 R857.1
PSU5_DC_OK_R_BUF: C612.1 R843.2 U85.2(A) U96.G(GATE)
PSU6_AC_OK: C614.1 R846.2 U63.9(P0_5)
PSU6_AC_OK_R: J35.B50(HSOP8+) R846.1 R852.1
PSU6_DC_OK: U63.16(P1_3) U87.4(Y)
PSU6_DC_OK_R: J35.A50(RSVD8) R847.1 R858.1
PSU6_DC_OK_R_BUF: C615.1 R847.2 U87.2(A) U99.G(GATE)
PSU_ALERT_N: C607.1 R838.2 U63.17(P1_4)
PSU_ALERT_R_N: J18.A80(HSIP15+) R838.1
PSU_DC_OK_N: R1012.1 R1014.2 U92.G(GATE) U94.D(DRAIN) U95.D(DRAIN) U96.D(DRAIN) U97.D(DRAIN) U98.D(DRAIN) U99.D(DRAIN) U114.D(DRAIN)
PU_CPU_NODE1_BRD_ID0: R153.1 R156.2 U2.B57(GPIOCORE8)
PU_CPU_NODE1_DFX_GPIO_GRP1_3: R53.1 U2.H34(DFX_GPIO_GRP1_3)
PU_CPU_NODE1_DFX_GPIO_GRP1_5: R51.1 U2.E31(DFX_GPIO_GRP1_5)
PU_CPU_NODE1_DFX_GPIO_GRP1_6: R47.1 U2.C31(DFX_GPIO_GRP1_6)
PU_CPU_NODE1_MEM_SPEED0: R171.1 R173.2 U2.AD56(MEM_SPEED0)
PU_EMC1428_NODE1_TRIP: R196.2 U9.5(TRIP_SET)
PU_FAN_TACH: R769.2 U70.4(TACH3) U70.9(TACH4)
PU_I2C_BMC_SCL: R346.2 U14.K21(SCL1)
PU_I2C_BMC_SDA: R345.2 U14.K22(SDA1)
PU_I2C_SCL4: R672.2 U60.13(SCL4)
PU_I2C_SDA4: R674.2 U60.14(SDA4)
PU_LAN1_TDI: R536.2 U35.40(JTAG_TDI)
PU_LAN1_TMS: R537.2 U35.38(NVMT/JTAG_TMS)
PU_LAN2_TDI: R567.2 U37.40(JTAG_TDI)
PU_LAN2_TMS: R568.2 U37.38(NVMT/JTAG_TMS)
PU_SATA_NODE1_GPIO4: R502.2 U30.18(GPIO4)
PU_TEMP1_NODE1_SYS_SHDN_L: R197.2 U9.6(SYS_SHDN#)
PV_VCCP_NODE1: C63.1 C64.1 C65.1 C66.1 C67.1 C68.1 C69.1 C70.1 C71.1 C72.1 C73.1 C81.1 C82.1 C83.1 C84.1 C85.1 C86.1 C87.1 C88.1 C89.1 C90.1 PC99.1 PC100.1 PC105.2 PC106.2 PC107.2 PC112.2 PC113.2 PC114.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC123.2 PC124.2 PC125.2 PC126.2 PL8.1A PR63.2 U2.AA44(VCCCPU0VIDSI01P05_21) U2.AA46(VCCCPU0VIDSI01P05_22) U2.AC44(VCCCPU0VIDSI01P05_23) U2.U62(VCCCPU0VIDSI01P05_1) U2.U63(VCCCPU0VIDSI01P05_2) U2.U65(VCCCPU0VIDSI01P05_3) U2.V63(VCCCPU0VIDSI01P05_4) U2.V64(VCCCPU0VIDSI01P05_5) U2.V66(VCCCPU0VIDSI01P05_6) U2.W44(VCCCPU0VIDSI01P05_7) U2.W46(VCCCPU0VIDSI01P05_8) U2.W48(VCCCPU0VIDSI01P05_9) U2.W50(VCCCPU0VIDSI01P05_10) U2.W53(VCCCPU0VIDSI01P05_11) U2.W54(VCCCPU0VIDSI01P05_12) U2.W57(VCCCPU0VIDSI01P05_13) U2.W59(VCCCPU0VIDSI01P05_14) U2.Y48(VCCCPU0VIDSI01P05_15) U2.Y50(VCCCPU0VIDSI01P05_16) U2.Y53(VCCCPU0VIDSI01P05_17) U2.Y54(VCCCPU0VIDSI01P05_18) U2.Y57(VCCCPU0VIDSI01P05_19) U2.Y59(VCCCPU0VIDSI01P05_20)
PV_VDDR_NODE1: C113.1 C114.1 C115.1 C116.1 C117.1 C118.1 C119.1 C120.1 C144.1 C145.1 C146.1 C147.1 C148.1 C149.1 C150.1 C151.1 C152.1 C153.1 C154.1 C155.1 C156.1 C157.1 C158.1 C159.1 C160.1 C161.1 C162.1 C163.1 C164.1 C165.1 C166.1 C167.1 C168.1 C169.1 C170.1 C171.1 C172.1 C173.1 C174.1 C175.1 C176.1 C177.1 C178.1 C854.1 J2.85(VDD13) J2.86(VDD12) J2.93(VDD11) J2.94(VDD10) J2.101(VDD9) J2.102(VDD8) J2.109(VDD7) J2.110(VDD6) J2.115(VDD5) J2.116(VDD4) J2.123(VDD3) J2.124(VDD2) J2.131(VDD1) J2.132(VDD0) L10.1 PC78.1 PC79.1 PC80.1 PC81.1 PC82.1 PC83.1 PC84.1 PJ12.2 PL7.2 PR35.2 R27.1 R202.1 R214.1 R215.1 R1040.2 R1044.2 R1124.1 U2.BD37(VCC_DDR3_1P5_1) U2.BD38(VCC_DDR3_1P5_2) U2.BD45(VCC_DDR3_1P5_3) U2.BE32(VCC_DDR3_1P5_4) U2.BE34(VCC_DDR3_1P5_5) U2.BE41(VCC_DDR3_1P5_6) U2.BE42(VCC_DDR3_1P5_7) U2.BK32(VCC_DDR3_1P5_8) U2.BK35(VCC_DDR3_1P5_9) U2.BK37(VCC_DDR3_1P5_10) U2.BK39(VCC_DDR3_1P5_11) U2.BK44(VCC_DDR3_1P5_12) U2.BK46(VCC_DDR3_1P5_13) U2.BM36(VCC_DDR3_1P5_14) U2.BM40(VCC_DDR3_1P5_15) U2.BM43(VCC_DDR3_1P5_16) U2.BM45(VCC_DDR3_1P5_17) U2.BM49(VCC_DDR3_1P5_18) U2.BP34(VCC_DDR3_1P5_19) U10.6(RH) U123.2(VLDOIN)
PV_VDDR_NODE1_EN: PJ10.2 PU7.10(EN)
PV_VDDR_NODE1_MODE: PJ9.1 PR33.1 PU7.16(MODE)
PV_VDDR_NODE1_SLEW: PC85.2 PU7.19(SLEW)
PV_VDDR_NODE1_TRIP: PR103.1 PU7.18(TRIP)
PV_VDDR_NODE1_V0: PR38.2 PR40.1 PU7.5(V0)
PV_VDDR_NODE1_V1: PR36.2 PR38.1 PU7.2(V3) PU7.3(V2) PU7.4(V1)
PV_VDDR_NODE1_VID0: PU7.8(VID0) Q43.3(D) R1123.2
PV_VDDR_NODE1_VID1: PR37.1 PU7.9(VID1)
PV_VDDR_NODE1_VREF: PC86.2 PR40.2 PU7.6(VREF)
PV_VDDR_NODE1_VREF_LM321: C181.1 R216.2 R217.2
PV_VDDR_NODE1_VREF_R: R215.2 R216.1 R218.1 U11.3(-IN) U11.4(OUT)
PV_VDDR_NODE1_VREF_RW: R213.1 R214.2 U10.5(RW) U11.1(+IN)
PV_VDDR_VCCCLK_DDR3_NODE1: C131.1 C132.1 L10.2 U2.BA41(VCCCLK_DDR3_1P5_1) U2.BB41(VCCCLK_DDR3_1P5_2)
PV_VTT_DDR_NODE1: C141.1 C857.1 C858.1 C859.1 J2.203(VTT1) J2.204(VTT0) J24.1 U123.3(VO)
PV_VTT_DDR_NODE1_REFIN: C855.1 R1124.2 R1125.1 U123.1(REFIN)
PV_VTT_DDR_NODE1_REFOUT: C860.1 U123.6(REFOUT)
PV_VTT_DDR_NODE1_VOSNS: J24.2 U123.5(VOSNS)
PWR_BTN_NODE1_C_L: C798.1 R1054.1 R1066.1 U106.2(A)
PWR_BTN_NODE1_L: C797.2 R1053.1 R1054.2 S1.1 S1.2
PWRGD_CPU_NODE1_EPWRGOOD: R141.2 U2.AD58(EPWRGOOD)
PWRGD_NODE1_DDR3_DRAM_POK: Q24.C(3) R1040.1 U2.BH42(DDR3_DRAM_PWROK)
PWRGD_NODE1_DDR3_SYSPWRGD: Q26.C(3) R1044.1 U2.BG32(DDR3_SYSPWRGOOD)
PWRGD_NODE1_P1V0: C884.2 R1218.2 U102.F3(IO_46) U130.5(PGOOD)
PWRGD_NODE1_P1V05_PG: PR24.2 PU6.16(PGOOD) U102.G3(IO_52)
PWRGD_NODE1_P1V5_SUS_PG: C824.2 R1087.2 U102.F1(IO_43) U120.5(PGOOD)
PWRGD_NODE1_P1V05_SUS_PG: C816.2 R1084.2 U102.G1(IO_49) U119.5(PGOOD)
PWRGD_NODE1_P1V8_STB_PG: PR13.2 PR14.1 PU4.5(PG) U102.D2(IO_33)
PWRGD_NODE1_P1V26_BMC_PG: R1096.1 U102.E3(IO_40) U122.5(PGOOD)
PWRGD_NODE1_P1V538_BMC_PG: C834.2 R1094.2 U102.D3(IO_34) U121.5(PGOOD)
PWRGD_NODE1_P3V3_PG: PR18.2 PR19.1 PU5.5(PG) U102.G2(IO_51)
PWRGD_NODE1_P3V3_STB_PG: PR5.2 PR6.1 PU2.5(PG) R1247.2
PWRGD_NODE1_P3V3_STB_PG_CPLD: R1247.1 U102.D1(IO_31)
PWRGD_NODE1_P5V_STB_PG: PC26.1 PJ2.1 PR1.2 PR2.1 PU1.5(PG) R1103.2 R1246.2
PWRGD_NODE1_P5V_STB_PG_CPLD: R1246.1 U102.C2(IO_23)
PWRGD_NODE1_P12V_PG: R1027.1 U102.B1(IO_11)
PWRGD_NODE1_P12V_PG_R: R1027.2 R1029.1 U101.2(RESET#)
PWRGD_NODE1_PVCCP_PG: PR52.1 PU8.21(VR_READY) U102.H4(IO_57)
PWRGD_NODE1_PVDDR_STB_PG: PR31.2 PU7.7(PGOOD) U102.F2(IO_45)
PWRGD_NODE1_PVTT_DDR_PG: R1126.2 U102.H1(IO_55) U123.9(PGOOD)
RST_BMC_NODE1_PERST_L: R253.2 R254.2 R272.2 U14.K19(PERST#)
RST_BTN_L: C801.2 R1062.1 R1063.2 S3.1 S3.2
RST_BTN_NODE1_C_L: C802.1 R1063.1 R1067.1 U58.2(A)
RST_BTN_NODE1_L: R1067.2 U58.4(Y) U102.J7(DEV_OE_IO_68)
RST_CPU_NODE1_SRTCRST_L: R175.1 R176.1 U2.N62(RTC_SRTCRST#) U102.E9(IO_42)
RST_NODE1_CPU_XDP_RSTIN_L: C183.1 J3.48 R223.1 U102.J9(IO_70)
SATA_A_NODE1_RX_N0: C494.2 U30.30(RXN_0)
SATA_A_NODE1_RX_P0: C492.2 U30.29(RXP_0)
SATA_A_NODE1_TX_N0: C490.2 U30.32(TXN_0)
SATA_A_NODE1_TX_P0: C489.2 U30.33(TXP_0)
SATA_NODE1_GPIO1: R509.2 R510.2 U30.74(GPIO1)
SATA_NODE1_GPIO2: R511.2 R512.2 U30.75(GPIO2)
SATA_NODE1_GPIO3: R514.2 R515.2 U30.17(GPIO3)
SATA_NODE1_GPIO5: R517.2 R518.2 U30.19(GPIO5)
SATA_NODE1_ISET: R504.1 U30.37(ISET)
SATA_NODE1_XTLOUT: R505.2 U30.36(XTLOUT)
SATA_P7: C495.1 C496.1 J7.7 R629.2 R630.2
SATA_RX0_C_DN: C494.1 J7.5
SATA_RX0_C_DP: C492.1 J7.6
SATA_SPI_CLK_NODE1: R508.1 U31.6(SCK)
SATA_SPI_CLK_NODE1_R: R508.2 U30.50(SPI_CLK)
SATA_SPI_CS_NODE1: R507.1 U31.1(CS#)
SATA_SPI_CS_NODE1_R: R507.2 U30.48(SPI_CS)
SATA_SPI_DI_NODE1: R519.2 U30.49(SPI_DI)
SATA_SPI_DI_NODE1_R: R516.1 R519.1 U31.2(SO)
SATA_SPI_DO_NODE1: R506.1 U31.5(SI)
SATA_SPI_DO_NODE1_R: R506.2 U30.47(SPI_DO)
SATA_TX0_C_DN: C490.1 J7.3
SATA_TX0_C_DP: C489.1 J7.2
SATA_VCONT_NODE1: Q12.1(B) U30.38(VCONT_10)
SDC_RST_N: U73.3(RESET) U128.8(IO7_B1)
SDC_WAKEUP: R782.1 R783.2 U73.13(WAKEUP)
SEL_DOT_SRC5: R20.1 R24.2 U1.16(^DOT96_SEL/USB48M)
SEL_PCI_27M: R12.1 R18.2 U1.21(VSEL_PCI/27M_PCI4_2X)
SIO_AVCC: C482.1 C483.1 L36.1 U43.99(AVCC)
SIO_CLKIN: R618.2 R815.2 U43.49(CLKIN)
SIO_COPEN_N: R624.1 U43.68(COPEN#)
SIO_CPLD_RSV1_R: R1078.1 R1181.2 R1182.1 U43.111(PD2/GP62)
SIO_CPLD_RSV2_R: R1183.2 R1184.1 R1193.1 U43.110(PD1/GP61)
SIO_CPLD_RSV3_R: R1185.2 R1186.1 R1194.1 U43.109(PD0/GP60)
SIO_GPIO47: R1150.2 U43.71(SUSB#/GP47)
SIO_JTAG_CPLD1_TCK: R1267.2 R1270.1 R1287.1
SIO_JTAG_CPLD1_TCK_R: R1267.1 R1291.1 U43.58(STEP#/GP54)
SIO_JTAG_CPLD1_TDI: R1265.2 R1266.1 R1285.1
SIO_JTAG_CPLD1_TDI_R: R1265.1 R1289.1 U43.59(HDSEL#/GP55)
SIO_JTAG_CPLD1_TDO: R1286.1 R1290.1 U43.91(VIN7/SO/GP32)
SIO_JTAG_CPLD1_TMS: R1268.2 R1269.1 R1272.1
SIO_JTAG_CPLD1_TMS_R: R1268.1 R1288.1 U43.61(RDATA#/GP57)
SIO_JTAG_CPLD2_TCK: R1119.1 R1189.2 R1192.1
SIO_JTAG_CPLD2_TCK_R: R816.1 R1189.1 U43.116(PD7/GP67)
SIO_JTAG_CPLD2_TDI: R1081.1 R1187.2 R1188.1
SIO_JTAG_CPLD2_TDI_R: R1077.1 R1187.1 U43.113(PD4/GP64)
SIO_JTAG_CPLD2_TDO: R1056.1 R1080.1 U43.115(PD6/GP66)
SIO_JTAG_CPLD2_TMS: R1079.1 R1190.2 R1191.1
SIO_JTAG_CPLD2_TMS_R: R1065.1 R1190.1 U43.114(PD5/GP65)
SIO_JTAG_CPLD3_TCK: R1200.1 R1207.2 R1210.1
SIO_JTAG_CPLD3_TCK_R: R1204.1 R1207.1 U43.52(MTRA#/GP50)
SIO_JTAG_CPLD3_TDI: R1198.1 R1205.2 R1206.1
SIO_JTAG_CPLD3_TDI_R: R1202.1 R1205.1 U43.57(DIR#/GP53)
SIO_JTAG_CPLD3_TDO: R1199.1 R1203.1 U43.54(DRVA#/GP51)
SIO_JTAG_CPLD3_TMS: R1197.1 R1208.2 R1209.1
SIO_JTAG_CPLD3_TMS_R: R1201.1 R1208.1 U43.56(WDATA#/GP52)
SIO_LRESET_N: R621.2 U43.37(LRESET#)
SIO_PCICLK33: R625.2 U43.47(PCICLK)
SIO_PIN38: R617.2 U43.38(LDRQ#)
SIO_PIN45: R1138.2 U43.45(KRST#/GP36)
SIO_PIN72: R1143.2 U43.72(PWRON#/GP46)
SIO_PIN73: R1140.2 U43.73(PME#/GP45)
SIO_PIN75: R1142.2 U43.75(PANSWH#/GP43)
SIO_PIN76: R1141.2 U43.76(PSON#/GP42)
SIO_PIN78: R1144.2 U43.78(PWROK1/GP41)
SIO_PIN80: R1145.2 U43.80(KDAT/GP13)
SIO_PIN81: R1146.2 U43.81(KCLK/GP12)
SIO_PIN82: R1147.2 U43.82(MDAT/GP11)
SIO_PIN83: R1148.2 U43.83(MCLK/GP10)
SIO_PWROK2: R620.2 U43.51(DENSEL#/PWROK2)
SIO_VBAT: C486.1 D6.2 U43.69(VBAT)
SIO_VCCH: C487.1 C488.1 R628.2 U43.67(VCCH)
SIO_VREF: C485.1 U43.90(VREF)
SMB_BMC_NODE1_DDC_CLK: D7.1 Q17.S(SOURCE) R633.2 U14.T2(DDCCLK_GPIOJ6)
SMB_BMC_NODE1_DDC_DAT: D8.1 Q18.S(SOURCE) R632.2 U14.T1(DDCDAT_GPIOJ7)
SMB_BMC_NODE1_HSC_ALERT_L: R106.2 R1023.1 U2.M60(GPIOSUS5)
SMB_BMC_NODE1_HSC_ALERT_R_L: R106.1 U100.10(ALERT#)
SMB_CPU_NODE1_BMC_CLK: R130.2 R131.2 R232.1 U100.6(SCL)
SMB_CPU_NODE1_BMC_CLK_RR: C30.2 R130.1 U2.Y13(SMBM_CLK)
SMB_CPU_NODE1_BMC_DAT: R132.2 R133.2 R233.1 U100.7(SDA)
SMB_CPU_NODE1_BMC_DAT_RR: C31.2 R132.1 U2.W16(SMBM_DATA)
SMB_CPU_NODE1_MEM_ICS_CLK_R: C28.2 R125.1 U2.Y11(SMBH_CLK)
SMB_CPU_NODE1_MEM_ICS_DAT_R: C29.2 R128.1 U2.W13(SMBH_DATA)
SMB_CPU_NODE1_XDP_CLK: J3.53 R121.2 R122.2
SMB_CPU_NODE1_XDP_CLK_R: C26.2 R121.1 U2.W11(SMBD_CLK)
SMB_CPU_NODE1_XDP_DAT: J3.51 R123.2 R124.2
SMB_CPU_NODE1_XDP_DAT_R: C27.2 R123.1 U2.W17(SMBD_DATA)
SMB_DIMM_NODE1_CLK: J2.202(SCL) R471.2
SMB_DIMM_NODE1_DAT: J2.200(SDA) R472.2
SMB_LAN1_ALT_N: R538.2 R561.2 U35.35(S\M\B\_\A\L\R\T\)
SMB_LAN1_CLK: R539.2 R563.2 U35.34(SMB_CLK)
SMB_LAN1_DAT: R540.2 R562.2 U35.36(SMB_DAT)
SMB_LAN2_ALT_N: R569.2 R591.2 U37.35(S\M\B\_\A\L\R\T\)
SMB_LAN2_CLK: R570.2 R593.2 U37.34(SMB_CLK)
SMB_LAN2_DAT: R566.2 R592.2 U37.36(SMB_DAT)
SMB_MUX_CPU_ICS_NODE1_CLK: R125.2 R126.2 R471.1 U1.6(SCLK_3.3) U9.12(SMCLK) U10.3(SCL) U134.6(SCL)
SMB_MUX_CPU_ICS_NODE1_DAT: R128.2 R129.2 R472.1 U1.5(SDATA_3.3) U9.11(SMDATA) U10.4(SDA) U134.5(SDA)
SMB_PCH_SCL: R563.1 R593.1
SMB_PCH_SDA: R562.1 R592.1
SMB_TEMP1_NODE1_ALERT_L: R199.1 U2.H54(GPIOCORE5)
SMB_TEMP1_NODE1_ALERT_R_L: R198.2 R199.2 U9.7(ALERT#)
SPC_CPU_NODE1_CTS_L: R71.2 U2.C49(UART_CTS#)
SPC_CPU_NODE1_DCD_L: R67.2 U2.H46(UART_DCD#)
SPC_CPU_NODE1_DSR_L: R69.2 U2.J44(UART_DSR#)
SPC_CPU_NODE1_DTR_L: R67.1 R69.1 U2.A48(UART_DTR#)
SPC_CPU_NODE1_RI_L: R75.2 U2.B48(UART_RI#)
SPC_CPU_NODE1_RTS_L: R71.1 U2.H50(UART_RTS#)
SPI_CPU_NODE1_CS0_L: R57.1 U4.1(C\S\) U5.1(C\S\)
SPI_CPU_NODE1_CS0_R_L: R57.2 U2.C40(SPI_CS#0)
SPI_CPU_NODE1_HOLD_L: R177.2 U4.7(H\O\L\D\) U5.7(H\O\L\D\)
SPI_CPU_NODE1_MISO: R178.1 U2.E40(SPI_MISO)
SPI_CPU_NODE1_MISO_R: R178.2 U4.2(SO) U5.2(SO)
SPI_CPU_NODE1_MOSI: R58.2 U4.5(SI) U5.5(SI)
SPI_CPU_NODE1_MOSI_R: R58.1 U2.D42(SPI_MOSI)
SPI_CPU_NODE1_SCLK: R59.2 U4.6(SCK) U5.6(SCK)
SPI_CPU_NODE1_SCLK_R: R59.1 U2.J38(SPI_SCLK)
SPI_CPU_NODE1_WP_L: R49.1 U4.3(W\P\) U5.3(W\P\)
SPI_CPU_NODE1_WP_R_L: R48.2 R49.2 R112.2 U2.L60(GPIOSUS7)
SPI_LAN1_NVM_CS_N: R542.2 R543.1 U35.15(N\V\M\_\C\S\)
SPI_LAN1_NVM_SI: R547.1 U35.12(NVM_SI)
SPI_LAN1_NVM_SK: R545.1 U35.13(NVM_SK)
SPI_LAN1_NVM_SO: R549.1 U35.14(NVM_SO)
SPI_LAN2_NVM_CS_N: R572.2 R573.1 U37.15(N\V\M\_\C\S\)
SPI_LAN2_NVM_SI: R577.1 U37.12(NVM_SI)
SPI_LAN2_NVM_SK: R575.1 U37.13(NVM_SK)
SPI_LAN2_NVM_SO: R579.1 U37.14(NVM_SO)
SPI_USB_NODE1_CLK: R522.1 U33.6(SCK)
SPI_USB_NODE1_CLK_R: R522.2 U32.18(SPISCK)
SPI_USB_NODE1_CSB_N: R523.1 U33.1(CS#)
SPI_USB_NODE1_CSB_R_L: R523.2 U32.17(SPICSB)
SPI_USB_NODE1_HOLD_L: R529.2 U33.7(HOLD#)
SPI_USB_NODE1_R_SO: R524.2 U32.19(SPISI)
SPI_USB_NODE1_SI: R530.2 R531.1 U32.16(SPISO)
SPI_USB_NODE1_SI_R: R530.1 U33.2(SO)
SPI_USB_NODE1_SO: R524.1 U33.5(SI)
SPI_USB_NODE1_WP_L: R528.2 U33.3(WP#)
SVID_CPU_NODE1_CLK_R: PR44.2 PU8.25(VCLK)
SVID_CPU_NODE1_DAT_R: PR46.2 PU8.24(VDIO)
SVID_CPU_NODE1_PVCCP_ALERT_L: PU8.23(ALERT) R118.2 R119.1
SVID_CPU_NODE1_PVCCP_ALERT_R_L: R118.1 U2.AB63(SVID_ALERT#)
SVID_CPU_NODE1_PVCCP_CLK: PR44.1 PR50.2 U2.AB62(SVID_CLK)
SVID_CPU_NODE1_PVCCP_DAT: PR45.2 PR46.1 R117.2 R127.1 R137.1
SVID_CPU_NODE1_PVCCP_DAT_R: R117.1 U2.AC58(SVID_DATA)
SW_P1V05_NODE1_BT: PC60.1 PU6.13(VBST)
SW_P1V05_NODE1_DRVH: PQ1.1(G1) PU6.11(DRVH)
SW_P1V05_NODE1_DRVL: PQ1.8(G2) PU6.10(DRVL)
SW_P1V05_NODE1_PH: PC60.2 PL6.1 PQ1.S1/D2_EP(S1/D2) PU6.12(SW)
SW_P1V05_NODE1_VIN_FLT: PC54.1 PC55.1 PC56.1 PC57.1 PC58.1 PQ1.2(D1-1) PQ1.3(D1-2) PQ1.4(D1-3) PQ1.D1_EP(D1-4) PR22.1
SW_P1V8_STB_NODE1_BT: PC36.1 PU4.12(VBST)
SW_P1V8_STB_NODE1_PH: PC36.2 PL4.1 PU4.9(SW_1) PU4.10(SW_2) PU4.11(SW_3)
SW_P3V3_NODE1_BT: PC47.1 PU5.12(VBST)
SW_P3V3_NODE1_PH: PC47.2 PL17.1 PU5.9(SW_1) PU5.10(SW_2) PU5.11(SW_3)
SW_P3V3_STB_NODE1_BT: PC15.1 PU2.12(VBST)
SW_P3V3_STB_NODE1_PH: PC15.2 PL2.1 PU2.9(SW_1) PU2.10(SW_2) PU2.11(SW_3)
SW_P5V_STB_NODE1_BT: PC4.1 PU1.12(VBST)
SW_P5V_STB_NODE1_PH: PC4.2 PL12.1 PU1.9(SW_1) PU1.10(SW_2) PU1.11(SW_3)
SW_PV_VDDR_NODE1_BT: PC77.1 PU7.11(BST)
SW_PV_VDDR_NODE1_DRVH: PQ2.1(G1) PU7.13(DRVH)
SW_PV_VDDR_NODE1_DRVL: PQ2.8(G2) PU7.14(DRVL)
SW_PV_VDDR_NODE1_PH: PC77.2 PL7.1 PQ2.S1/D2_EP(S1/D2) PU7.12(SW)
SW_PV_VDDR_NODE1_VIN_FLT: PC71.1 PC72.1 PC73.1 PC74.1 PC75.1 PQ2.2(D1-1) PQ2.3(D1-2) PQ2.4(D1-3) PQ2.D1_EP(D1-4) PR32.1
SW_VR_PVCCP_NODE1_VIN_FLT: PC89.1 PC90.1 PC91.1 PC92.1 PC93.1 PC94.1 PR43.2 PR49.1 U124.2(D1-1) U124.3(D1-2) U124.4(D1-3) U124.D1_EP(D1-4)
SYS_AUTO_POWER_ON_N: R1120.1 R1121.1 U102.K1(IO_71)
T1_NODE1_EN: R689.1 R859.1 U62.4(P0_0)
T1_NODE1_EN_R: C622.1 J35.A30(HSIP3-) R859.2
T1_NODE2_EN: R690.1 R862.1 U62.5(P0_1)
T1_NODE2_EN_R: C625.1 J35.A31(GND10) R862.2
T1_NODE3_EN: R691.1 R865.1 U62.6(P0_2)
T1_NODE3_EN_R: C628.1 J35.A32(RSVD6) R865.2
T1_NODE4_EN: R692.1 R868.1 U62.7(P0_3)
T1_NODE4_EN_R: C631.1 J35.A33(RSVD7) R868.2
T2_NODE1_EN: R693.1 R871.1 U62.8(P0_4)
T2_NODE1_EN_R: C634.1 J35.B27(HSOP3+) R871.2
T2_NODE2_EN: R694.1 R874.1 U62.9(P0_5)
T2_NODE2_EN_R: C637.1 J35.B28(HSOP3-) R874.2
T2_NODE3_EN: R695.1 R877.1 U62.10(P0_6)
T2_NODE3_EN_R: C640.1 J35.B29(GND43) R877.2
T2_NODE4_EN: R696.1 R880.1 U62.11(P0_7)
T2_NODE4_EN_R: C643.1 J35.B30(RSVD3) R880.2
T3_NODE1_EN: R697.1 R883.1 U62.13(P1_0)
T3_NODE1_EN_R: C646.1 J35.A15(GND3) R883.2
T3_NODE2_EN: R698.1 R886.1 U62.14(P1_1)
T3_NODE2_EN_R: C649.1 J35.A16(HSIP0+) R886.2
T3_NODE3_EN: R699.1 R889.1 U62.15(P1_2)
T3_NODE3_EN_R: C652.1 J35.A17(HSIP0-) R889.2
T3_NODE4_EN: R700.1 R892.1 U62.16(P1_3)
T3_NODE4_EN_R: C655.1 J35.A18(GND4) R892.2
T4_NODE1_EN: R703.1 R895.1 U62.17(P1_4)
T4_NODE1_EN_R: C658.1 J35.B12(RSVD2) R895.2
T4_NODE2_EN: R705.1 R898.1 U62.18(P1_5)
T4_NODE2_EN_R: C661.1 J35.B13(GND36) R898.2
T4_NODE3_EN: R707.1 R901.1 U62.19(P1_6)
T4_NODE3_EN_R: C664.1 J35.B14(HSOP0+) R901.2
T4_NODE4_EN: R709.1 R904.1 U62.20(P1_7)
T4_NODE4_EN_R: C667.1 J35.B15(HSOP0-) R904.2
T5_NODE1_EN: R710.1 R896.1 U64.4(P0_0)
T5_NODE1_EN_R: C659.1 J18.A81(HSIP15-) R896.2
T5_NODE2_EN: R711.1 R899.1 U64.5(P0_1)
T5_NODE2_EN_R: C662.1 J18.A82(GND33) R899.2
T5_NODE3_EN: R712.1 R902.1 U64.6(P0_2)
T5_NODE3_EN_R: C665.1 J35.A2(12V_1) R902.2
T5_NODE4_EN: R713.1 R905.1 U64.7(P0_3)
T5_NODE4_EN_R: C668.1 J35.A3(12V_2) R905.2
T6_NODE1_EN: R714.1 R884.1 U64.8(P0_4)
T6_NODE1_EN_R: C647.1 J18.B76(GND65) R884.2
T6_NODE2_EN: R715.1 R887.1 U64.9(P0_5)
T6_NODE2_EN_R: C650.1 J18.B77(GND66) R887.2
T6_NODE3_EN: R716.1 R890.1 U64.10(P0_6)
T6_NODE3_EN_R: C653.1 J18.B78(HSOP15+) R890.2
T6_NODE4_EN: R717.1 R893.1 U64.11(P0_7)
T6_NODE4_EN_R: C656.1 J18.B79(HSOP15-) R893.2
T7_NODE1_EN: R720.1 R872.1 U64.13(P1_0)
T7_NODE1_EN_R: C635.1 J18.A65(HSIP11-) R872.2
T7_NODE2_EN: R721.1 R875.1 U64.14(P1_1)
T7_NODE2_EN_R: C638.1 J18.A66(GND26) R875.2
T7_NODE3_EN: R722.1 R878.1 U64.15(P1_2)
T7_NODE3_EN_R: C641.1 J18.A67(RSVD9) R878.2
T7_NODE4_EN: R723.1 R881.1 U64.16(P1_3)
T7_NODE4_EN_R: C644.1 J18.A68(HSIP12+) R881.2
T8_NODE1_EN: R724.1 R860.1 U64.17(P1_4)
T8_NODE1_EN_R: C623.1 J18.B61(GND58) R860.2
T8_NODE2_EN: R725.1 R863.1 U64.18(P1_5)
T8_NODE2_EN_R: C626.1 J18.B62(HSOP11+) R863.2
T8_NODE3_EN: R726.1 R866.1 U64.19(P1_6)
T8_NODE3_EN_R: C629.1 J18.B63(HSOP11-) R866.2
T8_NODE4_EN: R727.1 R869.1 U64.20(P1_7)
T8_NODE4_EN_R: C632.1 J18.B64(GND59) R869.2
T9_NODE1_EN: R728.1 R861.1 U66.4(P0_0)
T9_NODE1_EN_R: C624.1 J18.A50(RSVD8) R861.2
T9_NODE2_EN: R729.1 R864.1 U66.5(P0_1)
T9_NODE2_EN_R: C627.1 J18.A51(GND19) R864.2
T9_NODE3_EN: R730.1 R867.1 U66.6(P0_2)
T9_NODE3_EN_R: C630.1 J18.A52(HSIP8+) R867.2
T9_NODE4_EN: R731.1 R870.1 U66.7(P0_3)
T9_NODE4_EN_R: C633.1 J18.A53(HSIP8-) R870.2
T10_NODE1_EN: R732.1 R873.1 U66.8(P0_4)
T10_NODE1_EN_R: C636.1 J18.B46(HSOP7-) R873.2
T10_NODE2_EN: R733.1 R876.1 U66.9(P0_5)
T10_NODE2_EN_R: C639.1 J18.B47(GND51) R876.2
T10_NODE3_EN: R736.1 R879.1 U66.10(P0_6)
T10_NODE3_EN_R: C642.1 J18.B48(PRSNT2_N-3) R879.2
T10_NODE4_EN: R740.1 R882.1 U66.11(P0_7)
T10_NODE4_EN_R: C645.1 J18.B49(GND52) R882.2
T11_NODE1_EN: R741.1 R885.1 U66.13(P1_0)
T11_NODE1_EN_R: C648.1 J18.A35(HSIP4+) R885.2
T11_NODE2_EN: R742.1 R888.1 U66.14(P1_1)
T11_NODE2_EN_R: C651.1 J18.A36(HSIP4-) R888.2
T11_NODE3_EN: R744.1 R891.1 U66.15(P1_2)
T11_NODE3_EN_R: C654.1 J18.A37(GND12) R891.2
T11_NODE4_EN: R745.1 R894.1 U66.16(P1_3)
T11_NODE4_EN_R: C657.1 J18.A38(GND13) R894.2
T12_NODE1_EN: R746.1 R897.1 U66.17(P1_4)
T12_NODE1_EN_R: C660.1 J18.B31(PRSNT2_N-2) R897.2
T12_NODE2_EN: R747.1 R900.1 U66.18(P1_5)
T12_NODE2_EN_R: C663.1 J18.B32(GND44) R900.2
T12_NODE3_EN: R748.1 R903.1 U66.19(P1_6)
T12_NODE3_EN_R: C666.1 J18.B33(HSOP4+) R903.2
T12_NODE4_EN: R749.1 R906.1 U66.20(P1_7)
T12_NODE4_EN_R: C669.1 J18.B34(HSOP4-) R906.2
TACKOVER_EN: R1309.2 U140.D(DRAIN) U141.G(GATE) U142.G(GATE) U143.G(GATE) U144.G(GATE)
TACKOVER_EN_N: J32.1 R812.1 U65.13(P1_0) U128.58(IO7_B2) U129.58(IO7_B2) U140.G(GATE)
THRU_85_OHM: J30.2 J30.3
TMP05_FUNC1: R759.1 U68.3(FUNC)
TMP05_FUNC2: R766.1 U71.3(FUNC)
TOP_85OHM: J4.2 J4.3
TP_BIOS_NODE1_PORT80_ID0: J1.6
TP_BMC_NODE1_ADCVREFN: U14.K2(ADCVREFN)
TP_BMC_NODE1_ADCVREFP: U14.K1(ADCVREFP)
TP_BMC_NODE1_DDR3_CE1_NC1: U15.J9(CE1_NC1)
TP_BMC_NODE1_DDR3_CS1_L: U15.L1(CS1_N_NC)
TP_BMC_NODE1_DDR3_MA15: U15.M7(A15_BA3)
TP_BMC_NODE1_DDR3_ODT_1NC: U15.J1(ODT_1NC)
TP_BMC_NODE1_DDR3_ZQ1: U15.L9(ZQ1_NC)
TP_CPLD_NODE1_IO39: U102.E10(GCLK3_IO_38)
TP_CPU0_NODE1_HFPLL: U2.AH50(CPU0_HFPLL)
TP_CPU0_NODE1_SFRANAD: U2.C36(CPU0_SFRANAD)
TP_CPU1_NODE1_HFPLL: U2.AG50(CPU1_HFPLL)
TP_CPU1_NODE1_SFRANAD: U2.D35(CPU1_SFRANAD)
TP_CPU_D53: U2.D53(GPIOCORE3)
TP_CPU_E59: U2.E59(GPIOCORE14)
TP_CPU_NODE1_ADR_COMPLETE: U2.B53(NC#B53)
TP_CPU_NODE1_C2F_LP_MODE: U2.A51(TESTLO_14)
TP_CPU_NODE1_EXTBGREF: U2.E36(CPU_EXTBGREF)
TP_CPU_NODE1_HPLL_MONN: U2.H1(HPLL_MONN)
TP_CPU_NODE1_HPLL_MONP: U2.F1(HPLL_MONP)
TP_CPU_NODE1_IERR_LV: U2.AG54(CPU_IERR)
TP_CPU_NODE1_K62: U2.K62(GPIOSUS6)
TP_CPU_NODE1_M52: U2.M52(GPIOSUS0)
TP_CPU_NODE1_RP0_PERN1: U2.BM7(RP0_PERN1)
TP_CPU_NODE1_RP0_PERN3: U2.BF1(RP0_PERN3)
TP_CPU_NODE1_RP0_PERN5: U2.BB2(RP0_PERN5)
TP_CPU_NODE1_RP0_PERN7: U2.AY4(RP0_PERN7)
TP_CPU_NODE1_RP0_PERP1: U2.BL7(RP0_PERP1)
TP_CPU_NODE1_RP0_PERP3: U2.BF3(RP0_PERP3)
TP_CPU_NODE1_RP0_PERP5: U2.BB4(RP0_PERP5)
TP_CPU_NODE1_RP0_PERP7: U2.AY2(RP0_PERP7)
TP_CPU_NODE1_RP0_PETN1: U2.BB17(RP0_PETN1)
TP_CPU_NODE1_RP0_PETN3: U2.BG9(RP0_PETN3)
TP_CPU_NODE1_RP0_PETN5: U2.BC10(RP0_PETN5)
TP_CPU_NODE1_RP0_PETN7: U2.AW11(RP0_PETN7)
TP_CPU_NODE1_RP0_PETP1: U2.BD17(RP0_PETP1)
TP_CPU_NODE1_RP0_PETP3: U2.BG8(RP0_PETP3)
TP_CPU_NODE1_RP0_PETP5: U2.BC8(RP0_PETP5)
TP_CPU_NODE1_RP0_PETP7: U2.AW9(RP0_PETP7)
TP_CPU_NODE1_RP0_PLLMON0: U2.BM5(RP0_PLLMON0)
TP_CPU_NODE1_RP0_PLLMON1: U2.BM3(RP0_PLLMON1)
TP_CPU_NODE1_RSVD_MVT0: U2.B39(RSVD_MVT0)
TP_CPU_NODE1_RSVD_MVT1: U2.H37(RSVD_MVT1)
TP_CPU_NODE1_SOC_THERMATP0: U2.T18(SOC_THERMANATP0)
TP_CPU_NODE1_SOC_THERMATP1: U2.P22(SOC_THERMANATP1)
TP_CPU_NODE1_VCCCPU0VIDSI0GT1_1: U2.AC42(VCCCPU0VIDSI0GT1P05_2)
TP_CPU_NODE1_VCCCPU0VIDSI0GT1P0: U2.AC41(VCCCPU0VIDSI0GT1P05_1)
TP_CPU_NODE1_VCCCPU1VIDSI0GT1_1: U2.AG42(VCCCPU1VIDSI0GT1P05_2)
TP_CPU_NODE1_VCCCPU1VIDSI0GT1P0: U2.AG41(VCCCPU1VIDSI0GT1P05_1)
TP_DDR3_NODE1_CS2_L: J2.120(S2#)
TP_DDR3_NODE1_CS3_L: J2.118(S3#)
TP_FM_CPLD_NODE1_BMC_EXTRST_L: U102.D9(IO_36)
TP_FM_CPLD_NODE1_P1V0_STB_EN: U102.A8(IO_09)
TP_FM_CPLD_NODE1_P3V3_STB_SW_EN: U102.C3(IO_24)
TP_FM_CPLD_NODE1_PWR_BTN_BMC: U102.C4(IO_25)
TP_FM_CPLD_NODE1_SSI_PERST_L: U102.C6(IO_27)
TP_NODE1_ERR_OUT_DIMM0: J2.198(EVENT#)
TP_P1V8_VCCABGTS_NODE1: U2.AG23(VCCABGTS1P8)
TP_P3V3_NODE1_INIT_L: J1.2
TP_SATA_NODE1: U30.22(TP)
TP_SPI_CPU_NODE1_CS1_L: U2.E39(SPI_CS#1)
TP_TEMP1_NODE1_1: U9.15(DP6/DN7)
TP_TEMP1_NODE1_2: U9.14(DN6/DP7)
TP_TEMP1_NODE1_3: U9.13(NC#13)
TP_U3TXDN1: U32.36(U3TXDN1)
TP_U3TXDN2: U32.45(U3TXDN2)
TP_U3TXDN3: U32.53(U3TXDN3)
TP_U3TXDN4: U32.62(U3TXDN4)
TP_U3TXDP1: U32.35(U3TXDP1)
TP_U3TXDP2: U32.44(U3TXDP2)
TP_U3TXDP3: U32.52(U3TXDP3)
TP_U3TXDP4: U32.61(U3TXDP4)
TPM_LPC_SERIRQ_PORT80_NODE1: J1.10 R179.2
UART3_RESET_N: R673.1 U61.3(RESET) U129.8(IO7_B1)
UART_CMC_RX_P: R1248.2 U61.10(TX) U129.21(IO14_B1)
UART_CMC_TX_P: U61.9(RX) U129.20(IO13_B1)
UART_CTS_P1_L_N: J35.B65(GND60) U51.6(RIN3)
UART_CTS_P1_N: U43.120(CTS1#) U51.17(ROUT3)
UART_CTS_P2_L_N: J35.A65(HSIP11-) U52.6(RIN3)
UART_CTS_P2_N: U43.128(CTS2#) U52.17(ROUT3)
UART_CTS_P3_N: R777.2 U43.13(CTS3#)
UART_CTS_P4_N: R1325.2 U43.22(CTS4#)
UART_CTS_P5_L_N: J35.B57(GND56) U55.7(RIN4)
UART_CTS_P5_N: R616.2 U43.32(RESETCON#/CTS5#/GP27) U55.16(ROUT4)
UART_CTS_P6_L_N: J35.A57(HSIP9-) U56.7(RIN4)
UART_CTS_P6_N: U43.92(VIN6/CTS6#/GP31) U56.16(ROUT4)
UART_CTS_RP5_L_N: J18.B24(HSOP2-) TP10.1
UART_CTS_RP6_L: J18.A23(GND6) TP12.1
UART_DCD_P3_N: R1264.2 U43.11(DCD3#)
UART_DCD_P4_N: R1322.2 U43.20(DCD4#)
UART_DSR_P1_L_N: J35.B61(GND58) U51.5(RIN2)
UART_DSR_P1_N: U43.123(DSR1#) U51.18(ROUT2)
UART_DSR_P2_L_N: J35.A61(HSIP10-) U52.5(RIN2)
UART_DSR_P2_N: U43.3(DSR2#) U52.18(ROUT2)
UART_DSR_P3_N: R614.2 U43.17(DSR3#)
UART_DSR_P4_N: R1323.2 U43.27(DSR4#)
UART_DSR_P5_L_N: J35.B53(GND54) U55.6(RIN3)
UART_DSR_P5_N: U43.36(DSR5#/GP24) U55.17(ROUT3)
UART_DSR_P6_L_N: J35.A53(HSIP8-) U56.6(RIN3)
UART_DSR_P6_N: R1139.2 U43.95(VIN3/ATXPG/DSR6#) U56.17(ROUT3)
UART_DSR_RP5_L: J18.B20(HSOP1-) TP9.1
UART_DSR_RP6_L_N: J18.A19(RSVD5) TP11.1
UART_DTR_P1_L_N: J35.B64(GND59) U51.11(DOUT3)
UART_DTR_P1_N: R1005.2 R1008.2 U43.121(DTR1#/JP1) U51.12(DIN3)
UART_DTR_P2_L_N: J35.A64(HSIP11+) U52.11(DOUT3)
UART_DTR_P2_N: R1015.2 R1016.2 U43.1(DTR2#/JP4) U52.12(DIN3)
UART_DTR_P3_N: R1155.2 R1156.1 U129.17(IO10_B1)
UART_DTR_P3_R_N: R1132.2 R1133.2 R1155.1 U43.14(DTR3#/JP7)
UART_DTR_P4_N: R1163.2 R1166.1 U128.17(IO10_B1)
UART_DTR_P4_R_N: R1163.1 U43.23(DTR4#)
UART_DTR_P5_L_N: J35.B56(GND55) U55.11(DOUT3)
UART_DTR_P5_N: U43.33(DTR5#/GP26) U55.12(DIN3)
UART_DTR_P6_L_N: J35.A56(HSIP9+) U56.11(DOUT3)
UART_DTR_P6_N: U43.29(DTR6#/GP15) U56.12(DIN3)
UART_DTR_RP5_L_N: J18.B23(HSOP2+) U57.11(DOUT3)
UART_DTR_RP6_L_N: J18.A22(HSIP1-) U59.11(DOUT3)
UART_RI_P1_N: R814.2 U43.119(RI1#)
UART_RI_P2_N: R626.2 U43.127(RI2#)
UART_RI_P3_BUFFER_N: R1327.1 R1330.1 U129.62(IO41_B2/GCLK2) U146.2(A)
UART_RI_P3_N: R1263.2 R1327.2 R1328.1 U43.12(RI3#) U146.4(Y)
UART_RI_P4_N: R1324.1 R1329.1 U128.19(IO12_B1) U145.2(A)
UART_RI_P4_R_N: R615.2 R1324.2 R1326.1 U43.21(RI4#) U145.4(Y)
UART_RI_P5_L_N: R1332.1 U55.5(RIN2)
UART_RI_P5_L_N_R: J35.B58(HSOP10+) R1332.2
UART_RI_P5_LS_N: R1068.1 R1310.2 U55.18(ROUT2) U144.S(SOURCE)
UART_RI_P5_N: R1068.2 R1262.2 U43.70(RI5#/GP21) U144.D(DRAIN)
UART_RI_P6_L_N: R1331.2 U56.5(RIN2)
UART_RI_P6_L_N_R: J35.A58(GND22) R1331.1
UART_RI_P6_LS_N: R1069.1 R1311.2 U56.18(ROUT2) U143.S(SOURCE)
UART_RI_P6_N: R776.2 R1069.2 U43.87(TMPIN3/RI6#) U143.D(DRAIN)
UART_RI_RP5_L_N: R1334.1 U57.5(RIN2)
UART_RI_RP5_L_N_R: J18.B25(GND41) R1334.2
UART_RI_RP6_L_N: R1333.2 U59.5(RIN2)
UART_RI_RP6_L_N_R: J18.A24(GND7) R1333.1
UART_RTS_P1_L_N: J35.B60(GND57) U51.9(DOUT1)
UART_RTS_P1_N: R1011.2 R1013.2 U43.122(RTS1#/JP2) U51.14(DIN1)
UART_RTS_P2_L_N: J35.A60(HSIP10+) U52.9(DOUT1)
UART_RTS_P2_N: R1017.2 R1018.2 U43.2(RTS2#/JP5) U52.14(DIN1)
UART_RTS_P3_N: R1157.2 R1158.1 U129.78(IO21_B2)
UART_RTS_P3_R_N: R1136.2 R1137.2 R1157.1 U43.16(RTS3#/JP9)
UART_RTS_P4_N: R1164.2 R1165.1 U128.18(IO11_B1)
UART_RTS_P4_R_N: R1164.1 U43.26(RTS4#)
UART_RTS_P5_L_N: J35.B52(GND53) U55.9(DOUT1)
UART_RTS_P5_N: U43.34(RTS5#/GP25) U55.14(DIN1)
UART_RTS_P6_L_N: J35.A52(HSIP8+) U56.9(DOUT1)
UART_RTS_P6_N: R1149.2 U43.85(RSMRST#/RTS6#/GP34/CIRRX1) U56.14(DIN1)
UART_RTS_RP5_L_N: J18.B19(HSOP1+) U57.9(DOUT1)
UART_RTS_RP6_L_N: J18.A18(GND4) U59.9(DOUT1)
UART_RX_P1: U43.125(SIN1) U51.19(ROUT1)
UART_RX_P1_L: J35.B62(HSOP11+) U51.4(RIN1)
UART_RX_P2: U43.6(SIN2) U52.19(ROUT1)
UART_RX_P2_L: J35.A62(GND24) U52.4(RIN1)
UART_RX_P3: J5.3 U43.19(SIN3#) U129.19(IO12_B1)
UART_RX_P4: U128.16(IO9_B1) U129.16(IO9_B1) U136.2(A)
UART_RX_P4_BUF: J6.3 U43.31(SIN4) U136.4(B)
UART_RX_P5: U43.48(SIN5/GP23) U55.19(ROUT1)
UART_RX_P5_L: J35.B54(HSOP9+) U55.4(RIN1)
UART_RX_P6: U43.93(VIN5/FAN_TAC3/SIN6/GP30) U56.19(ROUT1)
UART_RX_P6_L: J35.A54(GND20) U56.4(RIN1)
UART_RX_RP5_L: J18.B21(GND39) U57.4(RIN1)
UART_RX_RP6_L: J18.A20(GND5) U59.4(RIN1)
UART_SDC_RX: U73.10(TX) U128.21(IO14_B1)
UART_SDC_TX: U73.9(RX) U128.20(IO13_B1)
UART_SW_S0_N: D15.A R784.1 U73.1(GPIO0) U128.2(IO1_B1) U129.2(IO1_B1)
UART_SW_S1_N: D16.A R785.1 U73.2(GPIO1) U128.3(IO2_B1) U129.3(IO2_B1)
UART_SW_S2_N: D17.A R786.1 U73.5(GPIO2) U128.4(IO3_B1) U129.4(IO3_B1)
UART_SW_S3_N: D23.A R787.1 U73.6(GPIO3) U128.5(IO4_B1) U129.5(IO4_B1)
UART_SW_S4_N: D22.A R790.1 U73.15(GPIO4) U128.6(IO5_B1) U129.6(IO5_B1)
UART_SW_S5_N: D24.A R791.1 U73.14(GPIO5) U128.7(IO6_B1) U129.7(IO6_B1)
UART_T1_NODE1_RXD: C670.1 R907.1 U128.27(IO16_B1)
UART_T1_NODE1_RXD_R: J35.A42(GND15) R907.2
UART_T1_NODE1_TXD: R910.1 U128.26(IO15_B1)
UART_T1_NODE1_TXD_R: C673.1 J35.A43(HSIP6+) R910.2
UART_T1_NODE2_RXD: C676.1 R913.1 U128.29(IO18_B1)
UART_T1_NODE2_RXD_R: J35.A35(HSIP4+) R913.2
UART_T1_NODE2_TXD: R916.1 U128.28(IO17_B1)
UART_T1_NODE2_TXD_R: C679.1 J35.A36(HSIP4-) R916.2
UART_T1_NODE3_RXD: C682.1 R919.1 U128.34(IO21_B1)
UART_T1_NODE3_RXD_R: J35.A37(GND12) R919.2
UART_T1_NODE3_TXD: R922.1 U128.33(IO20_B1)
UART_T1_NODE3_TXD_R: C685.1 J35.A38(GND13) R922.2
UART_T1_NODE4_RXD: C688.1 R925.1 U128.36(IO23_B1)
UART_T1_NODE4_RXD_R: J35.A40(HSIP5-) R925.2
UART_T1_NODE4_TXD: R928.1 U128.35(IO22_B1)
UART_T1_NODE4_TXD_R: C691.1 J35.A41(GND14) R928.2
UART_T2_NODE1_RXD: C694.1 R931.1 U128.38(IO25_B1)
UART_T2_NODE1_RXD_R: J35.B32(GND44) R931.2
UART_T2_NODE1_TXD: R934.1 U128.37(IO24_B1)
UART_T2_NODE1_TXD_R: C697.1 J35.B33(HSOP4+) R934.2
UART_T2_NODE2_RXD: C700.1 R937.1 U128.40(IO27_B1)
UART_T2_NODE2_RXD_R: J35.B34(HSOP4-) R937.2
UART_T2_NODE2_TXD: R940.1 U128.39(IO26_B1)
UART_T2_NODE2_TXD_R: C703.1 J35.B35(GND45) R940.2
UART_T2_NODE3_RXD: C706.1 R943.1 U128.42(IO29_B1)
UART_T2_NODE3_RXD_R: J35.B37(HSOP5+) R943.2
UART_T2_NODE3_TXD: R946.1 U128.41(IO28_B1)
UART_T2_NODE3_TXD_R: C709.1 J35.B38(HSOP5-) R946.2
UART_T2_NODE4_RXD: C712.1 R949.1 U128.48(IO31_B1)
UART_T2_NODE4_RXD_R: J35.B39(GND47) R949.2
UART_T2_NODE4_TXD: R952.1 U128.47(IO30_B1)
UART_T2_NODE4_TXD_R: C715.1 J35.B40(GND48) R952.2
UART_T3_NODE1_RXD: C671.1 R908.1 U128.53(IO2_B2)
UART_T3_NODE1_RXD_R: J35.A20(GND5) R908.2
UART_T3_NODE1_TXD: R911.1 U128.52(IO1_B2)
UART_T3_NODE1_TXD_R: C674.1 J35.A21(HSIP1+) R911.2
UART_T3_NODE2_RXD: C677.1 R914.1 U128.55(IO4_B2)
UART_T3_NODE2_RXD_R: J35.A22(HSIP1-) R914.2
UART_T3_NODE2_TXD: R917.1 U128.54(IO3_B2)
UART_T3_NODE2_TXD_R: C680.1 J35.A23(GND6) R917.2
UART_T3_NODE3_RXD: C683.1 R920.1 U128.57(IO6_B2)
UART_T3_NODE3_RXD_R: J35.A25(HSIP2+) R920.2
UART_T3_NODE3_TXD: R923.1 U128.56(IO5_B2)
UART_T3_NODE3_TXD_R: C686.1 J35.A26(HSIP2-) R923.2
UART_T3_NODE4_RXD: C689.1 R926.1 U128.67(IO10_B2)
UART_T3_NODE4_RXD_R: J35.A27(GND8) R926.2
UART_T3_NODE4_TXD: R929.1 U128.66(IO9_B2)
UART_T3_NODE4_TXD_R: C692.1 J35.A28(GND9) R929.2
UART_T4_NODE1_RXD: C695.1 R932.1 U128.69(IO12_B2)
UART_T4_NODE1_RXD_R: J35.B17(PRSNT2_N-1) R932.2
UART_T4_NODE1_TXD: R935.1 U128.68(IO11_B2)
UART_T4_NODE1_TXD_R: C698.1 J35.B18(GND38) R935.2
UART_T4_NODE2_RXD: C701.1 R938.1 U128.71(IO14_B2)
UART_T4_NODE2_RXD_R: J35.B19(HSOP1+) R938.2
UART_T4_NODE2_TXD: R941.1 U128.70(IO13_B2)
UART_T4_NODE2_TXD_R: C704.1 J35.B20(HSOP1-) R941.2
UART_T4_NODE3_RXD: C707.1 R944.1 U128.73(IO16_B2)
UART_T4_NODE3_RXD_R: J35.B22(GND40) R944.2
UART_T4_NODE3_TXD: R947.1 U128.72(IO15_B2)
UART_T4_NODE3_TXD_R: C710.1 J35.B23(HSOP2+) R947.2
UART_T4_NODE4_RXD: C713.1 R950.1 U128.75(IO18_B2)
UART_T4_NODE4_RXD_R: J35.B24(HSOP2-) R950.2
UART_T4_NODE4_TXD: R953.1 U128.74(IO17_B2)
UART_T4_NODE4_TXD_R: C716.1 J35.B25(GND41) R953.2
UART_T5_NODE1_RXD: C672.1 R909.1 U128.77(IO20_B2)
UART_T5_NODE1_RXD_R: J35.A5(JTAG2) R909.2
UART_T5_NODE1_TXD: R912.1 U128.76(IO19_B2)
UART_T5_NODE1_TXD_R: C675.1 J35.A6(JTAG3) R912.2
UART_T5_NODE2_RXD: C678.1 R915.1 U128.82(IO23_B2)
UART_T5_NODE2_RXD_R: J35.A8(JTAG5) R915.2
UART_T5_NODE2_TXD: R918.1 U128.81(IO22_B2)
UART_T5_NODE2_TXD_R: C681.1 J35.A9(3.3V_1) R918.2
UART_T5_NODE3_RXD: C684.1 R921.1 U128.84(IO25_B2)
UART_T5_NODE3_RXD_R: J35.A10(3.3V_2) R921.2
UART_T5_NODE3_TXD: R924.1 U128.83(IO24_B2)
UART_T5_NODE3_TXD_R: C687.1 J35.A11(PWRGD) R924.2
UART_T5_NODE4_RXD: C690.1 R927.1 U128.86(IO27_B2)
UART_T5_NODE4_RXD_R: J35.A12(GND2) R927.2
UART_T5_NODE4_TXD: R930.1 U128.85(IO26_B2)
UART_T5_NODE4_TXD_R: C693.1 J35.A13(REFCLK+) R930.2
UART_T6_NODE1_RXD: C696.1 R933.1 U128.88(IO29_B2)
UART_T6_NODE1_RXD_R: J18.B81(PRSNT2_N-4) R933.2
UART_T6_NODE1_TXD: R936.1 U128.87(IO28_B2)
UART_T6_NODE1_TXD_R: C699.1 J18.B82(RSVD4) R936.2
UART_T6_NODE2_RXD: C702.1 R939.1 U128.90(IO31_B2)
UART_T6_NODE2_RXD_R: J35.B2(12V_4) R939.2
UART_T6_NODE2_TXD: R942.1 U128.89(IO30_B2)
UART_T6_NODE2_TXD_R: C705.1 J35.B3(RSVD1) R942.2
UART_T6_NODE3_RXD: C708.1 R945.1 U128.92(IO33_B2)
UART_T6_NODE3_RXD_R: J35.B5(SMCLK) R945.2
UART_T6_NODE3_TXD: R948.1 U128.91(IO32_B2)
UART_T6_NODE3_TXD_R: C711.1 J35.B6(SMDATA) R948.2
UART_T6_NODE4_RXD: C714.1 R951.1 U128.96(IO35_B2)
UART_T6_NODE4_RXD_R: J35.B7(GND35) R951.2
UART_T6_NODE4_TXD: R954.1 U128.95(IO34_B2)
UART_T6_NODE4_TXD_R: C717.1 J35.B8(3.3V_3) R954.2
UART_T7_NODE1_RXD: C718.1 R955.1 U129.27(IO16_B1)
UART_T7_NODE1_RXD_R: J18.A70(GND27) R955.2
UART_T7_NODE1_TXD: R958.1 U129.26(IO15_B1)
UART_T7_NODE1_TXD_R: C721.1 J18.A71(GND28) R958.2
UART_T7_NODE2_RXD: C724.1 R961.1 U129.29(IO18_B1)
UART_T7_NODE2_RXD_R: J18.A72(HSIP13+) R961.2
UART_T7_NODE2_TXD: R964.1 U129.28(IO17_B1)
UART_T7_NODE2_TXD_R: C727.1 J18.A73(HSIP13-) R964.2
UART_T7_NODE3_RXD: C730.1 R967.1 U129.34(IO21_B1)
UART_T7_NODE3_RXD_R: J18.A75(GND30) R967.2
UART_T7_NODE3_TXD: R970.1 U129.33(IO20_B1)
UART_T7_NODE3_TXD_R: C733.1 J18.A76(HSIP14) R970.2
UART_T7_NODE4_RXD: C736.1 R973.1 U129.36(IO23_B1)
UART_T7_NODE4_RXD_R: J18.A77(HSIP14-) R973.2
UART_T7_NODE4_TXD: R976.1 U129.35(IO22_B1)
UART_T7_NODE4_TXD_R: C739.1 J18.A78(GND31) R976.2
UART_T8_NODE1_RXD: C742.1 R979.1 U129.38(IO25_B1)
UART_T8_NODE1_RXD_R: J18.B66(HSOP12+) R979.2
UART_T8_NODE1_TXD: R982.1 U129.37(IO24_B1)
UART_T8_NODE1_TXD_R: C745.1 J18.B67(HSOP12-) R982.2
UART_T8_NODE2_RXD: C748.1 R985.1 U129.40(IO27_B1)
UART_T8_NODE2_RXD_R: J18.B68(GND61) R985.2
UART_T8_NODE2_TXD: R988.1 U129.39(IO26_B1)
UART_T8_NODE2_TXD_R: C751.1 J18.B69(GND62) R988.2
UART_T8_NODE3_RXD: C754.1 R991.1 U129.42(IO29_B1)
UART_T8_NODE3_RXD_R: J18.B71(HSOP13-) R991.2
UART_T8_NODE3_TXD: R994.1 U129.41(IO28_B1)
UART_T8_NODE3_TXD_R: C757.1 J18.B72(GND63) R994.2
UART_T8_NODE4_RXD: C760.1 R997.1 U129.48(IO31_B1)
UART_T8_NODE4_RXD_R: J18.B73(GND64) R997.2
UART_T8_NODE4_TXD: R1000.1 U129.47(IO30_B1)
UART_T8_NODE4_TXD_R: C763.1 J18.B74(HSOP14+) R1000.2
UART_T9_NODE1_RXD: C719.1 R956.1 U129.53(IO2_B2)
UART_T9_NODE1_RXD_R: J18.A55(GND21) R956.2
UART_T9_NODE1_TXD: R959.1 U129.52(IO1_B2)
UART_T9_NODE1_TXD_R: C722.1 J18.A56(HSIP9+) R959.2
UART_T9_NODE2_RXD: C725.1 R962.1 U129.55(IO4_B2)
UART_T9_NODE2_RXD_R: J18.A57(HSIP9-) R962.2
UART_T9_NODE2_TXD: R965.1 U129.54(IO3_B2)
UART_T9_NODE2_TXD_R: C728.1 J18.A58(GND22) R965.2
UART_T9_NODE3_RXD: C731.1 R968.1 U129.57(IO6_B2)
UART_T9_NODE3_RXD_R: J18.A60(HSIP10+) R968.2
UART_T9_NODE3_TXD: R971.1 U129.56(IO5_B2)
UART_T9_NODE3_TXD_R: C734.1 J18.A61(HSIP10-) R971.2
UART_T9_NODE4_RXD: C737.1 R974.1 U129.67(IO10_B2)
UART_T9_NODE4_RXD_R: J18.A62(GND24) R974.2
UART_T9_NODE4_TXD: R977.1 U129.66(IO9_B2)
UART_T9_NODE4_TXD_R: C740.1 J18.A63(GND25) R977.2
UART_T10_NODE1_RXD: C743.1 R980.1 U129.69(IO12_B2)
UART_T10_NODE1_RXD_R: J18.B51(HSOP8-) R980.2
UART_T10_NODE1_TXD: R983.1 U129.68(IO11_B2)
UART_T10_NODE1_TXD_R: C746.1 J18.B52(GND53) R983.2
UART_T10_NODE2_RXD: C749.1 R986.1 U129.71(IO14_B2)
UART_T10_NODE2_RXD_R: J18.B53(GND54) R986.2
UART_T10_NODE2_TXD: R989.1 U129.70(IO13_B2)
UART_T10_NODE2_TXD_R: C752.1 J18.B54(HSOP9+) R989.2
UART_T10_NODE3_RXD: C755.1 R992.1 U129.73(IO16_B2)
UART_T10_NODE3_RXD_R: J18.B56(GND55) R992.2
UART_T10_NODE3_TXD: R995.1 U129.72(IO15_B2)
UART_T10_NODE3_TXD_R: C758.1 J18.B57(GND56) R995.2
UART_T10_NODE4_RXD: C761.1 R998.1 U129.75(IO18_B2)
UART_T10_NODE4_RXD_R: J18.B58(HSOP10+) R998.2
UART_T10_NODE4_TXD: R1001.1 U129.74(IO17_B2)
UART_T10_NODE4_TXD_R: C764.1 J18.B59(HSOP10-) R1001.2
UART_T11_NODE1_RXD: C720.1 R957.1 U129.77(IO20_B2)
UART_T11_NODE1_RXD_R: J18.A40(HSIP5-) R957.2
UART_T11_NODE1_TXD: R960.1 U129.76(IO19_B2)
UART_T11_NODE1_TXD_R: C723.1 J18.A41(GND14) R960.2
UART_T11_NODE2_RXD: C726.1 R963.1 U129.82(IO23_B2)
UART_T11_NODE2_RXD_R: J18.A42(GND15) R963.2
UART_T11_NODE2_TXD: R966.1 U129.81(IO22_B2)
UART_T11_NODE2_TXD_R: C729.1 J18.A43(HSIP6+) R966.2
UART_T11_NODE3_RXD: C732.1 R969.1 U129.84(IO25_B2)
UART_T11_NODE3_RXD_R: J18.A45(GND16) R969.2
UART_T11_NODE3_TXD: R972.1 U129.83(IO24_B2)
UART_T11_NODE3_TXD_R: C735.1 J18.A46(GND17) R972.2
UART_T11_NODE4_RXD: C738.1 R975.1 U129.86(IO27_B2)
UART_T11_NODE4_RXD_R: J18.A47(HSIP7+) R975.2
UART_T11_NODE4_TXD: R978.1 U129.85(IO26_B2)
UART_T11_NODE4_TXD_R: C741.1 J18.A48(HSIP7-) R978.2
UART_T12_NODE1_RXD: C744.1 R981.1 U129.88(IO29_B2)
UART_T12_NODE1_RXD_R: J18.B36(GND46) R981.2
UART_T12_NODE1_TXD: R984.1 U129.87(IO28_B2)
UART_T12_NODE1_TXD_R: C747.1 J18.B37(HSOP5+) R984.2
UART_T12_NODE2_RXD: C750.1 R987.1 U129.90(IO31_B2)
UART_T12_NODE2_RXD_R: J18.B38(HSOP5-) R987.2
UART_T12_NODE2_TXD: R990.1 U129.89(IO30_B2)
UART_T12_NODE2_TXD_R: C753.1 J18.B39(GND47) R990.2
UART_T12_NODE3_RXD: C756.1 R993.1 U129.92(IO33_B2)
UART_T12_NODE3_RXD_R: J18.B41(HSOP6+) R993.2
UART_T12_NODE3_TXD: R996.1 U129.91(IO32_B2)
UART_T12_NODE3_TXD_R: C759.1 J18.B42(HSOP6-) R996.2
UART_T12_NODE4_RXD: C762.1 R999.1 U129.96(IO35_B2)
UART_T12_NODE4_RXD_R: J18.B43(GND49) R999.2
UART_T12_NODE4_TXD: R1002.1 U129.95(IO34_B2)
UART_T12_NODE4_TXD_R: C765.1 J18.B44(GND50) R1002.2
UART_TX_P1: R1009.2 R1010.2 U43.124(SOUT1/JP3) U51.13(DIN2)
UART_TX_P1_L: J35.B63(HSOP11-) U51.10(DOUT2)
UART_TX_P2: R1020.2 R1024.2 U43.5(SOUT2/JP6) U52.13(DIN2)
UART_TX_P2_L: J35.A63(GND25) U52.10(DOUT2)
UART_TX_P3: J5.2 R1159.2 R1160.1 U129.18(IO11_B1)
UART_TX_P3_R: R1134.2 R1135.2 R1159.1 U43.18(SOUT3#/JP8)
UART_TX_P4: J6.2 U128.15(IO8_B1) U129.15(IO8_B1) U135.4(B)
UART_TX_P4_BUF: R1161.2 R1162.1 U135.2(A)
UART_TX_P4_R: R1161.1 U43.28(SOUT4)
UART_TX_P5: U43.66(SOUT5/GP22) U55.13(DIN2)
UART_TX_P5_L: J35.B55(HSOP9-) U55.10(DOUT2)
UART_TX_P6: U43.77(SUSC#/SOUT6/GP35) U56.13(DIN2)
UART_TX_P6_L: J35.A55(GND21) U56.10(DOUT2)
UART_TX_RP5_L: J18.B22(GND40) U57.10(DOUT2)
UART_TX_RP6_L: J18.A21(HSIP1+) U59.10(DOUT2)
USB0_DN: L42.1 R265.2 U32.42(U2DM1)
USB0_DP: L42.4 R264.2 U32.41(U2DP1)
USB0_L_DN: J14.2(D-_1) L42.2 R265.1 U53.6(ESD_P4)
USB0_L_DP: J14.3(D+_1) L42.3 R264.1 U53.4(ESD_P3)
USB1_DN: L43.1 R267.2 U32.51(U2DM2)
USB1_DP: L43.4 R266.2 U32.50(U2DP2)
USB1_L_DN: J14.6(D-_2) L43.2 R267.1 U53.1(ESD_P1)
USB1_L_DP: J14.7(D+_2) L43.3 R266.1 U53.3(ESD_P2)
USB2_DN: L44.1 R269.2 U32.59(U2DM3)
USB2_DP: L44.4 R268.2 U32.58(U2DP3)
USB2_L_DN: J15.2(D-_1) L44.2 R269.1 U54.6(ESD_P4)
USB2_L_DP: J15.3(D+_1) L44.3 R268.1 U54.4(ESD_P3)
USB3_DN: L45.1 R271.2 U32.68(U2DM4)
USB3_DP: L45.4 R270.2 U32.67(U2DP4)
USB3_L_DN: J15.6(D-_2) L45.2 R271.1 U54.1(ESD_P1)
USB3_L_DP: J15.7(D+_2) L45.3 R270.1 U54.3(ESD_P2)
USB_NODE1_PECREQ_L: R533.2 U32.13(PECREQB)
USB_NODE1_RREF: R526.1 U32.33(RREF)
USB_NODE1_SMI_L: R525.2 U2.G62(GPIOCORE12) U32.1(SMIB)
USB_NODE1_XTA1: C365.1 U32.31(XT1) Y3.2
USB_NODE1_XTA2: C366.1 U32.30(XT2) Y3.1
USB_OC_PU: R532.1 U32.20(OCI4B) U32.22(OCI3B) U32.24(OCI2B) U32.26(OCI1B)
USB_WAKE_N: R520.2 R534.2 U32.3(PEWAKEB)
USBPWR_P0: C557.1 C558.1 CE2.1 D9.C FS3.2 J14.1(VBUS1) J14.5(VBUS2) U53.5(VP)
USBPWR_P1: C560.1 C561.1 CE3.1 D10.C FS4.2 J15.1(VBUS1) J15.5(VBUS2) U54.5(VP)
VGA_HSYNC: R638.1 U132.3(Y2)
VGA_VSYNC: R637.1 U132.6(Y1)
VR_CPU_NODE1_INTVRMEN: R163.1 R166.1 U2.J64(RTC_INTVRMEN)
VR_HSC_NODE1_GATE: Q22.4 R1021.2
VR_HSC_NODE1_GATE_R: C779.1 R1021.1 U100.9(GATE)
VR_HSC_NODE1_TIMER: C780.1 U100.5(TIMER)
VR_NODE1_VDDR_1V5_CNTL: Q43.1(G) R77.2 U2.L59(GPIOSUS1)
VR_PVCCP_NODE1_BOOT1: PC96.1 PU8.1(BOOT1)
VR_PVCCP_NODE1_COMP: PC102.1 PC108.1 PR68.1 PU8.5(COMP)
VR_PVCCP_NODE1_COMP_RC: PC102.2 PR66.1
VR_PVCCP_NODE1_EN: PC122.1 PJ16.2 PR79.2 PU8.32(EN)
VR_PVCCP_NODE1_FB: PC110.2 PR66.2 PR67.1 PR68.2 PR69.1 PU8.6(FB)
VR_PVCCP_NODE1_FB_RC: PC103.1 PR67.2
VR_PVCCP_NODE1_FB_RR: PR69.2 PR70.1
VR_PVCCP_NODE1_IBIAS: PC115.1 PR78.2 PU8.19(IBIAS)
VR_PVCCP_NODE1_ICCMAX: PR64.2 PR65.2 PU8.13(ICCMAX)
VR_PVCCP_NODE1_ISEN1P_CC: PC98.1 PR55.1 PR58.1 PU8.3(ISEN1P)
VR_PVCCP_NODE1_ISEN1P_RR: PR56.1 PR58.2 PR59.1
VR_PVCCP_NODE1_LGATE1: PR53.1 PU8.38(LGATE1) U124.8(G2)
VR_PVCCP_NODE1_OCSET: PR76.2 PR77.2 PU8.16(OCSET)
VR_PVCCP_NODE1_PHASE1: PC96.2 PL8.2A PR51.1 PU8.39(PHASE1) U124.S1/D2_EP(S1/D2)
VR_PVCCP_NODE1_PVCC: PC88.1 PR48.1 PU8.37(PVCC)
VR_PVCCP_NODE1_RGND: PC109.1 PJ15.1 PU8.7(RGND)
VR_PVCCP_NODE1_SETINI: PR57.2 PR60.2 PU8.11(SETINI)
VR_PVCCP_NODE1_TEMPMAX: PR61.2 PR62.2 PU8.12(TMPMAX)
VR_PVCCP_NODE1_TONSET: PR42.1 PU8.2(TONSET)
VR_PVCCP_NODE1_TONSET_R: PC95.1 PR42.2 PR43.1
VR_PVCCP_NODE1_TSEN: PC111.2 PR73.2 PR74.1 PU8.15(TSEN)
VR_PVCCP_NODE1_TSEN_R: PR72.2 PR73.1 PR75.2
VR_PVCCP_NODE1_UGATE1: PR51.2 PU8.40(UGATE1) U124.1(G1)
VR_PVCCP_NODE1_VCC: PC87.1 PR41.2 PR57.1 PR61.1 PR64.1 PR72.1 PR75.1 PR76.1 PU8.9(VCC) PU8.17(TSENA)
VR_PVCCP_NODE1_VSEN: PC103.2 PC109.2 PJ14.1 PR70.2
VSENSE_HSC_NODE1: Q22.5 R1019.2 U100.2(SENSE)
VSENSE_P1V05_NODE1_N: PC65.1 PJ7.2 PR27.2 PU6.3(GSNS)
VSENSE_P1V05_NODE1_P: PJ8.2 PR29.1 PR30.2
VSENSE_PV_VDDR_NODE1_N: PJ11.1 PR34.1 PU7.1(GSNS)
VSENSE_PV_VDDR_NODE1_P: PJ12.1 PR35.1 PU7.20(VSNS)
VSENSE_VCC_CPU_NODE1: PC104.2 PJ14.2 PR63.1 U2.AD41(VCCCPU0SENSE)
VSENSE_VSS_CPU_NODE1: PC104.1 PJ15.2 PR71.1 U2.AF41(VSSCPU0SENSE)
WDT_LED: D25.A U128.30(IO19_B1)
XDP_CPU_NODE1_PG_RST_R: J3.41 R220.2 R222.1
XDP_CPU_NODE1_PRDY_L: J3.5 R114.1 U2.AC52(CPU_PRDY#)
XDP_CPU_NODE1_PREQ_L: J3.3 R113.1 U2.AE62(CPU_PREQ#)
XDP_CPU_NODE1_PWROK: R219.2 U102.A2(IO_03)
XDP_CPU_NODE1_PWROK_R: J3.39 R219.1
XDP_CPU_NODE1_PWROK_STALL_L: C184.2 J3.47 R226.2 R227.1 U102.H7(IO_60)
XDP_CPU_NODE1_VISA0: J3.4 U2.AT53(PSMI_VISA0)
XDP_CPU_NODE1_VISA1: J3.9 U2.AR53(PSMI_VISA1)
XDP_CPU_NODE1_VISA2: J3.11 U2.AT59(PSMI_VISA2)
XDP_CPU_NODE1_VISA3: J3.15 U2.AT54(PSMI_VISA3)
XDP_CPU_NODE1_VISA4: J3.17 U2.AR54(PSMI_VISA4)
XDP_CPU_NODE1_VISA5: J3.27 U2.AT60(PSMI_VISA5)
XDP_CPU_NODE1_VISA6: J3.29 U2.AT57(PSMI_VISA6)
XDP_CPU_NODE1_VISA7: J3.33 U2.AR57(PSMI_VISA7)
XDP_CPU_NODE1_VISA8: J3.35 U2.AR60(PSMI_VISA8)
XDP_CPU_NODE1_VISA9: J3.6 U2.AM53(PSMI_VISA9)
XDP_CPU_NODE1_VISA10: J3.10 U2.AM52(PSMI_VISA10)
XDP_CPU_NODE1_VISA11: J3.12 U2.AR59(PSMI_VISA11)
XDP_CPU_NODE1_VISA12: J3.16 U2.AM58(PSMI_VISA12)
XDP_CPU_NODE1_VISA13: J3.18 U2.AM56(PSMI_VISA13)
XDP_CPU_NODE1_VISA14: J3.28 U2.AW56(PSMI_VISA14)
XDP_CPU_NODE1_VISA15: J3.30 U2.AL53(PSMI_VISA15)
XDP_CPU_NODE1_VISA16: J3.34 U2.AL52(PSMI_VISA16)
XDP_CPU_NODE1_VISA17: J3.36 U2.AW58(PSMI_VISA17)
XDP_NODE1_P60: J3.60 R225.1
XDP_SOC_CPU_NODE1_TCK: J3.57 R78.1 U2.AD62(SOC_TCK)
XDP_SOC_CPU_NODE1_TDI: J3.56 R76.2 U2.AA66(SOC_TDI)
XDP_SOC_CPU_NODE1_TDO: J3.52 R228.1 U2.AA64(SOC_TDO)
XDP_SOC_CPU_NODE1_TMS: J3.58 R74.2 U2.AD63(SOC_TMS)
XDP_SOC_CPU_NODE1_TRST_L: J3.54 R229.2 U2.AA62(SOC_TRST#)
XTAL_CLK_NODE1_X1: C12.1 R4.1 U1.2(X1) Y1.1(IN)
XTAL_CLK_NODE1_X2: C13.1 R4.2 U1.1(X2) Y1.3(OUT)
XTAL_CPU_NODE1_X1PAD: C24.1 R64.1 U2.R65(RTC_X1PAD) Y2.2
XTAL_CPU_NODE1_X2PAD: C25.1 R64.2 U2.N65(RTC_X2PAD) Y2.1
N20512383: J1.13 R194.2
N20512395: J1.1 R193.2
N20822523: R293.1 U14.E4(ENTEST1)
N21116716: R653.2 U31.3(WP#) U31.7(HOLD#)
N21311590: TP1.1 U35.45(ATESTP)
N21311592: TP2.1 U35.46(ATESTN)
N21357353: TP3.1 U37.45(ATESTP)
N21357373: TP4.1 U37.46(ATESTN)
N21550241: OSC4.1(OE) R619.2
N21581283: Q17.G(GATE) Q18.G(GATE) R631.2
N21581564: CD1.2 FS2.2
N21624804: R649.2 U51.23(FORCEON)
N21624806: R650.2 U51.22(FORCEOFF#)
N21624848: C533.1 U51.28(C1+)
N21624850: C533.2 U51.24(C1-)
N21624861: C534.1 U51.1(C2+)
N21624866: C534.2 U51.2(C2-)
N21624890: C531.2 U51.27(V+)
N21624894: C532.2 U51.3(V-)
N21698757: R743.2 U66.2(A1)
N21698906: R739.1 R754.1 U67.3(A2)
N21698939: R738.1 R753.1 U67.2(A1)
N21698959: R750.1 U66.3(A2) U66.21(A0)
N21698979: R704.2 U65.21(A0)
N21699069: R682.2 U60.15(EN4)
N21699285: R685.2 U62.1(I\N\T\)
N21699372: R706.2 U64.21(A0)
N21699571: R702.2 U64.1(I\N\T\)
N21699606: R719.1 U65.2(A1)
N21699710: R688.1 U63.2(A1) U63.21(A0)
N21699716: R718.1 U64.2(A1) U64.3(A2)
N21700156: R734.2 U66.1(I\N\T\)
N21700864: R686.2 U63.3(A2)
N21700927: R687.1 U62.2(A1) U62.3(A2) U62.21(A0)
N21700941: R737.1 R752.1 U67.1(A0)
N21700943: R735.1 R751.1 U67.7(WP)
N21701261: R708.2 U65.3(A2)
N21701263: R701.2 U65.1(I\N\T\)
N29180194: C14.1 R27.2 R31.1 U2.BH41(DDR3_VREF)
N31328106: D15.C R796.1
N31328107: D17.C R798.1
N31328108: D16.C R797.1
N31341801: D22.C R1048.1
N31341803: D23.C R805.1
N31348569: D24.C R1058.1
N31521709: OSC6.1(NC/I\N\H\) R1057.2
N31521711: OSC6.3(OUT) R1055.1
N32265582: C32.1 R143.1 U2.R62(RTCRESET#)
N34379705: R273.2 R274.2 U32.2(PERSTB)
N37284163: R656.2 U51.7(RIN4) U51.8(RIN5)
N41777073: Q41.E(2) R93.2
N41777080: Q41.B(1) R1122.1
N43448372: R1151.1 U134.7(WP)
N45787194: Q42.B(1) R1215.1
N46114787: L20.2 OSC4.4(VDD)
N47241340: C852.1 PJ3.2 R1105.2 U130.6(EN)
N49382752: R1226.2 U13.1(A0) U13.2(A1) U13.3(A2)
N52410978: C887.2 R802.1 U107.D(DRAIN) U108.G(GATE)
N52410998: C886.2 R800.1 U104.D(DRAIN) U105.G(GATE)
N52411040: R655.1 R1127.2 U105.D(DRAIN)
N52411069: Q44.1(B) R1127.1
N52411102: Q44.2(E) R1129.2
N52411159: Q45.2(E) R1130.2
N52411212: R657.1 R1128.2 U108.D(DRAIN)
N52411214: Q45.1(B) R1128.1
N52998261: C934.2 R1059.1 U110.D(DRAIN) U111.G(GATE)
N52998325: Q46.2(E) R1249.2
N52998343: R1039.1 R1250.2 U111.D(DRAIN)
N52998345: Q46.1(B) R1250.1
N53103066: R1070.1 U114.G(GATE)
N53313175: TP175.1 U115.11(TCK)
N53313289: TP173.1 U115.25(TMS)
N53313325: TP174.1 U115.1(TDI)
N53313389: TP172.1 U115.35(TDO)
N53313464: D32.C R1253.2
N53313479: D33.C R1254.2
N53313501: D34.C R1255.2
N53313513: D35.C R1256.2
N53313558: D36.C R1258.2
N53313577: D37.C R1257.2
N53313596: D38.C R1259.2
N53313646: D31.C R1260.2
N53608934: D18.2(C) R808.1
N53608970: D19.2(C) R813.1
