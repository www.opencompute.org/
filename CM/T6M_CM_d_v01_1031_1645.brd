# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
P1V05_SUS_NODE1 on IN2 (solid shape): outline of 4092 points within 75.46,76.07 107.28,114.33
P1V5_SUS_NODE1 on IN2 (solid shape): outline of 5203 points within 43.84,62.33 66.62,103.65
P1V5_SUS_NODE1_ADJ on TOP (solid shape): 48.25,104.67 48.25,103.28 48.23,103.26 47.18,103.26 46.83,103.6 44.95,103.6 44.91,103.64 44.91,103.87 46.42,103.87 46.68,104.13 47.49,104.13 47.62,104.26 47.62,104.59 47.8,104.78 48.14,104.78
P1V05_SUS_NODE1_ADJ on TOP (solid shape): 106.86,140.39 106.95,140.35 106.99,140.26 106.99,138.11 106.97,138.09 106.97,137.12 106.99,137.1 106.99,137.02 106.68,137.02 106.28,137.42 106.28,137.49 106.42,137.63 106.42,139.11 106.21,139.33 106.14,139.33 105.62,139.85 105.62,140.26 105.66,140.35 105.75,140.39
P1V05_SUS_NODE1_ADJ_S on TOP (solid shape): 109.04,139.82 109.04,138.57 109,138.53 107.41,138.53 107.26,138.68 107.26,140.42 107.29,140.51 107.38,140.54 108.32,140.54
P1V05_VCCPLLCPU0SIO_NODE1 on TOP (solid shape): 99.69,78.23 99.69,75.72 99.51,75.54 97.7,75.54 97.6,75.63 97.6,78.42 97.71,78.53 97.76,78.56 97.81,78.56 97.94,78.58 98.07,78.65 98.1,78.67 99.25,78.67
P1V05_VCCPLLCPU1SIO_NODE1 on TOP (solid shape): 99.35,82.09 99.38,82.05 99.39,82 99.39,79.24 99.24,79.09 98.23,79.09 98.17,79.12 98.15,79.15 97.96,79.3 97.71,79.31 97.61,79.33 97.51,79.33 97.42,79.43 97.38,79.55 97.38,82.08 97.39,82.13 97.42,82.17 97.54,82.29 98.44,82.29 98.56,82.31 99.13,82.31
P1V8_NODE1 on TOP (solid shape): 43.27,125.69 43.27,122.57 43.13,122.43 41.48,122.43 41.01,122.9 41.01,124.1 41.58,124.67 41.87,124.67 42.03,124.82 42.03,125.69 42.04,125.7 43.27,125.7
P1V8_NODE1 on TOP (solid shape): 96.87,145.85 96.87,143.74 96.61,143.49 96.61,142.42 96.6,142.41 95.35,142.41 95.34,142.42 95.34,143.74 95.06,144.02 95.06,145.95 95.14,146.03 96.69,146.03
P1V8_NODE1 on TOP (solid shape): 149.15,66.15 149.15,65.51 148.52,64.88 148.52,63.56 148.52,63.56 148.52,63.45 148.31,63.25 147.42,63.25 147.42,63.25 147.33,63.25 146.87,63.71 146.87,66.02 147.12,66.27 149.02,66.27
P1V8_NODE1 on TOP (solid shape): 83.11,114.16 86.96,114.16 87.3,113.82 87.3,112.26 86.58,111.54 80.97,111.54 80.96,111.53 80.58,111.53 80.56,111.55 80.56,113.86 80.84,114.14 81.15,114.14 81.18,114.17 83.1,114.17
P1V8_NODE1 on TOP (solid shape): 179.03,78.4 179.7,78.4 179.95,78.15 179.95,75.24 179.9,75.19 179.15,75.19 177.59,76.75 176.32,76.75 176.31,76.76 176.31,76.96 176.32,76.97 176.32,77.9 176.38,77.96 177.48,77.96 177.78,78.27 177.81,78.28 177.9,78.32 177.97,78.37 178.01,78.4 178.06,78.4 179.03,78.4
P1V8_NODE1 on TOP (solid shape): outline of 673 points within 123.02,77.7 147.28,102.98
P1V8_NODE1 on BOTTOM (solid shape): 179.93,78.12 179.93,75.54 179.7,75.31 178.56,75.31 177.95,75.92 176.74,75.92 176.49,76.17 176.49,78.32 176.64,78.47 179.58,78.47
P1V8_NODE1 on BOTTOM (solid shape): 159.09,75.13 159.18,75.09 159.22,75 159.22,74.37 159.12,74.27 158.11,74.27 157.89,74.5 157.89,74.94 157.91,75.02 157.99,75.06 158.31,75.13
P1V8_NODE1 on BOTTOM (solid shape): 170.83,68.38 170.83,60.84 170.38,60.39 168.15,60.39 167.37,61.16 167.37,61.82 167.47,61.92 169.38,61.92 169.51,62.05 169.51,63.27 169.28,63.5 167.58,63.5 167.4,63.68 167.4,64.74 167.47,64.82 169.33,64.82 169.43,64.92 169.43,66.42 169.43,67.06 169.43,67.31 169.38,67.36 167.4,67.36 167.25,67.51 167.25,68.53 167.5,68.78 170.42,68.78
P1V8_NODE1 on BOTTOM (solid shape): 67.15,98.8 67.34,98.84 67.42,98.83 67.48,98.75 67.48,96.95 67.42,96.89 66.66,96.89 66.57,96.92 66.53,97.01 66.54,97.1 66.54,97.3 66.73,97.49 66.87,97.76 66.82,98.05 66.8,98.21 66.88,98.36 66.99,98.48 67.04,98.63
P1V8_NODE1 on BOTTOM (solid shape): 66.73,87.91 66.82,87.88 66.85,87.79 66.85,86.46 66.84,86.43 66.79,86.28 66.81,86.12 66.81,86.1 66.81,85.48 66.8,85.4 66.81,85.31 66.81,84.72 66.8,84.63 66.81,84.55 66.81,84.46 66.82,84.45 66.82,84.4 66.95,84.27 67.07,84.27 67.08,84.27 67.18,84.25 67.28,84.27 67.3,84.27 67.43,84.27 67.44,84.28 68.48,84.28 68.5,84.27 68.65,84.24 68.8,84.27 68.83,84.28 69.29,84.28 69.44,84.13 69.44,82.83 69.52,82.76 69.52,81.88 69.41,81.77 68.95,81.77 68.85,81.87 68.85,82.74 68.71,82.87 67.77,82.87 67.72,82.88 67.68,82.91 67.62,82.97 67.62,83.31 67.58,83.35 67.55,83.4 67.54,83.44 67.54,83.49 67.49,83.55 66.72,83.55 66.7,83.55 65.73,83.55 65.58,83.69 65.58,85.33 65.38,85.53 64.54,85.53 64.53,85.54 64.44,85.54 64.35,85.54 64.33,85.53 63.99,85.53 63.6,85.92 63.6,87.48 64.04,87.91
P1V8_NODE1 on BOTTOM (solid shape): outline of 167 points within 63.83,96.89 67.48,102.53
P1V8_NODE1 on BOTTOM (solid shape): outline of 470 points within 94.27,112.04 102.23,131.26
P1V8_NODE1 on BOTTOM (solid shape): outline of 1674 points within 40.27,111.88 89.21,125.21
P1V8_NODE1 on IN1 (solid shape): outline of 1539 points within 109.65,101.48 127.96,124.58
P1V8_NODE1 on IN1 (solid shape): outline of 3663 points within 60.87,79.91 102.22,145.67
P1V8_NODE1 on IN2 (solid shape): 96.77,113.94 96.77,112.52 95.86,111.61 92.48,111.61 92.45,111.62 92.28,111.66 92.11,111.62 92.08,111.61 86.28,111.61 85.91,111.97 80.69,111.97 80.48,112.18 80.48,113.72 80.53,113.76 94.36,113.76 94.53,113.93 94.69,113.93 95.16,114.41 96.31,114.41
P1V8_NODE1 on IN2 (solid shape): outline of 703 points within 100.03,120.36 112.56,131.2
P1V8_NODE1 on IN3 (solid shape): outline of 745 points within 99.32,119.79 112.02,131.1
P1V8_NODE1 on IN3 (solid shape): outline of 1955 points within 46.52,74.04 70.75,102.55
P1V8_NODE1 on IN3 (solid shape): outline of 3869 points within 141.1,59.82 184.13,82.57
P1V8_SATA_AVDD_NODE1 on BOTTOM (solid shape): 160.26,75.13 160.35,75.09 160.39,75 160.39,72.08 160.46,72.01 161.1,72.01 161.3,71.8 161.3,71.32 161.15,71.17 160.51,71.17 160.39,71.04 160.39,69.85 160.08,69.54 159.63,69.54 159.5,69.67 159.5,75 159.54,75.09 159.63,75.13
P1V8_SATA_VAA1_NODE1 on BOTTOM (solid shape): 162.67,67.05 162.74,67.02 162.81,66.99 162.99,66.98 163.16,67.05 163.2,67.08 169.05,67.08 169.18,66.95 169.18,66.52 168.97,66.32 162.65,66.32 162.42,66.55 162.42,66.98 162.52,67.08 162.64,67.08
P1V8_SATA_VAA2_0_NODE1 on BOTTOM (solid shape): 169.14,65.67 169.14,65.19 169.07,65.12 163.18,65.12 163.03,64.97 162.75,64.97 162.57,65.15 162.57,65.63 162.7,65.76 169.05,65.76
P1V8_SATA_VAA2_1_NODE1 on BOTTOM (solid shape): 169.23,62.91 169.23,62.33 169.15,62.25 162.57,62.25 162.37,62.46 162.37,62.91 162.47,63.02 169.12,63.02
P1V8_STB_NODE1 on TOP (solid shape): 42.71,103.81 42.71,102.63 42.71,102.63 40.68,102.63 40.57,102.74 40.57,103.69 40.71,103.84 42.69,103.84
P1V8_STB_NODE1 on TOP (solid shape): 105,158.52 105,151.76 104.9,151.66 100.45,151.66 100.3,151.81 100.3,158.45 100.58,158.73 104.79,158.73
P1V8_STB_NODE1 on TOP (solid shape): 77.35,103.33 77.35,100.62 77.22,100.49 73.98,100.49 73.69,100.78 73.69,103.22 73.73,103.31 73.82,103.35 77.34,103.35
P1V8_STB_NODE1 on TOP (solid shape): 83.94,110.61 83.94,106.11 83.55,105.72 80.75,105.72 80.32,106.15 80.32,107.1 79.43,107.99 79.43,110.68 79.74,110.99 83.57,110.99
P1V8_STB_NODE1 on TOP (solid shape): 107.99,133.56 107.99,132.47 107.99,132.47 107.99,132.13 108.01,132.11 108.01,130.27 107.9,130.16 106.48,130.16 106.42,130.21 106.42,132.04 106.75,132.36 106.75,132.46 106.75,132.47 106.75,133.14 106.75,133.21 106.75,133.44 106.78,133.53 106.87,133.57 107.99,133.57
P1V8_STB_NODE1 on BOTTOM (solid shape): 42.94,104.63 42.94,101.69 42.75,101.51 40.88,101.51 40.69,101.6 40.63,101.81 40.6,102.04 40.44,102.21 40.4,102.25 40.38,102.32 40.38,104.29 40.73,104.64 42.92,104.64
P1V8_STB_NODE1 on BOTTOM (solid shape): outline of 1517 points within 78.38,106.06 105,158.73
P1V8_STB_NODE1 on IN1 (solid shape): outline of 183 points within 74.07,101.9 87.68,108.78
P1V8_STB_NODE1 on VCC2 (solid shape): 107.75,158.64 107.84,158.61 107.88,158.52 107.88,148.04 108.72,147.2 108.72,129.84 107.4,128.52 101.9,128.52 101.81,128.53 101.73,128.52 100.24,128.52 91.97,120.25 91.97,120.12 91.95,120.1 91.91,119.92 91.95,119.75 91.97,119.72 91.97,111.5 91.95,111.47 91.9,111.28 91.95,111.09 91.97,111.06 91.97,106.92 90.13,105.09 79.92,105.09 79.4,105.61 79.4,110.32 79.99,110.91 82.32,110.91 83.01,111.6 83.01,112.59 83.05,112.66 83.09,112.67 83.31,113.02 83.09,113.36 83.03,113.41 83.01,113.48 83.01,117.65 83.05,117.71 83.08,117.72 83.28,118.06 83.08,118.39 83.05,118.41 83.01,118.47 83.01,123.5 85.02,125.51 85.07,125.54 85.13,125.54 85.44,125.64 85.54,125.95 85.54,126.01 85.57,126.06 86.38,126.87 90.79,126.87 100.72,136.79 100.72,146.02 100.63,146.12 100.63,158.35 100.93,158.64
P1V8_STB_NODE1 on IN2 (solid shape): outline of 1682 points within 39.25,101.71 84.68,108.52
P1V8_SUS_NODE1 on TOP (solid shape): 74.75,99.96 74.84,99.92 74.88,99.83 74.88,99.35 74.95,99.28 75.13,99.28 75.18,99.32 75.18,99.83 75.21,99.92 75.3,99.96 75.39,99.96 75.48,99.92 75.52,99.83 75.52,99.44 75.59,99.37 75.79,99.37 75.82,99.4 75.82,99.83 75.86,99.92 75.95,99.96 76.14,99.96 76.23,99.87 76.23,98.31 76.1,98.18 75.88,98.18 75.86,98.19 75.7,98.22 75.54,98.19 75.52,98.18 75.13,98.18 75.05,98.1 75.05,97.77 74.87,97.58 74.54,97.58 74.53,97.58 74.05,97.58 73.87,97.76 73.87,98.03 73.89,98.09 73.93,98.14 73.96,98.16 74.02,98.16 74.02,98.22 74.04,98.25 74.07,98.29 74.21,98.43 74.21,98.65 74.48,98.92 74.48,99.28 74.44,99.46 74.35,99.61 74.31,99.7 74.35,99.79 74.52,99.96
P1V8_SUS_NODE1 on BOTTOM (solid shape): outline of 214 points within 72.9,82.3 76.53,85.71
P1V8_SUS_NODE1 on IN1 (solid shape): outline of 620 points within 71.27,82.31 74.92,98.32
P1V8_VCCASFRHPLL_NODE1 on TOP (solid shape): 51.99,78.35 51.99,75.28 51.68,74.97 48.68,74.97 48.5,75.15 48.5,78.36 48.82,78.68 51.65,78.68
P1V8_VCCASFRHPLL_NODE1 on IN3 (solid shape): 51.99,78.35 51.99,75.28 51.68,74.97 48.68,74.97 48.5,75.15 48.5,78.36 48.82,78.68 51.65,78.68
P1V9_LAN1 on TOP (solid shape): 39.17,165.2 39.17,163.15 35.57,163.15 35.42,163.3 35.42,164.9 35.75,165.23 39.14,165.23
P1V9_LAN1 on TOP (solid shape): 39.29,157.5 39.29,155.69 39.11,155.5 35.68,155.5 35.35,155.84 35.35,157.38 35.62,157.64 39.15,157.64
P1V9_LAN1 on TOP (solid shape): 37.37,147.27 37.64,147.27 37.86,147.05 37.86,144.99 38.14,144.71 39.59,144.71 39.79,144.52 39.79,144.17 40.2,143.76 42.95,143.76 43.1,143.61 43.1,139.38 42.87,139.15 39.41,139.15 38.98,138.71 38.98,135.01 38.33,134.37 35.64,134.37 34.71,135.3 34.71,141.9 35.91,143.11 35.91,147.17 36.02,147.28 37.37,147.28
P1V9_LAN1 on BOTTOM (solid shape): 38.17,163.15 35.57,163.15 35.42,163.3 35.42,164.9 35.75,165.23 38.17,165.23
P1V9_LAN1 on BOTTOM (solid shape): 38.26,158.12 38.26,155.21 38.24,155.18 35.51,155.18 35.32,155.37 35.32,157.98 35.6,158.26 38.12,158.26
P1V9_LAN1 on BOTTOM (solid shape): 37.37,147.27 37.64,147.27 37.86,147.05 37.86,144.99 38.14,144.71 39.59,144.71 39.79,144.52 39.79,144.17 40.2,143.76 42.95,143.76 43.1,143.61 43.1,139.38 42.87,139.15 39.41,139.15 38.98,138.71 38.98,135.01 38.33,134.37 35.64,134.37 34.71,135.3 34.71,141.9 35.91,143.11 35.91,147.17 36.02,147.28 37.37,147.28
P1V9_LAN1 on BOTTOM (solid shape): outline of 106 points within 49.21,150.38 56.14,161.52
P1V9_LAN1 on IN1 (solid shape): outline of 479 points within 33.37,133.08 43.18,165.69
P1V9_LAN1 on IN2 (solid shape): outline of 1946 points within 34.03,151.66 63.58,167.73
P1V9_LAN2 on TOP (solid shape): 187.3,161.46 187.3,158.41 187.26,158.32 187.17,158.29 185.25,158.29 185.2,158.34 185.2,161.63 185.34,161.77 186.99,161.77
P1V9_LAN2 on TOP (solid shape): 195.26,161.62 195.26,159.94 195.24,159.94 195.24,158.51 195.2,158.42 195.11,158.39 192.79,158.39 192.7,158.42 192.66,158.51 192.66,161.54 192.8,161.68 195.2,161.68
P1V9_LAN2 on TOP (solid shape): 201.05,151.11 205.1,151.11 205.34,150.86 205.34,145.9 205.09,145.65 205.09,141.83 205.08,141.82 205.08,139.46 204.82,139.2 199.52,139.2 199.3,139.43 199.3,143.49 198.25,144.54 195.7,144.54 195.67,144.57 195.67,146.43 195.99,146.75 198.51,146.75 198.81,147.06 198.81,148.82 197.34,150.3 197.34,150.8 197.66,151.12 201.04,151.12
P1V9_LAN2 on BOTTOM (solid shape): outline of 1568 points within 173.29,141.55 204.87,162.12
P1V9_LAN2 on IN2 (solid shape): outline of 1264 points within 164.99,141.83 205.24,162.49
P1V26_BMC_NODE1 on TOP (solid shape): outline of 1671 points within 72.85,128.56 96.09,141.72
P1V26_BMC_NODE1 on BOTTOM (solid shape): 64.01,125.48 64.01,123.49 63.84,123.32 61.97,123.32 61.9,123.39 61.9,125.07 62.39,125.56 63.93,125.56
P1V26_BMC_NODE1 on BOTTOM (solid shape): 76.04,131.29 76.04,130.7 75.66,130.32 75.66,129.84 75.56,129.74 74.39,129.74 74.29,129.84 74.29,130.58 74.9,131.19 74.9,131.25 75.13,131.49 75.84,131.49
P1V26_BMC_NODE1 on BOTTOM (solid shape): 79.6,139.82 79.6,139.61 79.24,139.26 79.24,137.81 79.12,137.68 78.71,137.68 78.58,137.81 78.58,138.37 78.68,138.47 78.68,139.31 78.61,139.38 78.4,139.38 78.24,139.55 78.24,139.8 78.4,139.97 79.45,139.97
P1V26_BMC_NODE1 on BOTTOM (solid shape): 73.58,134.41 74.01,134.41 74.09,134.34 74.09,133.8 74.01,133.73 73.48,133.73 73.32,133.57 73.32,133.12 73.2,132.99 72.69,132.99 72.67,133.01 72.67,134.39 72.7,134.48 72.79,134.51 73.48,134.51
P1V26_BMC_NODE1 on BOTTOM (solid shape): 75.16,140.08 75.25,140.04 75.36,140.03 75.41,140.02 75.57,139.86 75.6,139.82 75.61,139.77 75.61,139.33 75.76,139.18 75.76,138.75 75.65,138.64 75.03,138.64 74.97,138.69 74.49,138.69 74.23,138.95 74.23,139.61 74.26,139.64 74.26,140.07 74.29,140.09 75.13,140.09
P1V26_BMC_NODE1 on BOTTOM (solid shape): outline of 115 points within 81.43,131.02 95.94,141.29
P1V26_BMC_NODE1 on VCC1 (solid shape): 92.13,145.74 92.14,145.67 92.13,145.63 92.16,145.34 92.39,145.15 92.46,145.1 92.49,145.03 92.49,142.02 92.89,141.61 93.94,141.61 93.96,141.6 94.11,141.57 94.27,141.6 94.29,141.61 96.28,141.61 96.55,141.35 96.55,137.02 96.06,136.53 94.65,136.53 94.15,136.03 94.15,126.24 93.76,125.85 69.38,125.85 69.32,125.88 69.31,125.91 69.04,126.09 68.73,126 68.56,125.94 68.38,126.01 67.86,126.53 67.86,133.91 67.9,133.97 67.93,133.99 68.12,134.32 67.93,134.65 67.9,134.67 67.86,134.73 67.86,137.87 67.89,137.91 67.97,138.13 67.89,138.36 67.86,138.4 67.86,143.29 67.87,143.34 67.9,143.38 68.03,143.66 67.9,143.94 67.87,143.98 67.86,144.03 67.86,145.85 68.51,146.5 68.59,146.51 68.62,146.49 68.87,146.46 69.08,146.59 69.13,146.62 69.18,146.63 91.23,146.63
P1V26_BMC_NODE1 on IN2 (solid shape): outline of 3589 points within 61.21,123.33 95.83,140.26
P1V26_BMC_NODE1_ADJ on TOP (solid shape): 96.6,140.18 96.6,138.66 96.82,138.44 96.82,137.87 96.65,137.7 96.65,137.22 96.61,137.19 96.19,137.19 96.14,137.25 96.14,138.43 96.34,138.63 96.34,138.64 96.34,140.19 96.36,140.21 96.57,140.21
P1V538_BMC_NODE1 on TOP (solid shape): 46.25,132.9 46.25,129.39 46.45,129.19 46.45,127.74 44.67,127.74 44.52,127.9 42.82,127.9 42.82,127.9 42.62,127.9 42.55,127.96 42.55,128.8 42.59,128.84 42.59,129.83 42.69,129.93 43.48,129.93 43.69,130.14 43.69,131.79 44.02,132.12 44.7,132.12 44.95,132.37 44.95,133.17 45.99,133.17
P1V538_BMC_NODE1 on BOTTOM (solid shape): 74.09,133.32 74.09,131.77 73.86,131.54 73.43,131.54 73.33,131.44 72.79,131.44 72.7,131.48 72.67,131.57 72.67,132.61 72.7,132.7 72.79,132.74 73.3,132.74 73.35,132.79 73.38,132.79 73.53,132.94 73.53,132.96 73.58,133.01 73.58,133.27 73.62,133.36 73.71,133.4 74.01,133.4
P1V538_BMC_NODE1 on BOTTOM (solid shape): outline of 3801 points within 42.6,122.53 74.06,144.59
P1V538_BMC_NODE1 on IN2 (solid shape): outline of 9624 points within 41.88,119.22 149.63,151.54
P1V538_BMC_NODE1 on IN3 (solid shape): outline of 5783 points within 42.53,127.96 140.15,154.24
P3V3_CLK_NODE1 on BOTTOM (solid shape): outline of 1230 points within 137.28,105.42 152.3,123.29
P3V3_CLK_NODE1 on IN1 (solid shape): outline of 1298 points within 137.22,103.95 156.19,118.11
P3V3_CLK_NODE1 on IN3 (solid shape): outline of 1142 points within 142.68,105.68 157.17,117.86
P3V3_CLK_NODE1_R on BOTTOM (solid shape): 150.54,104.73 150.54,103.7 150.53,103.69 150.53,102.37 149.69,101.53 146.96,101.53 146.56,101.93 146.56,102.86 146.56,102.86 146.56,104.67 146.83,104.95 150.33,104.95
P3V3_NODE1 on TOP (solid shape): 66.95,122.04 66.95,120.64 66.82,120.51 66.04,120.51 65.88,120.66 65.88,121.91 66.06,122.09 66.9,122.09
P3V3_NODE1 on TOP (solid shape): 89.85,95.29 89.85,94.32 89.81,94.28 88.32,94.28 88.31,94.29 88.31,95.33 88.39,95.4 89.74,95.4
P3V3_NODE1 on TOP (solid shape): 112.07,8.46 112.07,4.16 111.86,3.95 110.71,3.95 110.55,4.11 110.55,8.93 110.65,9.03 111.5,9.03
P3V3_NODE1 on TOP (solid shape): 156.18,159.52 156.18,158.73 155.53,158.09 153.07,158.09 152.96,158.2 152.96,159.2 153.45,159.69 156,159.69
P3V3_NODE1 on TOP (solid shape): 128.52,48.09 128.52,46.37 128.46,46.31 126.46,46.31 126.24,46.53 126.24,47.95 126.42,48.14 128.47,48.14
P3V3_NODE1 on TOP (solid shape): 96.06,8.6 96.06,1.97 95.77,1.68 91.57,1.68 91.35,1.9 91.35,8.65 91.45,8.75 95.91,8.75
P3V3_NODE1 on TOP (solid shape): 185.87,202.64 185.96,202.61 186,202.52 186,200.4 186.44,199.96 186.44,199.29 186.4,199.25 185.51,199.25 185.06,199.7 185.06,202.6 185.11,202.64
P3V3_NODE1 on TOP (solid shape): 35.76,149.56 35.76,148.6 35.56,148.4 35.56,143.42 34.3,142.16 34.3,139.33 34.12,139.15 31.37,139.15 31.2,139.32 31.2,141.32 31.18,141.35 31.18,147.19 31.74,147.75 31.74,149.11 32.68,150.05 35.28,150.05
P3V3_NODE1 on TOP (solid shape): 139.88,167.77 142.51,167.77 142.57,167.71 142.57,167.53 142.53,167.49 141.81,167.49 141.75,167.49 141.65,167.49 141.62,167.46 140.99,167.46 140.78,167.24 140.78,167.07 139.81,166.1 139.2,166.1 139.1,166.2 139.1,167.94 139.13,167.96 139.68,167.96
P3V3_NODE1 on TOP (solid shape): 133.9,173.85 133.95,173.84 133.99,173.81 134.26,173.7 134.53,173.81 134.58,173.84 134.62,173.85 135.56,173.85 135.67,173.74 135.67,172.83 135.67,172.81 135.64,172.72 135.63,172.64 135.56,172.46 135.38,172.39 132,172.39 131.92,172.46 131.92,173.19 132.58,173.85
P3V3_NODE1 on TOP (solid shape): 192.02,150.65 192.02,146.06 193.03,145.05 195.11,145.05 195.34,144.81 195.34,144.16 195.4,144.1 198.25,144.1 198.93,143.43 198.93,140.7 198.61,140.38 191.14,140.38 189.9,141.61 189.9,141.75 189.97,141.81 189.97,143.09 192.11,143.09 192.11,143.03 192.12,142.97 192.14,142.9 192.16,142.85 192.19,142.79 192.23,142.74 192.28,142.7 192.33,142.66 192.38,142.63 192.44,142.6 192.5,142.59 192.56,142.58 192.59,142.58 194.06,142.58 194.06,143.54 192.59,143.54 192.56,143.54 192.5,143.53 192.44,143.52 192.38,143.49 192.33,143.46 192.28,143.42 192.23,143.38 192.19,143.33 192.16,143.27 192.14,143.22 192.12,143.15 192.11,143.09 189.97,143.09 189.97,150.78 190.26,151.08 191.59,151.08
P3V3_NODE1 on TOP (solid shape): outline of 141 points within 159.62,20.4 171.63,27.2
P3V3_NODE1 on BOTTOM (solid shape): 96.06,8.22 96.06,1.97 95.77,1.68 91.57,1.68 91.35,1.9 91.35,8.16 91.52,8.33 95.94,8.33
P3V3_NODE1 on BOTTOM (solid shape): 174.68,108.59 174.68,107.9 174.51,107.73 172.79,107.73 172.67,107.85 172.67,108.56 172.82,108.71 174.56,108.71
P3V3_NODE1 on BOTTOM (solid shape): 153.03,104.75 153.03,103.27 152.77,103.02 151.22,103.02 151.03,103.21 151.03,103.25 151.01,103.34 150.97,103.42 150.95,103.45 150.95,104.92 151.04,105.01 152.76,105.01
P3V3_NODE1 on BOTTOM (solid shape): 78.1,131.23 78.1,129.93 77.41,129.93 77.11,129.64 76.02,129.64 75.92,129.74 75.92,129.96 75.93,129.97 75.93,130.11 76.37,130.55 76.37,131.43 76.42,131.48 77.85,131.48
P3V3_NODE1 on BOTTOM (solid shape): 35.76,149.56 35.76,148.6 35.56,148.4 35.56,143.42 34.3,142.16 34.3,139.33 34.12,139.15 31.37,139.15 31.2,139.32 31.2,141.32 31.18,141.35 31.18,147.19 31.74,147.75 31.74,149.11 32.68,150.05 35.28,150.05
P3V3_NODE1 on BOTTOM (solid shape): 89.85,95.29 89.85,94.32 89.81,94.28 88.32,94.28 88.18,94.42 88.18,94.88 88.24,95.01 88.26,95.15 88.33,95.33 88.51,95.4 89.74,95.4
P3V3_NODE1 on BOTTOM (solid shape): 68.22,125.44 68.22,124.93 68.85,124.3 68.85,123.25 68.82,123.16 68.73,123.13 68.16,123.13 68.03,123.22 67.87,123.26 67.83,123.26 67.71,123.38 67.71,124.04 67.2,124.55 67.2,125.44 67.33,125.57 68.09,125.57
P3V3_NODE1 on BOTTOM (solid shape): 73.77,139.63 73.77,139.32 73.83,139.26 73.83,137.74 74.09,137.48 74.09,136.88 74.02,136.81 73.98,136.78 73.93,136.77 73.51,136.77 73.23,137.06 72.81,137.06 72.69,137.17 72.63,137.26 72.6,137.29 72.57,137.33 72.56,137.38 72.56,139.78 72.75,139.96 73.43,139.96
P3V3_NODE1 on BOTTOM (solid shape): 81.69,131.08 81.91,131.08 82.01,130.98 82.9,130.98 82.95,130.93 82.95,129.76 82.82,129.63 82.67,129.63 82.59,129.64 82.53,129.64 82.51,129.64 82.45,129.65 82.44,129.66 80.06,129.66 79.97,129.7 79.93,129.79 79.93,130.19 80.21,130.46 80.21,130.52 80.39,130.69 80.39,130.98 80.5,131.09 81.67,131.09
P3V3_NODE1 on BOTTOM (solid shape): 71.47,83.36 71.47,83.31 71.52,83.31 72.07,82.76 72.07,81.15 71.95,81.03 70.97,81.03 70.58,81.42 70.58,81.99 70.96,82.37 70.96,82.4 70.99,82.43 71.08,82.74 70.95,83.03 70.91,83.07 70.91,83.24 70.95,83.32 71.02,83.37 71.47,83.37
P3V3_NODE1 on BOTTOM (solid shape): 76.6,140.46 76.6,140.41 76.64,140.28 76.73,140.18 76.83,140.11 76.95,140.09 76.99,140.08 77.41,139.66 77.41,137.78 77.34,137.71 76.83,137.71 76.75,137.78 76.75,139.26 76.65,139.36 76.09,139.36 75.92,139.54 75.92,139.84 75.87,139.89 75.87,139.93 75.83,139.97 75.8,140.01 75.79,140.06 75.79,140.34 75.8,140.41 75.81,140.46 75.81,140.51 75.84,140.55 75.96,140.67 76.39,140.67
P3V3_NODE1 on BOTTOM (solid shape): 159.34,39.68 159.36,39.6 159.34,39.56 159.43,39.04 159.95,38.95 160.02,38.96 160.09,38.92 161.51,37.51 161.51,35.83 161.47,35.74 161.38,35.7 160.92,35.25 161.38,34.79 161.47,34.75 161.51,34.66 161.51,33.07 161.41,32.98 157.26,32.98 157.04,33.2 157.04,40.93 157.12,41 158.02,41
P3V3_NODE1 on BOTTOM (solid shape): 80.82,140.12 80.97,140.09 81.12,140.12 81.15,140.13 81.6,140.13 81.62,140.12 81.77,140.09 81.92,140.12 81.95,140.13 82.4,140.13 82.43,140.12 82.59,140.09 82.74,140.13 82.77,140.13 83,139.9 83,139.64 83,138.88 83,138.84 83,138.08 83,138.04 83,137.34 82.99,137.26 83,137.17 83,136.48 83,136.44 83,135.68 83,135.38 83.09,135.3 83.29,135.3 83.37,135.29 83.46,135.3 84.09,135.3 84.17,135.29 84.26,135.3 84.54,135.3 84.72,135.12 84.72,134.87 84.36,134.52 83.45,134.52 82.69,133.75 81.59,133.75 81.4,133.94 81.4,137.82 81.71,138.12 81.71,139.24 81.65,139.3 81.65,139.42 80.54,139.42 80.51,139.38 80.44,139.38 80.31,139.26 80.31,138.8 80.03,138.52 79.6,138.52 79.5,138.62 79.5,139.15 79.85,139.51 79.85,139.51 79.9,139.56 79.9,139.87 80.1,140.07 80.14,140.09 80.17,140.09 80.25,140.09 80.32,140.12 80.35,140.13 80.8,140.13
P3V3_NODE1 on BOTTOM (solid shape): outline of 238 points within 49.29,97.07 60.39,100.59
P3V3_NODE1 on BOTTOM (solid shape): outline of 247 points within 90.27,82.33 93.9,88.31
P3V3_NODE1 on IN1 (solid shape): outline of 206 points within 101.02,173.96 106.13,176.41
P3V3_NODE1 on IN1 (solid shape): outline of 5705 points within 65.88,116.94 89.06,148.35
P3V3_NODE1 on IN2 (solid shape): 93.66,88.21 93.75,88.17 93.79,88.08 93.79,87.61 93.72,87.44 93.56,87.35 93.25,87.13 93.29,86.75 93.32,86.71 93.31,86.62 92.97,86.27 92.95,86.26 92.87,86.2 92.81,86.12 92.8,86.11 92.49,85.79 92.49,85.66 91.92,85.09 91.68,85.09 91.13,85.65 91.13,86.46 92.87,88.21
P3V3_NODE1 on IN2 (solid shape): outline of 3103 points within 55.33,81.18 86.77,103.15
P3V3_NODE1 on IN2 (solid shape): outline of 9134 points within 132.07,155.01 195.41,201.57
P3V3_NODE1 on IN2 (solid shape): outline of 14925 points within 125.15,20.85 178.24,93.26
P3V3_NODE1 on IN3 (solid shape): outline of 1056 points within 163.75,86.76 186.58,105.36
P3V3_NODE1 on IN3 (solid shape): outline of 1866 points within 115.04,166.45 137.28,180.25
P3V3_NODE1 on IN3 (solid shape): outline of 4975 points within 65.54,116.97 98.16,144.51
P3V3_NODE1 on VCC2: outline of 115 points within 13.05,1.02 211.02,207.68 ; 5 cut-outs
P3V3_RTC_NODE1 on TOP (solid shape): 75.52,83.86 75.85,83.86 75.99,83.72 75.99,83.68 75.92,83.5 75.97,83.3 75.99,83.27 75.99,82.92 75.97,82.89 75.92,82.71 75.97,82.54 75.99,82.51 75.99,82.35 75.95,82.26 75.94,82.24 75.85,82.13 75.82,81.99 75.81,81.95 75.53,81.66 75.53,81.16 75.46,81.09 75.19,81.09 75.18,81.09 74.78,81.09 74.72,81.15 74.72,82.04 74.73,82.04 74.73,82.73 74.85,82.85 74.89,82.86 74.99,82.88 75.08,82.94 75.21,83.12 75.21,83.34 75.21,83.35 75.21,83.74 75.3,83.84 75.36,83.87 75.43,83.87
P3V3_RTC_NODE1 on BOTTOM (solid shape): 100.09,85.22 100.18,85.18 100.21,85.09 100.21,82.88 99.27,81.94 98.02,81.94 98,81.95 98,82.43 97.98,82.45 97.98,82.98 98.06,83.15 98.24,83.23 98.57,83.42 98.56,83.81 98.52,83.96 98.58,84.1 98.63,84.52 98.26,84.73 98.07,84.79 97.98,84.98 97.98,85.1 98.11,85.22
P3V3_RTC_NODE1 on IN1 (solid shape): outline of 759 points within 90.26,82.14 100.03,91.34
P3V3_STB_NODE1 on TOP (solid shape): 20.21,3.8 20.21,2.71 20.1,2.6 17.92,2.6 17.78,2.73 17.78,3.45 17.87,3.54 19.46,3.54 19.73,3.82 20.2,3.82
P3V3_STB_NODE1 on TOP (solid shape): 71.48,112.99 71.75,112.99 71.9,112.83 71.9,105.33 71.78,105.21 67.2,105.21 66.99,105.43 66.99,112.86 67.14,113.01 71.45,113.01
P3V3_STB_NODE1 on TOP (solid shape): 96,102.12 96,99.13 95.72,98.85 92.65,98.85 92.48,99.02 90.93,99.02 90.91,99 90.83,99 90.41,98.59 89.3,98.59 89.13,98.76 89.13,100.97 89.11,100.99 89.11,101.77 89.81,102.46 95.65,102.46
P3V3_STB_NODE1 on TOP (solid shape): 129.56,20.76 129.56,18.73 129.49,18.65 128.18,18.65 128.07,18.77 128.07,19.09 128.28,19.31 128.28,21.08 128.32,21.17 128.41,21.2 129.12,21.2
P3V3_STB_NODE1 on BOTTOM (solid shape): outline of 2012 points within 124.49,1.99 156.67,30.04
P3V3_STB_NODE1 on BOTTOM (solid shape): outline of 3081 points within 183.91,115.59 202.72,140.42
P3V3_STB_NODE1 on VCC1 (solid shape): outline of 1123 points within 38.61,14.27 193.61,178.03
P3V3_SUS_NODE1 on TOP (solid shape): 93.72,98.33 93.76,98.33 94.21,98.33 94.24,98.33 94.45,98.33 94.5,98.28 94.5,97.88 94.66,97.72 94.66,97.7 94.69,97.7 95.39,96.99 95.39,96.28 94.92,95.8 94.92,94.96 94.92,94.95 94.92,92.07 94.86,92.01 92.61,92.01 92.5,92.12 92.5,92.38 92.52,92.4 92.52,93.38 92.51,93.44 92.5,93.51 92.5,96.11 92.56,96.18 92.61,96.19 92.67,96.2 92.72,96.21 92.77,96.24 92.81,96.26 92.84,96.28 92.9,96.28 92.9,96.34 92.93,96.37 93.03,96.67 92.93,96.96 92.9,96.99 92.85,97.06 92.81,97.08 92.72,97.18 92.72,97.87 92.62,97.96 92.59,98.05 92.63,98.14 92.82,98.33
P3V3_SUS_NODE1 on BOTTOM (solid shape): outline of 372 points within 89.54,86.68 97.54,94.91
P3V3_SUS_NODE1 on IN1 (solid shape): outline of 1686 points within 74.33,81.08 94.8,100.17
P3V3_USB_NODE1 on BOTTOM (solid shape): outline of 528 points within 172.12,93.96 183.43,107.15
P3V3_USB_NODE1 on IN3 (solid shape): outline of 1487 points within 169.88,95.26 182.64,106.87
P5V_CRT on TOP (solid shape): 30.2,72.69 30.41,72.65 30.63,72.69 30.65,72.71 32.3,72.71 32.37,72.63 32.37,69.53 31.9,69.06 30.37,69.06 29.72,68.41 29.72,67 29.6,66.88 27.33,66.88 27.14,67.07 27.14,68.14 27.79,68.78 27.79,71.76 28.74,72.71 30.18,72.71
P5V_CRT on BOTTOM (solid shape): outline of 2666 points within 20.59,39.82 37.18,72.1
P5V_CRT on IN3 (solid shape): outline of 2580 points within 20.59,39.66 36.71,72.1
P5V_NODE1 on TOP (solid shape): 157.93,51.28 157.93,49.2 157.7,48.97 156.55,48.97 156.3,49.22 156.3,51.46 156.43,51.59 157.62,51.59
P5V_NODE1 on TOP (solid shape): 189.7,49.67 189.7,47.15 189.44,46.89 183.48,46.89 183.28,47.08 183.28,49.75 183.41,49.88 189.48,49.88
P5V_NODE1 on TOP (solid shape): 203.25,29.57 203.25,25.21 203,24.95 201.02,24.95 200.82,25.15 200.82,29.62 201.04,29.84 202.99,29.84
P5V_NODE1 on TOP (solid shape): 33.68,73.84 33.68,72.29 33.47,72.08 32.8,72.08 32.65,72.23 32.65,72.77 32.41,73.02 31.35,73.02 31.18,73.18 31.18,73.84 31.36,74.01 33.5,74.01
P5V_NODE1 on TOP (solid shape): 107.5,8.96 107.5,5.51 107.29,5.29 107.29,4.29 107.17,4.17 106.11,4.17 105.9,4.39 105.9,5.42 106.53,6.06 106.53,8.98 106.57,9.02 107.44,9.02
P5V_NODE1 on TOP (solid shape): 78.02,163.84 78.02,161.32 77.96,161.26 77.18,161.26 77.06,161.38 77,161.38 76.83,161.55 73.72,161.55 73.56,161.71 73.56,162.09 73.58,162.1 73.77,162.1 74.01,162.35 74.01,164.1 74.06,164.14 77.71,164.14
P5V_NODE1 on TOP (solid shape): 151.52,25.41 151.52,24.27 151.75,24.04 152.15,24.04 152.17,24.03 155.08,24.03 155.09,24.03 155.51,24.45 155.51,25.49 155.51,25.51 155.52,25.54 155.54,25.57 155.56,25.6 155.59,25.61 155.62,25.62 155.64,25.62 156.18,25.62 156.19,25.61 156.19,19.92 155.51,19.24 149.63,19.24 149.43,19.44 149.43,19.9 151.66,19.9 151.66,21.7 149.86,21.7 149.86,19.9 149.43,19.9 149.43,25.34 149.5,25.41 150.51,25.41 150.73,25.63 151.31,25.63
P5V_NODE1 on BOTTOM (solid shape): 157.93,51.28 157.93,49.2 157.7,48.97 156.55,48.97 156.3,49.22 156.3,51.46 156.43,51.59 157.62,51.59
P5V_NODE1 on BOTTOM (solid shape): 189.7,49.67 189.7,47.15 189.44,46.89 183.48,46.89 183.28,47.08 183.28,49.75 183.41,49.88 189.48,49.88
P5V_NODE1 on BOTTOM (solid shape): 203.25,29.57 203.25,25.21 203,24.95 201.02,24.95 200.82,25.15 200.82,29.62 201.04,29.84 202.99,29.84
P5V_NODE1 on BOTTOM (solid shape): 78.02,163.84 78.02,161.32 77.96,161.26 77.18,161.26 77.06,161.38 77,161.38 76.83,161.55 73.72,161.55 73.56,161.71 73.56,162.09 73.58,162.1 73.77,162.1 74.01,162.35 74.01,164.1 74.06,164.14 77.71,164.14
P5V_NODE1 on BOTTOM (solid shape): outline of 87 points within 102.91,170.23 105.01,178.99
P5V_NODE1 on BOTTOM (solid shape): outline of 127 points within 77.23,3.64 107.96,15.95
P5V_NODE1 on IN1 (solid shape): 44.69,21.77 44.95,21.67 45.2,21.77 45.23,21.8 45.86,21.8 45.91,21.75 45.91,20.19 45.59,19.87 43.37,19.87 43.18,20.07 43.18,21.58 43.39,21.8 44.66,21.8
P5V_NODE1 on IN1 (solid shape): outline of 113 points within 73.23,13.01 77.87,14.91
P5V_NODE1 on IN1 (solid shape): outline of 384 points within 80.7,170.35 90.38,177.67
P5V_NODE1 on IN1 (solid shape): outline of 5358 points within 105.63,1.64 165.21,57.95
P5V_NODE1 on IN2 (solid shape): outline of 750 points within 86,171.36 105.14,179.56
P5V_NODE1 on IN2 (solid shape): outline of 1602 points within 69.9,159.84 84,178.1
P5V_NODE1 on IN3 (solid shape): outline of 740 points within 31.18,19.87 44.64,74.01
P5V_NODE1 on IN3 (solid shape): outline of 16670 points within 134.98,8.26 208.99,157.35
P5V_NODE1 on VCC2: outline of 420 points within 70.79,19.25 203.41,207.68
P5V_STB_NODE1 on TOP (solid shape): 44.24,125.7 44.24,124.82 44.72,124.34 44.72,123.48 44.67,123.43 43.81,123.43 43.53,123.71 43.53,125.69 43.58,125.74 44.2,125.74
P5V_STB_NODE1 on TOP (solid shape): 95.08,143.49 95.08,142.44 95.03,142.39 92.86,142.39 92.67,142.58 92.67,143.84 92.76,143.94 94.62,143.94
P5V_STB_NODE1 on TOP (solid shape): 83.48,163.07 83.48,150.82 82.92,150.27 77.43,150.27 77.06,150.64 77.06,159.42 77.47,159.84 78.11,159.84 78.59,160.32 78.59,163.68 82.87,163.68
P5V_STB_NODE1 on TOP (solid shape): 27.46,129.16 27.46,128.25 27.2,127.99 27.2,126.32 27.12,126.24 26.21,126.24 26.15,126.31 26.15,127.59 26.16,127.6 26.16,128.19 27.14,129.17 27.45,129.17
P5V_STB_NODE1 on TOP (solid shape): 57.75,114.04 57.75,111.07 57.74,111.06 57.54,111.06 57.53,111.07 57.53,111.89 57.52,111.9 57.52,112.06 57.14,112.44 56.55,112.44 56.52,112.47 56.52,114.04 56.61,114.13 57.66,114.13
P5V_STB_NODE1 on TOP (solid shape): 81.99,10.51 81.99,7.54 81.97,7.53 81.78,7.53 81.77,7.54 81.77,8.36 81.76,8.37 81.76,8.53 81.38,8.91 80.79,8.91 80.76,8.93 80.76,10.51 80.85,10.6 81.9,10.6
P5V_STB_NODE1 on TOP (solid shape): 117.87,129.3 117.96,129.26 117.99,129.17 117.99,129.14 118.29,128.85 118.29,128.15 118.2,128.06 116.77,128.06 116.74,128.1 116.74,129.08 116.96,129.3
P5V_STB_NODE1 on TOP (solid shape): 117.43,133.57 117.43,133.44 117.42,133.43 116.49,133.43 116.47,133.41 116.47,133.17 116.48,133.17 117.3,133.17 117.35,133.11 117.35,132.61 116.95,132.2 115.79,132.2 115.63,132.37 115.63,133.52 115.68,133.58 117.43,133.58
P5V_STB_NODE1 on TOP (solid shape): 53.03,14.58 53.03,12.61 52.12,11.7 52.12,11.18 51.98,11.05 51.31,11.05 51.26,11.09 51.26,12.06 52.13,12.93 52.13,13.25 52.41,13.53 52.41,14.58 52.54,14.71 52.9,14.71
P5V_STB_NODE1 on TOP (solid shape): 114.74,153.68 114.74,152.86 114.75,152.85 114.75,152.7 115.13,152.31 115.72,152.31 115.74,152.29 115.74,149.95 115.66,149.87 114.65,149.87 114.53,149.99 114.53,150.7 114.52,150.71 114.52,153.68 114.53,153.69 114.73,153.69
P5V_STB_NODE1 on TOP (solid shape): 42.67,102.32 42.67,101.65 42.64,101.56 42.55,101.53 41.18,101.53 41.15,101.55 40.89,101.62 40.63,101.55 40.6,101.53 39.35,101.53 39.22,101.66 39.22,102.13 39.25,102.16 41.66,102.16 41.84,102.34 42.66,102.34
P5V_STB_NODE1 on BOTTOM (solid shape): 82.74,163.7 82.83,163.67 82.87,163.58 82.87,161.35 83.48,160.74 83.48,150.82 82.92,150.27 77.79,150.27 77.7,150.31 77.66,150.4 77.66,159.54 77.96,159.84 78.11,159.84 78.59,160.32 78.59,160.47 78.93,160.8 78.93,163.58 78.96,163.67 79.05,163.7
P5V_STB_NODE1 on BOTTOM (solid shape): outline of 384 points within 115.33,128.05 120.56,140.25
P5V_STB_NODE1 on IN1 (solid shape): 204.55,80.31 204.55,78.63 204.41,78.49 201.42,78.49 201.27,78.65 201.27,80.08 201.59,80.4 204.46,80.4
P5V_STB_NODE1 on IN1 (solid shape): 79.46,163.68 82.74,163.68 82.83,163.64 82.87,163.55 82.87,161.35 83.48,160.74 83.48,150.82 82.92,150.27 77.43,150.27 77.06,150.64 77.06,159.42 77.47,159.84 78.11,159.84 78.59,160.32 78.59,163.58 78.63,163.67 78.72,163.71 79.43,163.71
P5V_STB_NODE1 on VCC1 (solid shape): outline of 401 points within 25.12,119.01 124.87,178.19
P5V_STB_NODE1 on IN2 (solid shape): 204.55,80.31 204.55,78.63 204.41,78.49 201.42,78.49 201.27,78.65 201.27,80.08 201.59,80.4 204.46,80.4
P5V_STB_NODE1 on IN2 (solid shape): 81.76,159.29 81.76,152.53 81.66,152.43 77.2,152.43 77.06,152.58 77.06,159.22 77.34,159.51 81.55,159.51
P5V_STB_NODE1 on IN2 (solid shape): 116.41,152.79 116.41,151.37 116.37,151.28 116.29,151.24 115.94,150.96 116.1,150.54 116.21,150.36 116.14,150.15 115.89,149.9 115.12,149.9 114.77,150.25 114.77,152.68 115,152.92 116.27,152.92
P5V_STB_NODE1 on IN2 (solid shape): outline of 6853 points within 16.65,1.61 100.69,115.15
P5V_STB_NODE1 on IN3 (solid shape): outline of 101 points within 99.6,7.7 104.19,11.26
P5V_STB_NODE1 on IN3 (solid shape): outline of 4075 points within 24.19,99.7 51.53,127.92
P12V_AUX on TOP (solid shape): 64.28,4.26 64.28,1.74 64.26,1.72 61.42,1.72 61.32,1.83 61.32,4.23 61.47,4.39 64.15,4.39
P12V_AUX on TOP (solid shape): 131.13,131.09 131.13,128.46 130.98,128.31 129.09,128.31 128.69,128.72 128.69,130.83 129.23,131.38 130.85,131.38
P12V_AUX on TOP (solid shape): 24.98,120.52 24.98,118.86 25.59,118.25 25.59,117.12 25.5,117.04 24.23,117.04 22.92,118.35 22.92,120.63 24.87,120.63
P12V_AUX on TOP (solid shape): 114.23,150.4 114.22,150.4 114.22,148.91 114.09,148.78 112.92,148.78 112.77,148.93 112.77,152.25 113.51,152.99 113.51,153.67 113.53,153.69 114.23,153.69
P12V_AUX on TOP (solid shape): 83.73,13.82 83.73,8.97 82.99,8.23 82.99,7.55 82.97,7.53 82.28,7.53 82.28,11.01 81.42,11.87 81.42,13.69 81.65,13.92 83.63,13.92
P12V_AUX on TOP (solid shape): 59.49,115.22 59.49,112.5 58.75,111.76 58.75,111.08 58.73,111.06 58.04,111.06 58.04,114.36 57.95,114.44 56.95,114.44 56.91,114.49 56.91,115.19 56.94,115.22 59.49,115.22
P12V_AUX on TOP (solid shape): 91.22,153.65 91.22,152.82 91.23,152.81 91.23,152.66 91.61,152.28 91.61,151.29 91.86,151.04 91.86,149.88 91.48,149.5 89.26,149.5 89.26,149.5 89.26,152.22 89.99,152.96 89.99,153.42 91,153.42 91,152.26 91,152.26 91,153.42 91,153.42 89.99,153.42 89.99,153.64 90.01,153.66 90.99,153.66 91,153.65 91.01,153.66 91.21,153.66
P12V_AUX on TOP (solid shape): 56.08,180.59 56.08,177.1 55.9,176.92 55.9,175.92 55.49,175.51 55.49,174.43 54.47,173.4 54.47,170.91 54.24,170.69 53.91,170.69 53.64,170.42 53.51,170.42 53.51,170.29 53.06,169.83 53.06,169.02 50.87,166.83 47.55,166.83 47.24,167.14 47.24,168.65 48.4,169.82 48.49,169.86 48.58,169.82 48.94,169.47 49.68,169.47 50.18,169.98 49.68,170.49 49.36,170.49 49.25,170.59 49.25,170.69 49.19,170.75 49.19,173.16 49.38,173.35 49.89,173.35 50.17,173.63 50.17,175.48 50.38,175.69 50.94,175.69 50.98,175.73 53.08,175.73 53.38,176.03 53.38,179.46 53.42,179.55 53.51,179.59 55.31,179.59 55.58,179.86 55.58,180.34 55.6,180.4 55.6,180.44 55.6,180.48 55.64,180.57 55.73,180.61 56.06,180.61
P12V_AUX on BOTTOM (solid shape): 131.13,131.09 131.13,128.46 130.98,128.31 129.09,128.31 128.69,128.72 128.69,130.83 129.23,131.38 130.85,131.38
P12V_AUX on BOTTOM (solid shape): 24.98,120.52 24.98,118.86 25.59,118.25 25.59,117.12 25.5,117.04 24.23,117.04 22.92,118.35 22.92,120.63 24.87,120.63
P12V_AUX on BOTTOM (solid shape): 64.46,4 64.46,1.92 64.26,1.72 61.42,1.72 61.32,1.83 61.32,4.06 61.35,4.15 61.44,4.18 64.28,4.18
P12V_AUX on BOTTOM (solid shape): 91.35,153.3 91.35,152.54 91.62,152.27 91.62,151.27 91.88,151.01 91.88,149.78 91.59,149.5 89.26,149.5 89.26,149.5 89.26,152.22 89.99,152.96 89.99,153.64 90.01,153.66 90.99,153.66
P12V_AUX on BOTTOM (solid shape): 114.23,148.83 114.03,148.63 112.99,148.63 112.77,148.85 112.77,152.25 113.51,152.99 113.51,153.67 113.53,153.69 114.23,153.69
P12V_AUX on BOTTOM (solid shape): 83.73,13.87 83.73,8.97 82.99,8.23 82.99,7.55 82.97,7.53 82.41,7.53 82.32,7.57 82.28,7.66 82.28,11.02 81.39,11.91 81.39,13.73 81.57,13.91 83.69,13.91
P12V_AUX on BOTTOM (solid shape): 59.49,115.22 59.49,112.5 58.75,111.76 58.75,111.08 58.73,111.06 58.04,111.06 58.04,114.36 57.95,114.44 56.95,114.44 56.91,114.49 56.91,115.19 56.94,115.22 59.49,115.22
P12V_AUX on BOTTOM (solid shape): outline of 136 points within 48.74,167.23 55.49,175.93
P12V_AUX on IN1 (solid shape): outline of 509 points within 61.26,1.8 83.81,13.57
P12V_AUX on IN1 (solid shape): outline of 764 points within 111.56,148.72 124.11,162.3
P12V_AUX on VCC1 (solid shape): outline of 1717 points within 13.05,1.02 211.02,207.68
P12V_AUX on VCC2 (solid shape): outline of 141 points within 108.39,127.07 134.01,163.23
P12V_AUX on IN2 (solid shape): outline of 442 points within 23.39,111.98 59.7,120.93
P12V_AUX on IN2 (solid shape): outline of 1283 points within 89.48,149.32 119.47,163.77
P12V_AUX_EN on TOP (solid shape): 56.75,175.7 56.99,175.46 57.84,175.46 58.07,175.24 58.07,174.6 57.72,174.25 55.97,174.25 55.97,175.41 56.25,175.68 56.25,176.52 56.3,176.57 56.75,176.57
P12V_AUX_EN on TOP (solid shape): 45.63,185.78 45.85,185.66 45.86,185.42 45.81,185.16 45.9,184.92 45.92,184.84 45.89,184.76 45.78,184.43 45.92,184.1 46.02,184 46.02,183.92 45.92,183.81 45.46,183.81 45.36,183.9 45.36,185.73 45.42,185.78
P12V_DBG on TOP (solid shape): outline of 241 points within 13.87,79.16 25.87,96.3
P12V_DBG on BOTTOM (solid shape): outline of 241 points within 13.87,79.16 25.87,96.3
P12V_DBG on IN1 (solid shape): outline of 265 points within 14.18,79.51 25.29,96.21
P12V_DBG on IN2 (solid shape): outline of 265 points within 13.87,79.16 25.87,96.3
P12V_DBG on IN3 (solid shape): outline of 312 points within 13.87,79.16 25.87,96.3
P12V_NODE1_PWRGD_EN on TOP (solid shape): 203.25,116.14 203.25,112.94 203.1,112.78 201.19,112.78 200.91,113.06 200.91,116.42 201.11,116.62 202.77,116.62
P12V_PDB on TOP (solid shape): 26.64,102.24 26.64,98.02 26.08,97.46 15.06,97.46 14.42,98.11 14.42,102.55 14.84,102.97 25.9,102.97
P12V_PDB on TOP (solid shape): outline of 86 points within 47.34,185.34 58.53,191.88
P12V_PDB on TOP (solid shape): 25.24,207.26 25.33,207.22 25.37,207.13 25.37,203.1 25.74,202.73 25.74,200.78 26,200.52 26.01,200.49 26.65,200.31 26.47,200.95 26.44,200.96 26.35,201.04 26.35,202.74 26.68,203.07 26.68,207.13 26.72,207.22 26.81,207.26 27.29,207.26 27.38,207.22 27.41,207.13 27.41,203.08 27.44,203.05 27.65,203.05 27.68,203.08 27.68,207.18 27.76,207.26 28.28,207.26 28.37,207.22 28.41,207.13 28.41,202.91 28.65,202.67 28.65,201.5 28.74,201.41 28.74,200.17 29.82,199.1 29.82,196.87 29.49,196.54 27.17,196.54 24.99,198.72 24.99,201.62 24.69,201.92 24.69,203.1 24.68,203.11 24.68,207.24 24.69,207.26
P12V_PDB on BOTTOM (solid shape): outline of 106 points within 24.68,196.71 29.44,207.28
P12V_PDB on BOTTOM (solid shape): outline of 726 points within 46.08,176.18 58.86,190.04
P12V_PDB on BOTTOM (solid shape): outline of 1070 points within 13.65,97.46 26.64,167.88
P12V_PDB on IN2 (solid shape): outline of 4577 points within 13.77,97.57 58.79,200.01
P12V_PDB on IN3 (solid shape): outline of 11222 points within 13.68,96.65 62.23,202.25
VCC5_CRTXX on TOP (solid shape): 32.12,76.68 32.12,74.47 32.02,74.37 30.01,74.37 29.79,74.15 28.63,74.15 28.08,74.7 28.08,76.95 28.31,77.19 31.61,77.19
VCC5_CRTXX on BOTTOM (solid shape): 32.12,76.68 32.12,74.47 32.02,74.37 30.01,74.37 29.79,74.15 28.63,74.15 28.08,74.7 28.08,76.95 28.31,77.19 31.61,77.19
BMC_NODE1_ADCAV33 on BOTTOM (solid shape): 77.45,146.04 77.45,145.46 76.71,144.72 75.77,144.72 75.73,144.75 75.15,144.57 75.48,144.06 75.52,144.06 75.71,143.99 75.79,143.8 75.79,142.43 75.91,142.31 76.05,142.31 76.08,142.28 76.13,142.26 76.18,142.23 76.26,142.21 76.36,142.2 76.4,142.2 76.49,142.16 76.53,142.08 76.53,141.93 76.43,141.83 75.54,141.83 75.53,141.82 75.15,141.82 74.95,142.02 74.95,142.39 74.98,142.48 75,142.49 75.1,142.66 75.13,142.86 75.13,143.37 74.57,143.94 74.57,145.6 74.59,145.67 74.64,145.72 74.69,145.74 74.73,145.78 74.77,145.8 74.82,145.81 76.09,145.81 76.1,145.81 76.54,146.25 77.23,146.25
BMC_NODE1_DACAV33 on TOP (solid shape): 74.38,149.94 74.38,149.52 74.37,149.52 74.37,149.5 74.34,149.47 74.22,149.14 74.34,148.81 74.36,148.77 74.37,148.72 74.37,148.53 74.36,148.49 74.34,148.45 74.22,148.18 74.27,147.9 74.29,147.86 74.27,147.78 74.12,147.62 72.07,147.62 71.97,147.72 71.97,149.77 72.3,150.1 74.22,150.1
BMC_NODE1_HPLLAV33 on BOTTOM (solid shape): 69.61,124.98 70.26,124.98 70.29,124.95 70.29,123.36 70.08,123.15 69.36,123.15 69.24,123.28 69.24,124.3 68.73,124.8 68.73,125.06 68.85,125.18 69.41,125.18
BMC_NODE1_HPLLAV33 on BOTTOM (solid shape): 73.17,131.19 73.27,131.08 73.27,129.69 73.2,129.61 73.09,129.61 73.08,129.62 72.97,129.63 72.87,129.62 72.85,129.61 72.29,129.61 72.21,129.63 72.08,129.77 72.08,130.19 72.48,130.59 72.49,130.61 72.49,130.63 72.56,130.7 72.56,131.11 72.64,131.19
BMC_NODE1_HPLLAV33 on IN3 (solid shape): outline of 302 points within 67.97,124.58 74.58,130.65
BMC_NODE1_MPLLAV33 on BOTTOM (solid shape): 68.6,130.01 68.6,129.63 69.11,129.12 69.11,127.85 68.47,127.22 68.47,126.45 68.09,126.07 66.06,126.07 65.86,126.28 65.86,126.89 65.95,126.98 67.47,126.98 67.71,127.22 67.71,130.01 67.84,130.14 68.47,130.14
BMC_NODE1_OSC1_EN on TOP (solid shape): 65.95,118.13 65.95,116.97 65.91,116.88 65.82,116.84 64.35,116.84 64.15,117.04 63.17,117.04 63.01,117.19 63.01,117.59 63.12,117.7 63.95,117.7 64.47,118.21 65.87,118.21
BMC_NODE1_OSC1_VDD on TOP (solid shape): 65.37,121.32 65.37,120.51 66.01,119.88 66.01,118.71 65.88,118.58 64.26,118.58 63.72,118.05 61.8,118.05 61.78,118.03 61.73,118.09 61.73,118.53 61.9,118.7 63.13,118.7 63.52,119.09 63.52,121.3 63.7,121.48 65.22,121.48
BMC_NODE1_VCC_1V8_PCIE on BOTTOM (solid shape): 82.19,127.78 82.19,127.6 82.21,127.58 82.24,127.49 82.35,127.36 82.57,127.29 82.79,127.36 82.82,127.38 83.12,127.38 83.16,127.36 83.25,127.31 83.36,127.29 83.4,127.28 83.8,126.89 83.8,126.84 83.91,126.6 84.16,126.49 84.21,126.48 84.32,126.37 84.45,126.37 84.67,126.15 84.7,126.11 84.7,126.06 84.7,125.4 84.42,125.12 83.51,125.12 83.37,124.98 81.92,124.98 81.89,124.99 81.79,125.03 81.68,125.04 80.88,125.04 80.7,125.22 80.57,125.22 80.48,125.25 80.44,125.34 80.44,126.4 80.45,126.45 80.48,126.5 80.51,126.53 80.51,127.21 81.23,127.93 82.04,127.93
BMC_NODE1_VCC_1V8_PCIEA on BOTTOM (solid shape): 85.67,127.21 85.77,127.2 85.88,127.21 85.89,127.22 86.02,127.22 86.09,127.15 86.53,127.15 86.53,127.12 87.24,127.12 87.24,127.15 87.45,127.15 87.52,127.22 88.67,127.22 89.3,126.58 89.3,125.14 88.84,124.68 88.54,124.68 87.45,124.68 87.45,124.68 87.02,124.68 86.51,125.18 86.31,125.18 86.3,125.2 85.35,125.2 84.96,125.58 84.96,126.22 84.89,126.28 84.87,126.32 84.86,126.37 84.86,126.58 84.73,126.71 84.73,127.09 84.86,127.22 85.66,127.22
BMC_NODE1_VCC_1V8_PCIEA on IN3 (solid shape): 82.77,127.95 82.82,127.95 83.37,127.95 83.75,127.57 83.79,127.57 83.85,127.53 83.88,127.47 83.91,127.44 83.96,127.27 83.9,127.11 84.17,126.49 84.45,127.11 84.39,127.27 84.44,127.44 84.46,127.47 84.48,127.5 84.53,127.55 84.6,127.57 85.39,127.57 85.45,127.53 85.47,127.5 85.77,127.31 86.08,127.49 86.08,127.5 86.13,127.55 86.24,127.55 86.25,127.54 88.22,127.54 88.65,127.1 88.65,125.82 88.49,125.66 86.87,125.66 86.76,125.55 83.05,125.55 82.3,126.29 82.3,127.83 82.43,127.95
FM_CPLD_NODE1_P1V5_EN_LV on TOP (solid shape): 51.25,117.77 51.25,115.14 51.1,114.99 48.36,114.99 48.29,115.06 48.29,115.73 47.89,116.12 46.72,116.12 46.6,116.24 46.6,117.9 46.64,117.94 51.08,117.94
FM_CPLD_NODE1_P5V_EN_LV on TOP (solid shape): 73.62,161.3 73.89,161.3 73.94,161.29 73.99,161.3 76.73,161.3 77.06,160.96 78,160.96 78.04,160.92 78.04,160.57 77.63,160.16 75.24,160.16 74.97,160.43 74.29,160.43 73.93,160.07 72.46,160.07 72.1,160.42 72.1,161.28 72.13,161.31 72.62,161.31 72.66,161.34 73.58,161.34
FM_OSC_NODE1_OSC_NC on TOP (solid shape): 88.71,101.61 88.71,98.5 88.66,98.45 87.7,98.45 87.47,98.68 87.47,101.51 87.62,101.65 88.66,101.65
LAN1_CTRL_P1V9 on TOP (solid shape): outline of 141 points within 36.2,145.18 52.49,151.96
LAN1_CTRL_P1V9 on BOTTOM (solid shape): 46.45,151.93 46.57,151.87 46.7,151.85 46.75,151.85 46.79,151.82 47.3,151.31 47.68,151.31 48.59,150.4 49.55,150.4 49.59,150.4 49.67,150.42 49.73,150.4 50.11,150.03 50.11,149.97 50.15,149.78 50.26,149.62 50.4,149.47 50.4,149.37 49.69,148.66 49.6,148.62 49.51,148.66 49.45,148.73 48.88,148.83 48.58,148.35 48.51,148.16 48.32,148.09 41.75,148.09 41.74,148.09 40.39,148.09 39.74,147.44 39.74,145.31 39.7,145.22 39.61,145.18 38.33,145.18 38.23,145.28 38.23,147.26 37.32,148.17 36.53,148.17 36.3,148.4 36.3,150.02 36.33,150.04 36.33,151.12 37.16,151.96 46.42,151.96
LAN1_CTRL_P1V9_R on TOP (solid shape): 43.1,146.93 43.1,144.25 42.86,144.01 40.35,144.01 40.13,144.23 40.13,146.67 40.57,147.11 42.92,147.11
LAN2_CTRL_P1V9 on TOP (solid shape): 181.84,159.45 181.84,157.77 181.59,157.52 180.04,157.52 179.38,156.86 178.16,156.86 178.04,156.73 177.18,156.73 177.16,156.75 177.16,157.51 179.2,159.55 181.74,159.55
LAN2_CTRL_P1V9 on TOP (solid shape): 198.38,148.7 198.38,147.29 198.13,147.03 195.6,147.03 195.22,146.65 195.22,145.39 195.13,145.3 193.56,145.3 192.76,146.1 192.76,148.95 192.78,148.97 198.11,148.97
LAN2_CTRL_P1V9 on IN1 (solid shape): outline of 459 points within 177.64,146.11 194.27,159.43
LAN2_CTRL_P1V9_R on TOP (solid shape): 196.66,151.12 196.66,150.1 196.31,149.74 193.54,149.74 193.54,149.74 192.66,149.74 192.38,150.02 192.38,151.18 192.49,151.28 196.49,151.28
POWER_SW1_PWR_CTR_12V on TOP: 192.07,188.26 191.94,188.13 191.94,186.74 192.4,186.28 197.5,186.28 197.81,186.59 197.81,188.04 197.58,188.26
POWER_SW1_PWR_CTR_12V_R on TOP: 192.24,190.46 191.79,190.02 191.79,188.87 192.12,188.54 197.55,188.54 197.81,188.8 197.81,189.94 197.29,190.46
POWER_SW2_PWR_CTR_12V on TOP (solid shape): 196.59,178.69 196.59,173.18 196.51,173.1 195.12,173.1 194.89,173.33 194.89,178.54 195.22,178.87 196.41,178.87
POWER_SW2_PWR_CTR_12V_R on TOP (solid shape): 199.05,178.64 199.05,173.38 198.75,173.08 197.07,173.08 196.93,173.22 196.93,174.13 196.92,174.14 196.92,178.59 197.2,178.87 198.82,178.87
POWER_SW3_PWR_CTR_12V on TOP: 197.91,185.17 196.64,185.17 196.56,185.09 196.56,180.05 196.56,180.04 196.56,179.46 196.61,179.4 197.83,179.4 198.16,179.73 198.16,184.91
POWER_SW3_PWR_CTR_12V_R on TOP (solid shape): 196.26,185.06 196.26,179.55 196.03,179.32 195.2,179.32 194.33,180.2 194.32,180.2 194.13,180.39 194.13,185.09 194.2,185.17 196.16,185.17
PV_VCCP_NODE1 on TOP (solid shape): 118.2,116.63 120.43,116.63 120.52,116.6 120.55,116.51 120.55,116.25 120.6,116.25 120.64,116.25 120.68,116.22 120.93,116.13 121.19,116.22 121.23,116.25 121.27,116.25 121.32,116.25 121.32,116.51 121.35,116.6 121.44,116.63 125.75,116.63 126.03,116.35 126.03,104.7 125.13,103.8 117.99,103.8 117.54,104.24 117.54,113.61 117.12,114.04 115.89,114.04 115.69,114.23 115.69,117.61 115.89,117.8 117.03,117.8
PV_VCCP_NODE1 on TOP (solid shape): outline of 209 points within 74.64,78.06 96.24,81.39
PV_VCCP_NODE1 on BOTTOM (solid shape): 118.2,116.63 125.66,116.63 126.37,115.92 126.37,104.72 125.44,103.8 117.99,103.8 117.54,104.24 117.54,113.61 117.12,114.04 115.89,114.04 115.69,114.23 115.69,117.61 115.89,117.8 117.03,117.8
PV_VCCP_NODE1 on BOTTOM (solid shape): 93.84,80.76 93.89,80.75 93.93,80.72 94.26,80.38 94.26,79.54 94.05,79.33 90.89,79.33 90.5,79.71 90.4,79.71 85.95,79.71 85.95,79.71 82.95,79.71 82.55,79.32 82.55,79.11 82.46,79.01 82.35,78.95 82.23,78.95 82.19,78.99 81.89,79.14 81.56,79.06 81.53,79.04 80.19,79.04 80.1,78.94 79.84,78.94 79.74,79.05 79.03,79.05 78.79,79.29 78.78,79.31 78.69,79.44 78.57,79.52 78.54,79.53 78.52,79.55 78.16,79.55 77.72,79.11 77.41,79.11 77.33,79.12 77.25,79.11 76.59,79.11 76.46,79.24 74.43,79.24 74.32,79.14 73.99,79.14 73.9,79.18 73.86,79.27 73.86,79.62 74,79.76 75.94,79.76 76.19,80 76.19,80.38 76.26,80.46 76.62,80.46 76.74,80.34 77.24,80.34 77.27,80.37 88.26,80.37 88.65,80.76
PV_VCCP_NODE1 on VCC1 (solid shape): outline of 556 points within 74.85,68.94 134.05,116.9
PV_VCCP_NODE1 on VCC2 (solid shape): outline of 443 points within 74.72,70.22 134.18,116.83
PV_VDDR_NODE1 on TOP (solid shape): 130.05,28.68 130.05,26.73 129.95,26.62 128.88,26.62 128.79,26.53 128.79,25.44 128.61,25.26 127.94,25.26 127.85,25.3 127.81,25.39 127.81,28.45 127.79,28.48 127.79,28.64 127.9,28.75 129.98,28.75
PV_VDDR_NODE1 on TOP (solid shape): outline of 102 points within 63.58,7.11 95.3,19.59
PV_VDDR_NODE1 on BOTTOM (solid shape): 77,14.74 77,9.07 76.43,8.51 76.43,7.47 76.08,7.11 65.58,7.11 63.58,9.11 63.58,13.17 64.15,13.74 67.23,13.74 68.31,14.81 76.93,14.81
PV_VDDR_NODE1 on BOTTOM (solid shape): outline of 100 points within 73.15,66.76 78.62,69.45
PV_VDDR_NODE1 on BOTTOM (solid shape): outline of 2070 points within 64.73,40.55 86.96,68.69
PV_VDDR_NODE1 on BOTTOM (solid shape): outline of 5952 points within 67.38,17.77 131.27,40.15
PV_VDDR_NODE1 on GND1 (solid shape): outline of 122 points within 68.46,18.51 96.51,68.53
PV_VDDR_NODE1 on VCC1 (solid shape): outline of 838 points within 13.05,1.02 96.26,69.58
PV_VDDR_NODE1 on VCC2 (solid shape): outline of 105 points within 61.14,16.42 95.95,69.81
PV_VDDR_NODE1 on IN2 (solid shape): outline of 8049 points within 44.02,24.34 98.32,68.68
