# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SATA_SPI_CS_NODE1_R: length 11.5
  TOP w0.102: U30.48 157.16,69.55 157.24,69.62 157.24,70.2 156.6,70.84 156.6,74.62 155.69,75.54 154.86,75.54 v1(154.66,75.74) 154.31,75.39 R507.2
SATA_SPI_DI_NODE1: length 42
  TOP w0.102: v1(156.02,73.63) 156.3,73.35 156.3,70.74 156.91,70.13 156.91,69.67 156.76,69.53 U30.49 ; R519.2 144.03,59.51 144.03,59.51 144.03,58.64 144.8,57.87 v1(147.72,57.87)
  BOTTOM w0.102: v1(147.72,57.87) 147.61,57.98 147.61,62.12 147.43,62.3 145.57,62.3 145.39,62.47 145.39,62.73 145.57,62.91 147.43,62.91 147.61,63.08 147.61,63.34 147.43,63.51 145.57,63.51 145.39,63.69 145.39,63.95 145.57,64.12 147.43,64.12 147.61,64.3 147.61,65.88 148.36,66.62 148.36,71.87 149.47,72.98 153.52,72.98 153.74,73.2 155.59,73.2 v1(156.02,73.63)
SATA_SPI_DI_NODE1_R: length 6.3
  TOP w0.102: U31.2 143.39,64.92 v1(143.01,64.54) 143.01,64.54 142.85,64.37 142.85,62.35 143.01,62.18 R516.1 R519.1
SATA_SPI_DO_NODE1: length 35.5
  TOP w0.102: R506.1 150.5,76.49 150.33,76.65 150.33,76.88 150.5,77.04 153.61,77.04 153.77,77.21 153.77,77.44 153.61,77.6 150.5,77.6 150.33,77.77 150.33,78 150.5,78.16 153.17,78.16 153.33,78.33 153.33,78.56 153.17,78.72 149.94,78.72 149.77,78.56 149.77,76.03 149.57,75.82 148.7,75.82 146.68,73.8 v1(146.68,71.15) 144.48,68.94 143.18,68.94 141.7,67.46 U31.5
SATA_SPI_DO_NODE1_R: length 12.6
  TOP w0.102: R506.2 153.88,76.49 154.05,76.66 155.74,76.66 v1(155.78,76.62) 156.88,75.52 156.88,71.04 157.56,70.36 U30.47
SATA_TX0_C_DN: length 32.3
  TOP w0.104: C490.1 168.02,65.71 168.41,65.71 169.21,64.9 169.21,64.65 169.44,64.43 169.69,64.43 169.91,64.21 169.91,63.96 170.13,63.74 170.38,63.74 170.6,63.52 170.6,63.26 170.82,63.04 171.08,63.04 171.3,62.82 171.3,62.57 171.52,62.35 171.77,62.35 171.99,62.13 171.99,61.87 172.21,61.65 172.47,61.65 172.69,61.43 172.69,61.18 172.91,60.96 173.16,60.96 173.38,60.74 173.38,60.49 173.6,60.26 173.85,60.26 175.71,58.41 175.71,57.88 176.94,56.65 176.94,51.3 174.76,49.12 174.57,49.12 174.35,48.9 174.35,48.7 174.13,48.48 173.93,48.48 173.71,48.26 173.71,48.07 173.49,47.85 173.3,47.85 173.07,47.63 173.07,47.43 172.85,47.21 172.66,47.21 172.44,46.99 172.44,46.8 172.2,46.56 171.15,46.56 v1(170.73,46.98)
  BOTTOM w0.104: v1(170.73,46.98) 170.29,46.53 168.04,46.53 J7.3
SATA_TX0_C_DP: length 32.2
  TOP w0.104: v1(170.73,45.71) 171.15,46.13 172.38,46.13 177.38,51.12 177.38,56.83 176.14,58.06 176.14,58.59 168.59,66.14 168.14,66.14 C489.1
  BOTTOM w0.104: v1(170.73,45.71) 170.34,46.1 168.04,46.1 J7.2
SATA_VCONT_NODE1: length 15.4
  IN1 w0.457: v1(149.01,67.84) 151.76,70.59 154.05,70.59 154.94,71.48 154.95,71.48 155.08,71.61 156.37,71.61 156.93,71.05 160.96,71.05 v1(162.11,69.9)
SDC_RST_N: length 15.9
  TOP w0.102: v1(95.06,171.74) 94.46,172.35 94.46,178.49 v1(94.36,178.59) 94.53,178.76 U128.8
  IN3 w0.114: v1(95.06,171.74) 97.16,169.65 v1(97.22,169.65)
  BOTTOM w0.102: v1(97.22,169.65) 97.74,169.13 97.74,167.93 98.71,166.95 U73.3
SDC_WAKEUP: length 4.6
  BOTTOM w0.102: R782.1 R783.2 91.72,164.38 v2(92.34,165) 93.01,165.67 93.01,165.67 93.01,165.91 93.41,166.3 U73.13
SEL_DOT_SRC5: length 6.2
  TOP w0.102: R20.1 151.91,112.53 R24.2 151.34,112.53 v1(150.81,113.06) 150.52,113.35 150.52,114.46 149.99,114.99 149.48,114.99 149.16,115.31 U1.16
SEL_PCI_27M: length 6.6
  TOP w0.102: R12.1 153.94,117.54 152.51,117.54 R18.2 151.56,117.01 v1(151.13,117.44) 150.48,117.44 150.19,117.15 149.71,117.15 149.55,117.31 U1.21
SIO_AVCC:
  vias: v1(153.76,28) v1(155.82,27.72)
SIO_CLKIN: length 2.9
  TOP w0.102: U43.49 132.46,39.89 v1(132.42,39.94) R815.2
SIO_COPEN_N: length 6.4
  TOP w0.102: U43.68 138.29,28.95 138.19,28.85 137.36,28.85 137.02,28.51 135.2,28.51 v1(135.06,28.65) 134.85,28.45 R624.1
SIO_CPLD_RSV1_R: length 16.2
  TOP w0.102: U43.111 155.94,36.39 155.32,35.77 153.07,35.77 152.29,36.54 v1(152.1,36.54)
  BOTTOM w0.102: R1078.1 155.54,35.67 153.2,35.67 152.33,36.54 v1(152.1,36.54) 151.77,36.87 149.88,36.87 149.6,36.6 R1182.1 149.53,36.36 R1181.2
SIO_CPLD_RSV2_R: length 15.4
  TOP w0.102: v1(152.28,35.19) 155.34,35.19 156.04,35.89 U43.110
  BOTTOM w0.102: R1193.1 156.29,35.41 152.51,35.41 v1(152.28,35.19) 151.52,35.95 150.01,35.95 149.6,35.54 R1184.1 149.56,35.37 R1183.2
SIO_CPLD_RSV3_R: length 16.3
  TOP w0.102: v1(151.88,33.68) 151.88,33.68 152.92,34.72 155.38,34.72 156.05,35.39 U43.109
  BOTTOM w0.102: R1194.1 154.31,34.65 153.35,33.68 v1(151.88,33.68) 149.93,33.68 149.6,34.01 R1186.1 148.69,34.4 148.62,34.33 R1185.2
SIO_GPIO47: length 4.5
  TOP w0.102: U43.71 139.79,29.25 138.73,28.18 138.18,28.18 v1(137.6,27.6) 137.24,27.25 R1150.2
SIO_JTAG_CPLD1_TCK: length 2.6
  TOP w0.102: R1267.2 R1270.1 v1(201.39,125.09) R1287.1
SIO_JTAG_CPLD1_TCK_R: length 172.6
  TOP w0.102: R1267.1 206.8,124.08 207.89,122.99 207.89,100.37 202.08,94.56 202.08,88.36 182.7,68.99 171.06,68.99 165.25,74.81 165.25,80.72 162.63,83.34 151.6,83.34 148.71,80.45 148.71,77.52 145,73.82 145,72.06 144.44,71.5 144.42,71.5 141.85,68.93 137.07,68.93 135.15,67.01 135.15,64.01 132.25,61.11 132.25,51.79 v1(131.74,51.28) ; U43.58 132.47,35.39 v1(132.23,35.64)
  BOTTOM w0.102: v1(131.74,51.28) 131.74,49.17 131.13,48.56 131.13,41.91 131.62,41.43 131.62,39.7 131.16,39.24 R1291.1 131.52,36.34 v1(132.23,35.64)
SIO_JTAG_CPLD1_TDI: length 4
  TOP w0.102: R1265.2 R1266.1 v3(201.52,120.65) R1285.1
SIO_JTAG_CPLD1_TDI_R: length 170.7
  TOP w0.102: R1265.1 204.82,121.67 205.68,120.8 205.68,99.71 200.98,95.01 200.98,88.81 181.77,69.6 171.32,69.6 165.85,75.06 165.85,80.9 162.93,83.82 151.4,83.82 148.3,80.72 148.3,77.7 144.67,74.07 144.67,72.36 141.57,69.27 136.9,69.27 134.71,67.08 134.71,64.34 131.77,61.39 131.77,53.98 v1(130.45,52.65) ; v1(131.01,34.49) 132.5,34.49 132.9,34.89 U43.59
  BOTTOM w0.102: v1(131.01,34.49) 130.52,34.98 130.52,39.34 131.29,40.11 131.29,41.05 130.52,41.81 130.52,50.44 R1289.1 130.14,52.34 v1(130.45,52.65)
SIO_JTAG_CPLD1_TDO: length 157.9
  TOP w0.102: v1(173.32,67.41) 182.31,67.41 202.91,88.01 202.91,94.21 208.73,100.03 208.73,125.96 205.35,129.34 199.26,129.34 198.56,128.65 R1286.1 R1290.1 ; U43.91 149.79,41.62 151.5,43.33 153.92,43.33 157.22,46.63 163.11,46.63 163.98,45.77 163.98,44.12 164.89,43.21 v1(174.39,43.21)
  BOTTOM w0.102: v1(173.32,67.41) 173.32,62.23 173.83,61.72 173.83,61.75 175.18,60.4 175.18,43.99 v1(174.39,43.21)
SIO_JTAG_CPLD1_TMS: length 3.9
  TOP w0.102: R1268.2 R1269.1 199.46,126.19 199.26,125.98 R1272.1 v1(198.61,125.11)
SIO_JTAG_CPLD1_TMS_R: length 181.6
  TOP w0.102: R1268.1 205.53,127.25 208.35,124.43 208.35,100.18 202.53,94.37 202.53,88.17 182.79,68.43 170.83,68.43 164.69,74.57 164.69,80.39 162.25,82.83 151.81,82.83 149.12,80.14 149.12,77.32 145.51,73.71 145.51,71.96 142,68.45 137.08,68.45 135.55,66.93 135.55,63.3 132.81,60.55 132.81,51.82 v1(133.04,51.59) ; v1(131.49,33.89) U43.61
  BOTTOM w0.102: v1(131.49,33.89) 132.71,35.1 132.71,36.17 131.79,37.08 131.79,38.58 132.96,39.75 132.96,40.13 131.95,41.15 131.95,41.66 131.64,41.96 131.64,48.29 133.04,49.68 v1(133.04,51.59) 133.44,51.99 R1288.1
SIO_JTAG_CPLD2_TCK: length 6.4
  BOTTOM w0.102: R1192.1 147.63,41.79 147.59,41.83 R1119.1 148.55,42.5 148.93,42.88 v2(148.93,42.88) 149.8,42.88 150.17,42.51 150.33,42.51 151.55,41.29 R1189.2
SIO_JTAG_CPLD2_TCK_R: length 9.4
  TOP w0.102: v1(153.78,39.18) 155.94,39.18 156.23,38.89 U43.116
  BOTTOM w0.102: R1189.1 152.94,40.02 v1(153.78,39.18) 154.93,39.18 155.47,39.73 R816.1
SIO_JTAG_CPLD2_TDI: length 6.6
  BOTTOM w0.102: R1187.2 148.62,37.44 148.55,37.38 R1188.1 147.11,37.9 145.89,37.9 v2(144.9,38.89) 144.72,39.06 R1081.1
SIO_JTAG_CPLD2_TDI_R: length 11.7
  TOP w0.102: v1(153.85,36.2) 153.85,36.31 154.93,37.39 U43.113
  BOTTOM w0.102: R1077.1 156.54,37.43 155.31,36.2 v1(153.85,36.2) 153.55,36.2 152.49,37.26 151.83,37.26 151.65,37.44 R1187.1
SIO_JTAG_CPLD2_TDO: length 11.3
  TOP w0.102: v1(151.83,40) 153.21,38.61 156,38.61 156.22,38.39 U43.115
  BOTTOM w0.102: 151.83,39.95 v1(151.83,40) ; 151.83,39.95 150.4,41.37 R1080.1 ; 151.83,39.95 153.43,38.34 R1056.1
SIO_JTAG_CPLD2_TMS: length 6.4
  BOTTOM w0.102: R1190.2 148.55,39.48 148.48,39.41 R1191.1 147.09,39.94 145.65,39.94 145.1,40.49 v2(144.9,40.49) 144.76,40.62 R1079.1
SIO_JTAG_CPLD2_TMS_R: length 9
  TOP w0.102: v1(151.87,38.53) 152.67,37.72 155.64,37.72 155.8,37.89 U43.114
  BOTTOM w0.102: R1065.1 R1190.1 150.92,39.48 v1(151.87,38.53)
SIO_JTAG_CPLD3_TCK: length 82.4
  TOP w0.102: R1200.1 v1(183.72,13.66)
  BOTTOM w0.102: R1207.2 R1210.1 142.03,37.26 v2(142.23,37.47) 143.88,37.47 145.94,35.41 145.94,34.39 147.16,33.17 155.37,33.17 159.61,28.93 159.61,22.94 156.66,19.99 156.66,7.26 158.67,5.26 169.41,5.26 172.18,8.03 172.18,12.7 174.19,14.71 182.67,14.71 v1(183.72,13.66)
SIO_JTAG_CPLD3_TCK_R: length 10
  TOP w0.102: U43.52 135.44,38.39 135.85,37.97 137.47,37.97 v1(137.63,37.81)
  BOTTOM w0.102: R1204.1 135.16,38.45 135.47,38.14 137.3,38.14 v1(137.63,37.81) 138.56,37.81 139.02,38.27 R1207.1
SIO_JTAG_CPLD3_TDI: length 71
  TOP w0.102: R1198.1 v1(174.58,13.68)
  BOTTOM w0.102: R1205.2 R1206.1 142.18,36.12 142.74,36.68 143.71,36.68 144.54,35.84 144.54,35.16 v2(144.73,34.97) 144.73,34.56 146.91,32.38 154.98,32.38 157.98,29.39 157.98,23.09 156,21.11 156,6.96 158.51,4.45 170,4.45 172.99,7.44 172.99,12.09 v1(174.58,13.68)
SIO_JTAG_CPLD3_TDI_R: length 9
  TOP w0.102: v1(137.11,36.13) 136.87,35.89 U43.57
  BOTTOM w0.102: R1202.1 136.53,36.41 136.81,36.13 v1(137.11,36.13) 137.12,36.12 R1205.1
SIO_JTAG_CPLD3_TDO: length 87.9
  TOP w0.102: U43.54 136.06,37.39 v1(136.13,37.46) ; R1199.1 v1(182.21,13.63)
  BOTTOM w0.102: v1(182.21,13.63) 181.64,14.2 174.21,14.2 172.61,12.6 172.61,7.7 169.79,4.88 158.57,4.88 156.33,7.11 156.33,20.75 158.35,22.77 158.35,29.53 155.11,32.77 147.06,32.77 145.42,34.41 145.42,35.45 143.83,37.03 142.56,37.03 142.18,36.65 139.17,36.65 138.82,37 136.59,37 v1(136.13,37.46) 136.1,37.43 R1203.1
SIO_JTAG_CPLD3_TMS: length 74.3
  TOP w0.102: R1197.1 v1(179.66,13.65)
  BOTTOM w0.102: R1208.2 142.15,34.97 R1209.1 142.15,34.37 v2(142.72,33.81) 144.75,33.81 146.53,32.03 154.76,32.03 157.63,29.16 157.63,23.91 155.67,21.95 155.67,6.81 158.44,4.04 170.2,4.04 173.4,7.24 173.4,10.62 175.81,13.03 179.04,13.03 v1(179.66,13.65)
SIO_JTAG_CPLD3_TMS_R: length 12.1
  TOP w0.102: v1(139.09,34.66) 139.09,34.76 137.29,36.56 136.41,36.56 136.24,36.39 U43.56
  BOTTOM w0.102: R1201.1 138.35,35.4 v1(139.09,34.66) 139.4,34.97 R1208.1
SIO_LRESET_N: length 4
  TOP w0.102: R621.2 136.31,49.68 v1(135.94,49.31) 136.24,49.02 136.76,49.02 137.29,48.48 U43.37
SIO_PCICLK33: length 3.2
  TOP w0.102: U43.47 132.95,40.89 v1(132.63,41.2) 132.31,41.53 R625.2
SIO_PIN38: length 4.3
  TOP w0.102: U43.38 136.79,48.24 136.51,48.53 136.02,48.53 v1(135.57,48.08) 135.04,48.61 R617.2
SIO_PIN45: length 3.5
  TOP w0.102: U43.45 136.06,41.89 v1(136.53,41.42)
  BOTTOM w0.102: v1(136.53,41.42) 137.02,41.42 137.23,41.21 R1138.2
SIO_PIN72: length 4.3
  TOP w0.102: U43.72 140.29,29.19 139.11,28 v1(139.11,27.74) 138.51,27.74 138.26,27.49 R1143.2
SIO_PIN73: length 3.7
  TOP w0.102: R1140.2 139.28,27.26 140.24,28.23 v1(140.24,28.38) 140.79,28.94 U43.73
SIO_PIN75: length 3.7
  TOP w0.102: R1142.2 140.29,27.48 v1(141.49,28.69) 141.79,28.99 U43.75
SIO_PIN76: length 3.9
  TOP w0.102: R1141.2 141.31,27.22 141.68,27.59 v1(142.3,27.59) 142.29,27.6 U43.76
SIO_PIN78: length 3.7
  TOP w0.102: R1144.2 142.58,26.97 142.88,27.27 142.88,28.48 v1(143.13,28.73) 143.29,28.89 U43.78
SIO_PIN80: length 3.8
  TOP w0.102: R1145.2 143.34,27.32 143.59,27.57 v1(144.02,27.57) 144.02,28.86 144.29,29.14 U43.80
SIO_PIN81: length 3.3
  TOP w0.102: U43.81 144.79,28.93 v1(144.65,28.78) 144.65,27.48 144.36,27.18 R1146.2
SIO_PIN82: length 3.5
  TOP w0.102: U43.82 145.29,28.07 v1(145.85,27.51) 145.37,27.03 R1147.2
SIO_PIN83: length 3.4
  TOP w0.102: U43.83 145.79,29.05 v1(146.05,28.8) 146.05,28.31 146.39,27.97 R1148.2
SIO_PWROK2: length 4.1
  TOP w0.102: v1(135.95,38.65) 135.7,38.89 U43.51
  BOTTOM w0.102: R620.2 137.67,39.62 136.7,38.65 v1(135.95,38.65)
SIO_VBAT: length 11.1
  TOP w0.254: D6.2 133.54,25.16 133.9,24.8 135.22,24.8 135.54,25.11 135.54,26.78 135.73,26.97 C486.1 v1(136.1,27.84) 136.98,27.84 137.65,28.52 138.33,28.52 138.79,28.98 U43.69
SIO_VCCH: length 2.2
  TOP w0.254: U43.67 137.79,31.19 137.18,31.81 v1(136.97,31.81)
  vias: v1(135.77,31.34) v1(137.74,33.86) v2(136.54,31.08)
SIO_VREF: length 3.7
  TOP w0.102: U43.90 149.29,27.85 v1(149.07,27.62) 148.71,27.62 148.42,27.33 C485.1
SMB_BMC_NODE1_DDC_CLK: length 177.5
  TOP w0.102: D7.1 35.14,67.95 v1(32.65,65.46) 32.45,65.26 R633.2 31.95,64.47 31.47,63.99 Q17.S ; v1(73.81,145.8) 73.81,142.83 U14.T2
  IN2 w0.114: v1(32.65,65.46) 29.99,65.46 29.79,65.66 29.79,67.15 29.99,67.36 31.39,67.36 31.61,67.58 31.61,67.89 31.39,68.11 30.06,68.11 29.86,68.31 29.86,68.65 30.06,68.85 32.92,68.85 33.13,69.06 33.13,69.4 32.92,69.6 29.85,69.6 29.73,69.73 29.73,70.66 29.95,70.88 31.02,70.88 31.24,71.1 31.24,71.41 31.02,71.63 29.95,71.63 29.73,71.85 29.73,72.66 29.25,73.14 29.25,73.45 30.21,74.41 30.21,74.72 29.99,74.94 29.68,74.94 28.72,73.98 28.41,73.98 27.72,74.67 27.72,75.85 27.94,76.07 30.57,76.07 30.77,76.27 30.77,76.62 30.57,76.82 27.94,76.82 27.72,77.04 27.72,77.35 27.94,77.57 29.07,77.57 29.27,77.77 29.27,78.11 29.07,78.32 27.94,78.32 27.72,78.54 27.72,87.73 24.1,91.35 24.1,91.39 18.6,96.89 18.6,136.37 22.01,139.78 24.08,139.78 24.14,139.84 24.14,139.84 24.59,140.28 27.75,140.28 28.88,141.41 31.81,141.41 32.28,141.88 33.81,141.88 34.11,141.58 42.2,141.58 47.92,147.3 50.3,147.3 51.34,148.34 51.34,148.34 51.6,148.6 51.6,148.6 51.77,148.77 51.82,148.77 52.41,149.35 52.41,149.51 53.38,150.47 61.1,150.47 61.34,150.23 63.84,150.23 64.32,149.74 66.64,149.74 67.69,148.7 70.82,148.7 73.71,145.8 v1(73.81,145.8)
SMB_BMC_NODE1_DDC_DAT: length 189
  TOP w0.102: U14.T1 74.18,143.26 74.48,143.56 v1(74.48,146.06) ; Q18.S 36.78,47.2 37.29,47.2 38.01,46.49 R632.2 37.48,44.5 37.13,44.15 D8.1 37.13,40.07 36.39,39.33 31.68,39.33 v1(31.34,39.66)
  IN2 w0.114: v1(31.34,39.66) 29.77,39.66 27.67,41.77 27.67,56.31 29.2,57.84 29.2,72.45 27.19,74.46 27.19,87.52 23.58,91.13 23.58,91.18 18.08,96.67 18.08,136.58 21.79,140.3 23.86,140.3 24.37,140.8 27.54,140.8 28.67,141.93 31.26,141.93 32.2,142.87 33.08,142.87 33.34,142.61 33.99,142.61 34.37,142.24 42.12,142.24 47.81,147.93 50.09,147.93 53.16,151 61.65,151 61.88,150.77 66.46,150.77 67.97,149.25 71.74,149.25 74.48,146.51 v1(74.48,146.06)
SMB_BMC_NODE1_HSC_ALERT_L: length 137.1
  TOP w0.102: v1(87.06,95.41) 87.06,101.42 84.17,104.31 54.55,104.31 v1(53.42,103.17) ; R1023.1 47.02,174.07 v1(47.38,174.43) 47.02,174.78 R106.2 ; U2.M60 83.22,83.51 82.9,83.83 82.45,83.83 82.29,84 82.29,84.73 v1(82.46,84.91)
  IN1 w0.114: v1(47.38,174.43) 46.93,173.98 45.72,173.98 43.67,171.93 43.67,142.57 44.31,141.94 44.31,137.71 48.12,133.9 48.12,123.89 52.66,119.35 52.66,111.16 52.63,111.13 52.63,103.96 v1(53.42,103.17)
  BOTTOM w0.102: v1(87.06,95.41) 87.06,95.17 86.08,94.18 86.08,91.09 85.31,90.32 85.31,89.1 86.15,88.26 86.15,86.28 85.9,86.03 85.11,86.03 84.79,85.72 83.88,85.72 83.63,85.47 83.02,85.47 v1(82.46,84.91)
SMB_BMC_NODE1_HSC_ALERT_R_L: length 2.5
  TOP w0.102: U100.10 46.67,177.12 46.83,176.96 v1(47.27,176.96) 47.27,176.49 47.02,176.24 R106.1
SMB_CPU_NODE1_BMC_CLK: length 234.1
  TOP w0.102: v1(158.09,140.9) 157.79,141.2 R232.1 ; U100.6 44.67,177.13 43.81,176.27 43.81,173.96 44.48,173.29 44.51,173.29 v1(45.12,172.68)
  IN1 w0.114: v1(158.09,140.9) 158.09,141.47 158.61,141.99 158.61,142.84 156.97,144.49 156.97,149.71 152.38,154.3 144.15,154.3 143.08,155.36 140.67,155.36 140.44,155.59 134.12,155.59 127.29,148.75 124.81,148.75 124.47,148.41 102.26,148.41 97.59,153.08 97.59,158.93 97.59,158.94 97.59,159.35 97.59,159.35 96.38,160.56 93.64,160.56 92.59,161.6 91.54,161.6 91.31,161.84 90.94,161.84 90.57,161.47 88.63,161.47 87.95,162.15 87.95,163.27 87.69,163.52 87.14,163.52 84.53,166.14 82.56,166.14 81.81,166.88 79.89,166.88 79.7,166.69 74.13,166.69 73.68,166.24 62.37,166.24 59.35,169.26 49.41,169.26 48.84,169.83 48.84,172.1 47.93,173.02 46.04,173.02 45.71,172.68 v1(45.12,172.68) 45.12,170.44 44.17,169.49 44.17,143.52 44.8,142.89 44.8,137.99 48.62,134.18 48.62,124.1 53.65,119.06 53.65,103.64 53.91,103.38 53.91,98.61 v1(52.85,97.55)
  BOTTOM w0.102: R130.2 51.68,94.81 R131.2 51.97,96.67 v1(52.85,97.55)
SMB_CPU_NODE1_BMC_CLK_RR: length 21.3
  TOP w0.102: U2.Y13 59.73,79.3 v1(59.34,78.91)
  BOTTOM w0.102: R130.1 C30.2 50.66,93.36 51.42,92.6 v2(52.32,92.6) 55.6,89.32 55.6,83.33 57.43,81.5 57.43,80.06 57.66,79.83 58.57,79.83 59.34,79.06 v1(59.34,78.91)
SMB_CPU_NODE1_BMC_DAT: length 232.2
  TOP w0.102: R233.1 v1(158.12,142.2) ; U100.7 45.17,176.81 45.17,176.81 44.29,175.93 44.29,174.16 44.68,173.77 45.14,173.77 v1(46.39,172.52)
  IN1 w0.114: v1(158.12,142.2) 158.12,142.64 156.47,144.28 156.47,149.51 152.83,153.14 151.96,153.14 151.95,153.14 151.59,153.14 150.93,153.8 143.94,153.8 143.62,154.12 141.2,154.12 140.56,154.77 140.56,154.77 140.23,155.09 134.33,155.09 126.8,147.56 101.29,147.56 97.1,151.75 97.1,159.14 96.17,160.06 93.43,160.06 92.72,160.78 90.86,160.78 90.43,160.35 88.15,160.35 84.48,164.02 84.48,164.69 83.53,165.64 82.21,165.64 82,165.85 80.25,165.85 80.12,165.72 79.45,165.72 79.16,166.01 74.62,166.01 73.91,165.3 68.39,165.3 68.07,165.62 62.29,165.62 59.74,168.17 56.24,168.17 55.64,168.77 49.21,168.77 48.31,169.66 48.31,171.93 47.72,172.52 v1(46.39,172.52) 46.39,169.79 44.81,168.21 44.81,143.87 45.33,143.35 45.33,138.17 49.11,134.38 49.11,124.52 54.15,119.48 54.15,103.87 54.41,103.61 54.41,100.39 v1(56.65,98.15)
  BOTTOM w0.102: R132.2 57.77,96.61 R133.2 57.7,96.73 56.65,97.78 v1(56.65,98.15)
SMB_CPU_NODE1_BMC_DAT_RR: length 17.4
  TOP w0.102: v1(61.3,80.53) 61.26,80.5 U2.W16
  BOTTOM w0.102: R132.1 C31.2 56.75,93.26 58.46,91.55 v2(58.46,89.44) 58.46,85.97 58.46,85.97 58.46,82.92 60.2,81.18 61.1,81.18 61.3,80.99 v1(61.3,80.53)
SMB_CPU_NODE1_MEM_ICS_CLK_R: length 21.7
  TOP w0.102: v1(58.58,78.91) 58.97,79.3 U2.Y11
  BOTTOM w0.102: v1(58.58,78.91) 57.94,79.55 57.27,79.55 55.12,81.69 55.12,87.7 51.4,91.42 50.55,91.42 48.62,93.35 C28.2 R125.1
SMB_CPU_NODE1_MEM_ICS_DAT_R: length 17.7
  TOP w0.102: v1(59.37,80.55) 59.74,80.18 U2.W13
  BOTTOM w0.102: v1(59.36,80.55) 59.21,80.7 59.21,81.57 57.89,82.89 57.89,91.09 57.39,91.59 56.91,91.59 v2(56.45,92.05) 55.86,92.05 54.72,93.19 C29.2 R128.1
SMB_CPU_NODE1_XDP_CLK: length 119.9
  TOP w0.102: v1(115.87,80.53) 110.19,74.86 110.19,65.31 113.12,62.38 114.59,62.38 115.61,63.41 J3.53
  IN1 w0.114: v1(106.33,104.87) 106.33,103.74 107.41,102.66 107.41,101.54 107.82,101.13 107.82,86.54 111.44,82.91 113.48,82.91 v1(115.87,80.53)
  IN3 w0.114: v1(52.9,96.59) 53.28,96.21 59.25,96.21 60.67,97.64 60.67,100.93 61.41,101.67 61.41,102.55 61.74,102.87 70.6,102.87 71.81,101.67 76.3,101.67 77.68,103.05 84.42,103.05 87.99,106.62 93.49,106.62 94.24,105.87 96.44,105.87 97.05,105.26 99.48,105.26 99.87,104.87 v1(106.33,104.87)
  BOTTOM w0.102: R121.2 53.62,94.88 R122.2 v1(52.9,96.59)
SMB_CPU_NODE1_XDP_CLK_R: length 17.6
  TOP w0.102: U2.W11 58.97,80.12 v1(58.57,80.52)
  BOTTOM w0.102: R121.1 C26.2 52.69,93.52 56.02,90.18 56.02,84.36 58.57,81.81 v1(58.57,80.52)
SMB_CPU_NODE1_XDP_DAT: length 113.9
  TOP w0.102: J3.51 115.41,63.91 114.36,62.86 113.32,62.86 110.67,65.51 110.67,74.28 116.49,80.1 v1(116.49,80.39)
  IN1 w0.114: v1(104.96,105.38) 104.96,104.41 106.91,102.46 106.91,101.33 107.32,100.92 107.32,86.33 111.23,82.42 111.24,82.42 111.36,82.29 113.28,82.29 115.54,80.04 116.14,80.04 v1(116.49,80.39)
  IN3 w0.114: v1(104.96,105.38) 100.41,105.38 99.19,106.6 97.21,106.6 96.59,107.23 93.11,107.23 92.77,107.57 92.4,107.57 91.95,107.11 87.73,107.11 84.24,103.63 77.46,103.63 76.53,102.69 72.41,102.69 71.73,103.37 61.37,103.37 59.88,101.88 59.88,97.54 v1(59.04,96.7)
  BOTTOM w0.102: R123.2 59.8,96.68 R124.2 v1(59.04,96.7)
SMB_CPU_NODE1_XDP_DAT_R: length 16.8
  TOP w0.102: U2.W17 62.02,80.44 v1(61.94,80.53)
  BOTTOM w0.102: R123.1 C27.2 58.78,92.06 v2(59.01,91.84) 59.01,86.32 59.84,85.49 59.84,83.56 59.84,83.56 59.84,82.01 60.41,81.44 61.13,81.44 61.94,80.64 v1(61.94,80.53)
SMB_DIMM_NODE1_CLK: length 110.8
  TOP w0.102: v1(26.41,5.22) 26.27,5.22 26.24,5.25 25.1,5.25 R471.2 ; v1(115.49,24.16) 115.08,24.57 115.08,29.15 J2.202
  IN2 w0.114: v1(114.73,16.56) 114.27,16.11 113.49,16.11 113.16,16.44 111.25,16.44 110.78,16.91 79.02,16.91 76.5,17.86 42.19,17.86 39.56,15.23 36.51,15.23 26.5,5.22 v1(26.41,5.22)
  BOTTOM w0.102: v1(115.49,24.16) 115.49,17.7 114.73,16.94 v1(114.73,16.56)
SMB_DIMM_NODE1_DAT: length 109.8
  TOP w0.102: v1(25.95,6.49) 25.91,6.49 25.17,5.75 24.58,5.75 R472.2 ; J2.200 114.48,29.15 114.48,24.22 v1(114.85,23.85)
  IN2 w0.114: v1(25.95,6.49) 35,15.54 39.17,15.54 41.75,18.12 76.55,18.12 79.07,17.18 110.92,17.18 111.32,16.78 113.71,16.78 v1(113.94,16.55)
  BOTTOM w0.102: v1(113.94,16.55) 115.22,17.83 115.22,23.35 114.85,23.71 v1(114.85,23.85)
SMB_LAN1_ALT_N: length 9.2
  TOP w0.102: U35.35 59.35,160.5 60.6,161.75 61.43,161.75 v1(62.19,162.51) 63.06,163.38 R538.2 62.86,163.5 62.49,163.87 62.49,165.46 R561.2
SMB_LAN1_CLK: length 10
  TOP w0.102: R563.2 63.7,165.53 63.7,163.84 64.04,163.5 R539.2 64.21,162.83 v1(63.61,162.23) 62.64,161.26 60.69,161.26 59.85,160.42 U35.34
SMB_LAN1_DAT: length 8.4
  TOP w0.102: R562.2 61.4,165.52 61.4,164.08 61.92,163.56 R540.2 61.92,163.5 60.76,162.34 v1(60.67,162.34) 60.55,162.34 58.85,160.64 U35.36
SMB_LAN2_ALT_N: length 9.9
  TOP w0.102: U37.35 170.3,147.73 167.29,144.72 165.2,144.72 v1(164.7,144.22) 164.54,144.06 R591.2 R569.2
SMB_LAN2_CLK: length 11.5
  TOP w0.102: R570.2 R593.2 v1(162.51,143.9) 162.51,144.23 163.48,145.2 166.78,145.2 168.3,146.72 168.8,146.72 169.8,147.72 U37.34
SMB_LAN2_DAT: length 8
  TOP w0.102: U37.36 170.8,147.51 v1(167.18,143.89) 166.58,143.29 R592.2 R566.2
SMB_MUX_CPU_ICS_NODE1_CLK: length 251.8
  TOP w0.102: v1(145.04,111.37) 144.58,111.83 144.58,112.93 144.39,113.13 U1.6 ; v1(25.13,4.47) 25.13,4.47 23.94,3.27 23.18,3.27 22.75,3.7 R471.1 22.55,3.9 21.66,3.9 21.41,3.65 U10.3 ; U134.6 35.13,98.45 35.53,98.85 38.21,98.85 39.82,97.24 43.36,97.24 v1(43.8,97.67) 45.22,97.67 46.56,96.33 48.7,96.33 48.72,96.36 50.27,96.36 v1(50.36,96.45) 50.65,96.16 56.76,96.16 59.22,98.63 59.8,98.63 60.1,98.93 U9.12
  IN1 w0.114: v1(145.04,111.37) 144.04,110.37 144.04,106.53 139.98,102.46 130.56,102.46 v1(130.37,102.28)
  IN2 w0.114: v1(25.13,4.47) 24.27,5.34 24.27,8.33 30.39,14.45 30.39,27.76 43.4,40.78 43.4,70.06 42.88,70.59 42.88,81.84 43.8,82.76 v1(43.8,97.67)
  IN3 w0.114: v1(50.36,96.45) 51.15,96.45 51.81,97.1 51.81,97.86 52.73,98.78 54.39,98.78 60.05,104.45 76.82,104.45 77.04,104.67 83.88,104.67 87.95,108.74 92.88,108.74 93.01,108.62 96.36,108.62 96.6,108.37 98.78,108.37 100.86,106.29 112.19,106.29 117.18,101.3 128.72,101.3 129.7,102.28 v1(130.37,102.28)
  BOTTOM w0.102: v1(50.36,96.45) 50.14,96.67 R126.2 49.62,95.85 49.9,95.57 49.9,95.06 R125.2
SMB_MUX_CPU_ICS_NODE1_DAT: length 246.4
  TOP w0.102: U1.5 143.99,113.1 144.3,112.78 144.3,111.22 144.72,110.8 v1(144.72,109.72) ; U10.4 21.41,4.86 21.73,4.54 22.57,4.54 R472.1 v1(22.75,5.47) ; U9.11 60.06,99.58 59.63,99.15 59.06,99.15 56.62,96.7 v1(56.52,96.7) 55.5,96.7 54.53,97.67 54.53,98.22 54.14,98.62 48.75,98.62 48.36,98.23 v1(43.05,98.23) 42.54,97.72 40.02,97.72 38.41,99.33 38.24,99.33 38.23,99.33 34.77,99.33 33.86,98.43 U134.5
  IN1 w0.114: v1(144.72,109.72) 144.54,109.54 144.54,106.32 139.64,101.42 130.5,101.42 v1(130.37,101.56)
  IN2 w0.114: v1(22.75,5.47) 22.75,5.47 23.78,6.49 23.78,8.62 29.84,14.68 29.84,27.99 43.14,41.29 43.14,69.63 42.38,70.39 42.38,70.39 42.38,82.05 43.05,82.72 v1(43.05,98.23)
  IN3 w0.114: v1(130.37,101.56) 129.84,101.04 117.06,101.04 112.1,106 100.77,106 99.59,107.18 97.42,107.18 96.25,108.35 92.17,108.35 91.43,107.61 87.52,107.61 84.09,104.18 77.25,104.18 77.03,103.95 60.85,103.95 59.1,102.21 59.1,99.28 v1(56.52,96.7)
  BOTTOM w0.102: v1(56.52,96.7) R129.2 55.7,94.83 R128.2
SMB_PCH_SCL: length 138
  TOP w0.102: R593.1 162.51,141.53 163.88,140.17 v1(166.03,140.17) ; R563.1 v1(64.21,167.94)
  IN1 w0.114: v1(166.03,140.17) 166.23,140.37 166.23,141.21 166.41,141.38 166.41,143.55 166.67,143.81 166.67,144.18 166.29,144.56 166.29,150.63 166.33,150.67 166.33,154.88 158.97,162.24 156.46,162.24 155.86,162.84 153.28,162.84 152.61,163.51 147.79,163.51 147.02,164.28 141.35,164.28 141.26,164.36 140.9,164.36 140.73,164.19 139.15,164.19 138.48,163.53 137.78,163.53 137.11,162.86 136.34,162.86 135.8,162.32 133.7,162.32 132.84,163.17 132.84,166.01 131.36,167.49 130.67,167.49 130.25,167.07 128.17,167.07 127.68,166.57 125.2,166.57 123.73,168.04 117.51,168.04 117.09,168.46 113.09,168.46 113.09,168.47 112.56,168.47 110.72,166.63 107.12,166.63 106.49,166 104.53,166 104.01,166.52 101.19,166.52 99.26,164.59 98.22,164.59 97.74,164.1 96.21,164.1 96.16,164.06 94.43,164.06 93.74,164.74 88.87,164.74 87.07,166.55 87.07,166.68 86.06,167.69 85.3,167.69 83.92,169.06 82.07,169.06 81.49,168.48 78.81,168.48 78.74,168.41 71.84,168.41 71.38,167.94 v1(64.21,167.94)
SMB_PCH_SDA: length 136.7
  TOP w0.102: v1(166.99,141.63) 166.58,142.04 R592.1 ; v1(62.71,168.44) 61.92,167.65 R562.1
  IN1 w0.114: v1(166.99,141.63) 166.99,143.08 167.62,143.71 167.62,146.83 166.72,147.73 166.72,155.01 159.12,162.61 156.61,162.61 156.02,163.21 153.44,163.21 152.77,163.87 147.99,163.87 147.22,164.65 141.51,164.65 141.42,164.73 140.47,164.73 140.31,164.56 138.96,164.56 138.29,163.89 137.62,163.89 136.95,163.23 135.88,163.23 135.34,162.69 133.85,162.69 133.36,163.17 133.36,166.01 131.51,167.85 130.51,167.85 130.11,167.45 125.35,167.45 125.31,167.41 124.95,167.41 123.72,168.64 118.88,168.64 118.37,169.15 116.66,169.15 116.34,168.83 113.42,168.83 113.41,168.83 111.9,168.83 111.19,168.12 109.78,168.12 109.76,168.14 108.4,168.14 107.71,167.45 105.67,167.45 105.53,167.59 104.19,167.59 104.07,167.71 103.71,167.71 102.89,166.89 101.03,166.89 99.11,164.96 98.07,164.96 97.62,164.51 96.09,164.51 96.01,164.43 94.58,164.43 93.84,165.17 89.59,165.17 89.02,165.74 89.02,166.7 88.1,167.63 86.79,167.63 85.78,168.64 84.88,168.64 83.28,170.24 80.56,170.24 79.67,169.34 71.66,169.34 70.76,168.44 63.97,168.44 63.66,168.12 63.03,168.12 v1(62.71,168.44)
SMB_TEMP1_NODE1_ALERT_L: length 47
  TOP w0.102: U2.H54 80.38,85.76 v1(80.74,86.11) ; v1(84.52,99.2) 85.38,100.06 85.38,102.38 83.96,103.8 59.61,103.8 R199.1
  BOTTOM w0.102: v1(80.74,86.11) 80.78,86.15 80.78,86.74 81.22,87.18 81.22,94.27 81.41,94.46 81.41,95.66 82.53,96.78 82.72,96.78 83.14,97.19 83.14,98.21 83.65,98.73 84.05,98.73 v1(84.52,99.2)
SMB_TEMP1_NODE1_ALERT_R_L: length 5.6
  TOP w0.102: U9.7 61.85,102.37 v1(61.89,102.4) 61.37,102.92 60.34,102.92 59.42,102 R199.2 R198.2
SPC_CPU_NODE1_CTS_L: length 11.5
  TOP w0.102: R71.2 83.34,95.85 81.33,93.84 80.71,93.84 79.34,92.47 v3(78.98,92.47) 78.98,91.95 77.43,90.4 77.43,89.59 77.81,89.21 77.81,88.89 77.75,88.83 U2.C49
SPC_CPU_NODE1_DCD_L: length 14.2
  TOP w0.102: U2.H46 76.22,85.92 76.84,86.55 77.02,86.55 77.45,86.97 77.45,87.83 77.24,88.03 77.13,88.03 76.79,88.37 76.79,88.96 76.65,89.1 76.65,91.2 80.06,94.62 80.6,94.62 v3(81.13,95.14) 82.29,96.31 R67.2
SPC_CPU_NODE1_DSR_L: length 14.3
  TOP w0.102: R69.2 81.31,96.25 77.68,92.62 v3(77.12,92.62) 76.34,91.84 76.34,88.98 76.55,88.77 76.55,88.28 76.67,88.16 76.67,86.83 75.88,86.04 75.88,85.53 75.52,85.17 U2.J44
SPC_CPU_NODE1_DTR_L: length 12.4
  TOP w0.102: R69.1 R67.1 82.83,96.6 82.83,95.98 v1(82.4,95.55) 81.07,94.21 80.49,94.21 79.63,93.35 79.11,93.35 78.45,92.69 78.45,91.81 77.17,90.53 77.17,89.38 U2.A48
SPC_CPU_NODE1_RI_L: length 10.9
  TOP w0.102: v1(77.21,91.19) 76.85,90.83 76.85,89.19 77.15,88.89 U2.B48
  BOTTOM w0.102: R75.2 77.74,95.95 77.14,95.35 v2(77.14,94.24) 77.21,94.17 v1(77.21,91.19)
SPC_CPU_NODE1_RTS_L: length 18.1
  TOP w0.102: v1(80.81,98.21) 80.99,98.38 82.59,98.38 82.78,98.19 82.78,97.3 82.97,97.11 R71.1 ; U2.H50 v1(79.09,85.38)
  BOTTOM w0.102: v1(79.09,85.38) 79.42,85.71 79.42,87.88 79.72,88.18 79.72,90.39 79.73,90.43 79.73,90.47 79.76,90.77 79.76,93.6 80.77,94.62 80.77,98.16 v1(80.81,98.21)
SPI_CPU_NODE1_CS0_L: length 40.4
  TOP w0.102: v1(71.12,100.59) 71.13,100.59 71.42,100.3 71.42,99.3 71.8,98.91 72.26,98.91 74.06,97.11 R57.1 ; U5.1 100.19,99.96 95.75,104.4 94.02,104.4 v1(93.8,104.18)
  BOTTOM w0.102: v1(71.12,100.59) 71.51,100.59 71.96,101.04 77.37,101.04 77.49,101.16 81.54,101.16 82.04,101.66 86.96,101.66 87.52,102.22 90.95,102.22 91.96,103.23 92.85,103.23 v1(93.8,104.18)
SPI_CPU_NODE1_CS0_R_L: length 9
  TOP w0.102: R57.2 74.19,96.04 v3(73.3,95.15) 73.3,94.76 72.84,94.31 72.84,90.79 72.98,90.65 72.98,89.54 73.3,89.22 73.3,88.88 73.25,88.83 U2.C40
SPI_CPU_NODE1_HOLD_L: length 4.1
  TOP w0.102: R177.2 101.19,106.91 v1(101.35,106.75) 101.46,106.64 U4.7 U5.7
SPI_CPU_NODE1_MISO: length 68
  TOP w0.102: R178.1 106.49,94.11 106.49,100.94 v1(109.23,103.68) ; U2.E40 73.19,86.81 72.85,86.47 v1(72.81,86.47)
  BOTTOM w0.102: v1(72.81,86.47) 72.62,86.66 72.62,87.63 v2(73.29,88.31) 73.57,88.59 73.57,92.97 73.23,93.31 73.23,94.31 71.58,95.96 71.58,100.18 72.02,100.62 77.39,100.62 77.62,100.86 81.67,100.86 82.17,101.36 87.06,101.36 87.64,101.94 91.7,101.94 92.63,102.87 93.78,102.87 97.75,106.84 99.08,106.84 99.83,106.09 106.83,106.09 v1(109.23,103.68)
SPI_CPU_NODE1_MISO_R: length 10.8
  TOP w0.102: R178.2 105.69,95.84 106.04,96.19 106.04,97.98 v1(104.64,99.38) 102.67,99.38 101.46,98.17 U5.2
SPI_CPU_NODE1_MOSI: length 40.9
  TOP w0.102: v1(97.56,105.94) 97.56,106.8 96.86,107.51 96.86,108.1 97.72,108.96 103.6,108.96 104,108.57 U4.5 U5.5 ; R58.2 76.49,97.37 v1(76.49,97.85)
  BOTTOM w0.102: v1(97.56,105.94) 94.07,102.44 92.6,102.44 91.74,101.58 87.75,101.58 87.25,101.08 82.37,101.08 81.81,100.52 77.73,100.52 76.49,99.28 v1(76.49,97.85)
SPI_CPU_NODE1_MOSI_R: length 10.1
  TOP w0.102: R58.1 76.23,95.9 74.3,93.98 74.3,92.48 v1(74.16,92.34) 73.94,92.12 73.94,91.19 73.92,91.17 73.92,88.79 74,88.71 74,87.95 74.43,87.52 U2.D42
SPI_CPU_NODE1_SCLK: length 48.6
  TOP w0.102: v1(96.34,106.51) 96.34,104.87 98.9,102.3 102.39,102.3 102.73,102.64 U5.6 U4.6
  BOTTOM w0.102: v1(96.34,106.51) 96.15,106.51 95.22,105.57 94.02,105.57 92.63,104.18 91.89,104.18 90.49,102.79 78.69,102.79 77.24,101.34 71.03,101.34 70.02,100.33 70.02,98.65 70.59,98.09 70.59,95.47 71.19,94.88 71.19,94.26 72.65,92.8 R59.2
SPI_CPU_NODE1_SCLK_R: length 8.5
  TOP w0.102: U2.J38 72.24,85 v1(72.62,84.62)
  BOTTOM w0.102: R59.1 72.65,91.24 72.94,90.95 72.94,90.27 71.78,89.11 v2(71.78,88.46) 72.06,88.18 72.06,85.33 72.62,84.77 v1(72.62,84.62)
SPI_CPU_NODE1_WP_L: length 16.1
  TOP w0.102: U5.3 U4.3 102.73,94.64 98.25,90.15 98.25,89.53 96.96,88.24 94.46,88.24 93.71,89 v1(93.13,89) R49.1
SPI_CPU_NODE1_WP_R_L: length 11.9
  TOP w0.102: v1(84.69,83.61) 84.21,84.09 83.97,84.09 83.85,84.21 U2.L60 ; R49.2 R48.2 R112.2 90.8,86.97 89.94,86.12 v1(89.73,86.12)
  IN1 w0.114: v1(89.73,86.12) 88.85,86.12 86.34,83.61 v1(84.69,83.61)
SPI_LAN1_NVM_CS_N: length 7.1
  TOP w0.102: R543.1 R542.2 63.32,147.55 63.23,147.63 v1(61.07,147.63) 59.9,148.81 59.85,148.86 U35.15
SPI_LAN1_NVM_SI: length 34.4
  TOP w0.102: R547.1 v1(70.25,163.11) ; v1(60.67,145.28) 60.67,145.6 58.54,147.72 58.54,149.42 58.35,149.61 U35.12
  BOTTOM w0.102: v1(60.67,145.28) 61.04,144.91 62.94,144.91 64.71,146.68 64.71,148.77 65.22,149.28 65.22,153.53 68.28,156.59 68.28,157.22 68.46,157.4 69.29,157.4 69.46,157.58 69.46,157.83 69.29,158.01 68.46,158.01 68.28,158.19 68.28,158.44 68.46,158.62 69.29,158.62 69.46,158.8 69.46,159.05 69.29,159.23 68.46,159.23 68.28,159.41 68.28,161.15 v1(70.25,163.11)
SPI_LAN1_NVM_SK: length 8.5
  TOP w0.102: R545.1 v1(62.26,145.51) 61.23,145.51 58.85,147.9 58.85,149.59 U35.13
SPI_LAN1_NVM_SO: length 7.1
  TOP w0.102: U35.14 59.35,148.65 61.48,146.53 v1(63.22,146.53) 63.58,146.53 63.58,146.53 R549.1
SPI_LAN2_NVM_CS_N: length 13.7
  TOP w0.102: U37.15 169.8,158.93 169.34,159.39 R572.2 168.74,160.8 v1(168.68,160.86) ; R573.1 165.66,167.79 165.09,167.22 165.09,163.54 v1(165.71,162.92)
  IN1 w0.114: v1(165.71,162.92) 166.22,162.41 167.13,162.41 v1(168.68,160.86)
SPI_LAN2_NVM_SI: length 12.9
  TOP w0.102: U37.12 171.3,158.31 171.11,158.51 171.11,159.36 171.27,159.52 171.27,162.23 v1(171.33,162.29) 171.33,162.29 171.33,162.52 173.12,164.31 177.78,164.31 R577.1
SPI_LAN2_NVM_SK: length 14.1
  TOP w0.102: U37.13 170.8,159.41 v1(170.51,159.69) 170.84,160.02 170.84,162.52 173.89,165.58 178,165.58 178.24,165.33 R575.1
SPI_LAN2_NVM_SO: length 12.9
  TOP w0.102: v1(166.54,162.97) 165.38,164.13 165.38,166.32 165.58,166.52 R579.1 ; U37.14 170.3,159.03 170.08,159.26 170.08,161.36 v1(170.15,161.43)
  IN1 w0.114: v1(166.54,162.97) 167.18,162.97 168.11,162.04 168.8,162.04 169.34,161.5 170.08,161.5 v1(170.15,161.43)
SPI_USB_NODE1_CLK: length 36.1
  TOP w0.102: v1(176.16,92.63) 175.92,92.87 R522.1 ; v1(171.58,87.58) U33.6
  BOTTOM w0.102: v1(171.58,87.58) 171.77,87.77 171.77,88.49 170.66,89.6 170.66,89.85 170.84,90.03 171.09,90.03 173.48,87.64 173.74,87.64 173.92,87.82 173.92,88.07 171.53,90.46 171.53,90.71 171.7,90.89 171.96,90.89 173.65,89.2 173.9,89.2 174.08,89.38 174.08,89.63 172.39,91.32 172.39,91.57 172.57,91.75 172.82,91.75 175.43,89.14 175.68,89.14 175.86,89.32 175.86,89.57 173.25,92.18 173.25,92.44 173.43,92.62 173.68,92.62 174.79,91.51 175.04,91.51 175.22,91.69 175.22,91.94 174.11,93.05 174.11,93.3 174.29,93.48 174.54,93.48 175.65,92.37 175.9,92.37 v1(176.16,92.63)
SPI_USB_NODE1_CLK_R: length 2.8
  TOP w0.102: U32.18 176.08,96.13 v1(175.92,95.98) R522.2
SPI_USB_NODE1_CSB_N: length 34.7
  TOP w0.102: R523.1 174.04,93.44 173.86,93.26 173.86,91.28 173.69,91.1 173.43,91.1 173.25,91.28 173.25,95.41 173.08,95.59 172.82,95.59 172.64,95.41 172.64,91.29 172.47,91.12 172.21,91.12 172.04,91.29 172.04,95.41 171.86,95.59 171.6,95.59 171.43,95.41 171.43,91.64 171.25,91.46 170.99,91.46 170.82,91.64 170.82,95.26 170.56,95.52 170.29,95.52 170.07,95.3 170.07,90.52 169.67,90.12 v1(169.15,90.12) U33.1
SPI_USB_NODE1_CSB_R_L: length 4.1
  TOP w0.102: R523.2 v1(174.91,96.93) 174.69,97.15 174.69,97.52 174.9,97.74 U32.17
SPI_USB_NODE1_HOLD_L: length 2.2
  TOP w0.102: U33.7 v1(174.55,88.85) 175.34,88.85 R529.2
SPI_USB_NODE1_R_SO: length 3
  TOP w0.102: U32.19 176.48,95.12 v1(176.73,94.86) 176.94,94.66 R524.2
SPI_USB_NODE1_SI: length 36.1
  TOP w0.102: R530.2 165.47,90.83 R531.1 166.99,90.93 v1(167.44,91.39) 167.44,92.14 167.26,92.31 164.79,92.31 164.61,92.49 164.61,92.74 164.79,92.92 168.15,92.92 168.33,93.1 168.33,93.35 168.15,93.53 164.79,93.53 164.61,93.71 164.61,93.96 164.79,94.14 168.29,94.14 168.47,94.32 168.47,94.57 168.29,94.75 164.79,94.75 164.61,94.93 164.61,95.18 164.79,95.36 168.87,95.36 169.61,96.1 172.75,96.1 174.79,98.14 U32.16
SPI_USB_NODE1_SI_R: length 3
  TOP w0.102: R530.1 165.67,88.8 166.36,89.49 v1(166.43,89.49) 167.07,88.85 U33.2
SPI_USB_NODE1_SO: length 36.5
  TOP w0.102: U33.5 174.77,86.31 v1(174.76,86.32) 175.03,86.32 175.47,86.76 184.07,86.76 184.25,86.94 184.25,87.19 184.07,87.37 178.13,87.37 177.95,87.55 177.95,87.8 178.13,87.98 184.07,87.98 184.25,88.16 184.25,88.41 184.07,88.59 178.13,88.59 177.95,88.77 177.95,90.83 176.94,91.85 R524.1
SPI_USB_NODE1_WP_L: length 2.4
  TOP w0.102: R528.2 166.37,87.57 v1(166.38,87.58) U33.3
SVID_CPU_NODE1_CLK_R: length 3.5
  TOP w0.102: PU8.25 116.51,135.1 115.61,134.19 v1(115.61,133.97) 114.76,133.12 PR44.2
SVID_CPU_NODE1_DAT_R: length 3.5
  TOP w0.102: PR46.2 114.76,134.12 115.14,134.5 v1(115.14,135.26) 115.39,135.5 PU8.24
SVID_CPU_NODE1_PVCCP_ALERT_L: length 76.1
  TOP w0.102: PU8.23 116.37,135.9 v1(115.79,136.48)
  BOTTOM w0.102: v1(115.79,136.48) 114.6,136.48 113.88,135.76 113.88,130.26 113.22,129.6 113.22,118.94 112.13,117.85 112.13,104.98 112.38,104.73 112.38,104.37 112.13,104.12 112.11,104.12 111.7,103.71 111.7,101.55 110.68,100.53 110.68,93.27 107.75,90.34 107.75,83.99 106.95,83.2 106.42,83.2 104.63,81.42 100.84,81.42 100.47,81.05 R119.1 100.07,80.83 99.91,80.67 99.07,80.67 98.26,79.86 97.74,79.86 96.68,78.8 96.68,78.68 95.75,77.75 94.31,77.75 94.11,77.95 R118.2
SVID_CPU_NODE1_PVCCP_ALERT_R_L: length 7.5
  TOP w0.102: U2.AB63 84.98,78.59 85.33,78.24 86.21,78.24 86.31,78.14 87.27,78.14 v1(87.38,78.25)
  BOTTOM w0.102: R118.1 90.92,77.95 v2(90.72,77.75) 90.28,77.75 90.01,78.02 87.6,78.02 v1(87.38,78.25)
SVID_CPU_NODE1_PVCCP_CLK: length 79.5
  TOP w0.102: v1(83.75,78.29) 84.03,78.29 U2.AB62 ; PR44.1 113.23,133.12 v1(112.76,132.65) 112.94,132.47 113.49,132.47 113.59,132.37 PR50.2
  BOTTOM w0.102: v1(112.76,132.65) 112.76,132.36 112.11,131.71 112.11,119.86 112.13,119.84 112.13,119.41 110.94,118.23 110.94,105.21 109.72,103.99 109.72,93.67 106.78,90.74 106.78,85.75 103.57,82.54 100.34,82.54 99.43,81.64 95.72,81.64 94.57,80.48 94.57,79.41 94.14,78.99 90.69,78.99 90.27,79.41 86.08,79.41 85.35,78.68 84.22,78.68 83.83,78.29 v1(83.75,78.29)
SVID_CPU_NODE1_PVCCP_DAT: length 82
  TOP w0.102: R137.1 114.47,134.94 PR46.1 112.78,134.12 v1(112.74,134.07) 112.25,133.59 112.25,132.22 PR45.2
  BOTTOM w0.102: v1(112.74,134.07) 113.4,133.41 113.4,130.46 112.74,129.8 112.74,119.2 111.43,117.89 111.43,104.94 110.51,104.03 110.51,101.05 110.2,100.73 110.2,93.47 107.27,90.54 107.27,85.55 103.73,82.01 100.57,82.01 99.71,81.15 95.97,81.15 95.22,80.4 R127.1 94.5,78.49 90.42,78.49 90.21,78.28 88.58,78.28 87.77,79.09 86.74,79.09 86.22,78.58 R117.2
SVID_CPU_NODE1_PVCCP_DAT_R: length 4.1
  TOP w0.102: v1(82.6,78.66) 82.23,78.29 U2.AC58
  BOTTOM w0.102: v1(82.6,78.66) 82.6,78.37 83.09,77.88 84.08,77.88 v2(84.31,77.65) 84.61,77.95 R117.1
SW_P1V05_NODE1_BT:
  vias: v1(30.48,129.28)
SW_P1V05_NODE1_DRVH:
  vias: v1(28.41,127.41)
SW_P1V05_NODE1_DRVL:
  vias: v1(27.7,127.67) v1(27.7,127.04) v1(33.25,126.57) v1(34.05,126.54)
SW_P1V05_NODE1_PH:
  vias: v1(30.9,123.61)
SW_P1V05_NODE1_VIN_FLT:
  vias: v1(26.25,125.61) v1(27.57,125) v1(27.57,124.36) v1(27.57,123.73) v1(27.62,122.78) v1(27.62,122.15) v1(27.62,121.38)
SW_P1V8_STB_NODE1_BT:
  vias: v1(112.21,153.43)
SW_P1V8_STB_NODE1_PH:
  vias: v1(111.46,155.44)
SW_P3V3_NODE1_BT:
  vias: v1(84.3,7.79)
SW_P3V3_NODE1_PH:
  vias: v1(85.13,5.41)
SW_P3V3_STB_NODE1_BT:
  vias: v1(60.06,111.32)
SW_P3V3_STB_NODE1_PH:
  vias: v1(60.93,108.98)
SW_P5V_STB_NODE1_BT:
  vias: v1(88.69,153.39)
SW_P5V_STB_NODE1_PH:
  vias: v1(87.8,155.75)
SW_PV_VDDR_NODE1_BT:
  vias: v1(52.64,9.18)
SW_PV_VDDR_NODE1_DRVH:
  vias: v1(52.86,10.42) v1(53.27,10.92) v1(54.19,6.89) v1(54.95,6.88)
SW_PV_VDDR_NODE1_DRVL:
  vias: v1(54.03,11.72)
SW_PV_VDDR_NODE1_PH:
  vias: v1(57.79,10.33)
SW_PV_VDDR_NODE1_VIN_FLT:
  vias: v1(56,6.83) v1(56.76,6.83) v1(57.98,7) v1(58.62,7) v1(59.95,7.08) v1(60.7,7.02)
SW_VR_PVCCP_NODE1_VIN_FLT: length 2.8
  TOP w0.457: 124.58,126.73 124.77,126.92 PR43.2
  vias: v1(125.11,125.63) v1(125.16,124.63) v1(126.54,125.22) v1(127.54,125.88) v1(128.25,125.87) v1(129.77,125.91) v1(130.47,125.9)
SYS_AUTO_POWER_ON_N: length 7
  TOP w0.102: U102.K1 193.04,126.17 v1(193.38,126.51) 193.38,128.07 R1121.1 R1120.1
T1_NODE1_EN: length 25
  BOTTOM w0.102: R859.1 78.57,183.48 78.82,183.22 78.82,179.46 79.51,178.77 79.6,178.77 79.6,178.77 79.85,178.52 79.85,178.43 83.53,174.75 v2(83.76,174.75) 84.53,173.98 86.49,173.98 89.43,171.03 90.94,171.03 91.26,170.71 R689.1 91.97,170.47 93.26,171.77 U62.4
T1_NODE1_EN_R: length 20.9
  BOTTOM w0.102: R859.2 78.57,186 77.98,186.59 77.98,187.94 C622.1 78.81,188.77 78.07,189.5 v2(78.07,199.45) 78.07,200 77.05,201.03 J35.A30
T1_NODE2_EN: length 26.1
  IN1 w0.114: v1(80.46,179.32) 80.24,179.11 v1(77.86,179.11)
  BOTTOM w0.102: v1(80.46,179.32) 80.63,179.32 83.22,176.74 83.22,176.7 85.33,174.59 86.24,174.59 88.78,172.05 91.13,172.05 91.26,171.91 R690.1 91.71,171.49 92.64,172.42 U62.5 ; R862.1 77.2,184.58 77.2,183.43 77.31,183.31 77.31,179.65 v1(77.86,179.11)
T1_NODE2_EN_R: length 20.9
  BOTTOM w0.102: R862.2 77.42,186.25 76.88,186.79 76.88,188.26 77.09,188.48 77.37,188.48 C625.1 77.59,188.69 77.22,189.06 v2(77.22,195.74) 76.71,196.26 76.71,201.04 76.05,201.7 J35.A31
T1_NODE3_EN: length 24.9
  TOP w0.102: v1(76.88,181.84) 78.29,181.84 79.88,180.25 v1(79.88,179.8)
  BOTTOM w0.102: U62.6 92.91,173.07 92.34,172.51 R691.1 91.26,172.92 91.16,173.03 88.24,173.03 85.35,175.92 84.89,175.92 81,179.8 v1(79.88,179.8) ; R865.1 76.88,184.2 v1(76.88,181.84)
T1_NODE3_EN_R: length 20.7
  BOTTOM w0.102: R865.2 76.28,185.7 75.73,186.25 75.73,187.98 C628.1 76.28,193.2 75.33,194.16 v2(75.33,195.52) 75.51,195.7 75.51,198.89 75.05,199.35 J35.A32
T1_NODE4_EN: length 25.3
  IN1 w0.114: v1(75.22,184.06) 76.41,182.86 78.44,182.86 v1(79.24,183.66)
  BOTTOM w0.102: U62.7 92.57,173.72 92.37,173.52 R692.1 91.26,173.83 91.11,173.98 89.42,173.98 87.6,175.8 86.75,175.8 82.95,179.6 82.36,179.6 79.24,182.72 v1(79.24,183.66) ; v1(75.22,184.06) 75.14,184.14 R868.1
T1_NODE4_EN_R: length 20.6
  BOTTOM w0.102: R868.2 75.14,186.19 74.46,186.87 74.46,187.85 C631.1 75.14,192.51 74.24,193.41 v2(74.24,199.59) 74.05,199.78 J35.A33
T2_NODE1_EN: length 18.8
  TOP w0.102: R871.1 v1(80.85,183.41)
  BOTTOM w0.102: U62.8 92.63,174.37 v1(92.34,174.66) 91.76,174.66 91.64,174.54 R693.1 91.26,174.74 91.01,174.99 89.59,174.99 87.99,176.59 87.34,176.59 85.39,178.54 85.39,179.17 84.54,180.02 84.24,180.02 v1(80.85,183.41)
T2_NODE1_EN_R: length 21
  TOP w0.102: J35.B27 80.05,200.02 v1(81.16,198.9) 81.16,189.76 80.85,189.45 C634.1 80.4,188.53 80.22,188.35 80.22,186.23 R871.2
T2_NODE2_EN: length 20.7
  TOP w0.102: v1(86.53,182.61) 86.19,182.95 80.7,182.95 80.42,183.23 80.42,183.78 79.71,184.49 R874.1
  IN3 w0.114: v1(91.94,175.45) 90.66,176.74 90.66,178.31 87.66,181.3 87.35,181.3 86.68,181.97 86.68,182.46 v1(86.53,182.61)
  BOTTOM w0.102: U62.9 92.7,175.02 92.27,175.45 v1(91.94,175.45) 91.85,175.55 R694.1
T2_NODE2_EN_R: length 20.4
  TOP w0.102: J35.B28 79.05,197.94 v1(79.17,197.81) 79.17,196.5 79.71,195.96 C637.1 79.51,188.53 79.15,188.17 79.15,186.16 R874.2
T2_NODE3_EN: length 23.1
  TOP w0.102: R877.1 78.57,184.8 78.71,184.8 80.15,183.37 80.15,182.53 80.74,181.94 81.1,181.94 81.8,182.64 85.34,182.64 v1(85.48,182.51)
  IN3 w0.114: v1(85.48,182.51) 86.02,183.05 87.4,183.05 88.73,181.72 88.73,180.85 90.98,178.6 90.98,177.48 v1(92.34,176.12)
  BOTTOM w0.102: U62.10 93.38,175.67 92.93,176.12 v1(92.34,176.12) 91.89,176.57 R695.1
T2_NODE3_EN_R: length 20.6
  TOP w0.102: J35.B29 78.05,202.22 78.6,201.67 78.6,196.03 v1(78.94,195.69) 78.94,195.05 78.57,194.68 C640.1 78.43,188.53 78.03,188.13 78.03,186.14 R877.2
T2_NODE4_EN: length 24.5
  TOP w0.102: v1(77.71,183.64) 77.71,184.35 77.42,184.64 R880.1
  IN1 w0.114: v1(84.17,184.14) 84.17,184.14 83.69,184.62 78.7,184.62 v1(77.71,183.64)
  BOTTOM w0.102: v1(84.17,184.14) 84.11,184.08 84.11,182.53 86.09,180.55 86.09,178.51 86.92,177.69 87.69,177.69 88.33,177.05 88.74,177.05 89.73,178.04 90.95,178.04 91.26,177.73 R696.1 92.04,177.59 93.31,176.32 U62.11
T2_NODE4_EN_R: length 20.2
  TOP w0.102: R880.2 76.94,186.09 76.94,188.17 77.3,188.53 C643.1 77.42,189.5 77.22,189.7 v1(77.22,197.7) 77.05,197.87 J35.B30
T3_NODE1_EN: length 17.7
  BOTTOM w0.102: R883.1 93.64,185.2 96.09,182.75 v2(96.09,182.66) 96.09,181.87 99.14,178.83 102.18,178.83 102.45,178.57 R697.1 101.96,178.09 100.84,176.97 U62.13
T3_NODE1_EN_R: length 20.3
  BOTTOM w0.102: R883.2 91.64,186.45 91.8,186.61 91.8,188.11 91.39,188.53 C646.1 91.27,189.22 92.19,190.15 92.19,197.34 92.56,197.71 v2(92.56,199.77) 92.56,200.18 92.05,200.69 J35.A15
T3_NODE2_EN: length 16.8
  IN3 w0.114: v1(92.02,184.03) 92.69,184.03 94.47,182.24 94.79,182.24 v1(95.96,181.08)
  BOTTOM w0.102: v1(92.02,184.03) 91.16,184.03 90.65,184.54 R886.1 ; R698.1 101.76,177.07 101.01,176.32 U62.14 98.99,176.32 98.81,176.5 98.81,178.22 v1(95.96,181.08)
T3_NODE2_EN_R: length 20.5
  BOTTOM w0.102: R886.2 90.65,186.28 90.71,186.33 90.71,187.92 90.7,187.92 90.7,188.26 90.43,188.53 C649.1 90.25,189.13 91.14,190.02 v2(91.14,196.61) 91.14,198.73 91.48,199.07 91.48,201.31 91.05,201.75 J35.A16
T3_NODE3_EN: length 18.3
  BOTTOM w0.102: R699.1 101.19,176.05 100.81,175.67 U62.15 99.77,175.67 98.65,175.67 97.35,176.97 97.35,178.51 v2(96.53,179.33) 95.52,180.34 95.52,181.48 94.92,182.08 94.45,182.08 93.1,183.42 91.16,183.42 89.73,184.86 R889.1
T3_NODE3_EN_R: length 20.8
  BOTTOM w0.102: J35.A17 90.05,200.36 v2(90.79,199.62) 90.58,199.42 90.58,194.68 90,194.09 90,189.62 89.11,188.73 C652.1 89.11,188.48 89.56,188.03 89.56,185.76 R889.2
T3_NODE4_EN: length 21.1
  BOTTOM w0.102: R892.1 88.6,183.24 89.29,182.55 v2(90.37,182.55) 90.94,182.55 91.1,182.7 91.59,182.7 91.84,182.45 92.98,182.45 93.01,182.47 93.45,182.47 94.1,181.83 94.82,181.83 95.27,181.38 95.27,179.8 96.98,178.09 96.98,177.16 96.97,177.15 96.97,176.08 97.66,175.39 98.56,175.39 98.94,175.02 U62.16 100.91,175.02 101.36,175.46 101.87,175.46 102.29,175.04 R700.1
T3_NODE4_EN_R: length 20.6
  BOTTOM w0.102: R892.2 88.45,185.4 88.45,187.35 88.52,187.42 88.52,188.09 C655.1 88.85,189.29 v2(88.85,199.32) 88.85,199.48 89.05,199.67 J35.A18
T4_NODE1_EN: length 19.4
  TOP w0.102: v1(96.54,177.34) 97.98,178.77 98.16,178.77 99.39,180 99.39,180.76 99.15,181 99.15,181.1 98.87,181.38 97.98,181.38 v3(97.2,182.16) 95.85,183.51 95.52,183.51 94.57,184.46 R895.1
  BOTTOM w0.102: v1(96.54,177.34) 96.54,176.15 97.69,175 98.57,175 99.2,174.37 U62.17 101.48,174.37 101.82,174.02 R703.1
T4_NODE1_EN_R: length 20.4
  TOP w0.102: J35.B12 95.05,202.88 94.83,202.66 94.83,197.18 v1(94.91,197.1) 94.57,196.76 C658.1 94.32,188.53 94.04,188.24 94.04,186.13 R895.2
T4_NODE2_EN: length 19.9
  TOP w0.102: v1(93.8,184.12) 93.42,184.5 R898.1
  IN3 w0.114: v1(93.8,184.12) 94.09,184.41 95.93,184.41 96.76,183.57 96.76,180.32 96.24,179.8 v1(96.24,178.22)
  BOTTOM w0.102: v1(96.24,178.22) 96.11,178.09 96.11,175.54 97.93,173.72 U62.18 100.63,173.72 100.69,173.66 101.37,173.66 102.02,173.01 R705.1
T4_NODE2_EN_R: length 20.5
  TOP w0.102: J35.B13 94.05,196.7 v1(93.42,196.08) C661.1 93.17,188.53 92.77,188.12 92.77,186.26 R898.2
T4_NODE3_EN: length 20
  TOP w0.102: R901.1 92.31,184.81 93.84,183.28 94.98,183.28 95.25,183 95.25,181.73 v1(94.72,181.2)
  BOTTOM w0.102: R707.1 102.22,171.99 101.14,173.07 U62.19 99.77,173.07 98.22,173.07 95.56,175.73 95.56,178.57 94.82,179.31 94.82,181.11 v1(94.72,181.2)
T4_NODE3_EN_R: length 20.9
  TOP w0.102: R901.2 91.68,186.21 91.68,188.2 92.01,188.53 C664.1 92.28,196.55 93.48,197.75 v1(93.48,198.02) 93.48,201.71 93.05,202.14 J35.B14
T4_NODE4_EN: length 21
  TOP w0.102: v1(93.22,181.97) 93.38,182.13 93.38,182.96 92.9,183.44 91.64,183.44 91.14,183.95 R904.1
  BOTTOM w0.102: R709.1 102.45,171.19 101.21,172.42 U62.20 98.51,172.42 95.3,175.63 95.3,178.42 93.34,180.38 93.34,181.84 v1(93.22,181.97)
T4_NODE4_EN_R: length 20.5
  TOP w0.102: J35.B15 v1(92.05,198.26) 91.14,197.35 C667.1 90.9,188.53 90.68,188.3 90.68,186.06 R904.2
T5_NODE1_EN: length 15.9
  IN3 w0.114: v1(119.15,182.22) 121.22,180.15 121.52,180.15 124.41,177.27 124.41,175.56 v1(123.97,175.12)
  BOTTOM w0.102: U64.4 124.43,175.58 v1(123.97,175.12) 123.39,174.54 R710.1 ; R896.1 118.32,182.67 118.76,182.22 v1(119.15,182.22)
T5_NODE1_EN_R: length 20.5
  BOTTOM w0.102: J18.A81 117.05,199.64 117.81,198.88 117.81,196.59 v2(118.09,196.31) 118.09,193.96 118.32,193.74 C659.1 117.84,188.05 117.84,186.64 118.32,186.16 R896.2
T5_NODE2_EN: length 14.9
  IN3 w0.114: v1(123.97,176.39) 122.19,178.16 121.24,178.16 120.02,179.39 120.02,180.04 118.03,182.02 v1(118.03,182.22)
  BOTTOM w0.102: R899.1 117.17,184.24 117.87,183.55 117.87,182.39 v1(118.03,182.22) ; R711.1 123.13,175.55 v1(123.97,176.39) 124.51,176.39 124.67,176.23 U64.5
T5_NODE2_EN_R: length 20.6
  BOTTOM w0.102: J18.A82 116.05,202.45 116.71,201.78 116.71,198.55 v2(117.22,198.04) 117.09,197.91 117.09,188.61 C662.1 116.62,187.98 116.62,186.56 117.17,186.02 R899.2
T5_NODE3_EN: length 26.2
  TOP w0.102: R902.1 105.87,183.64 v1(106.55,182.96)
  IN1 w0.114: v1(106.55,182.96) 113.09,182.96 113.48,182.57 115.86,182.57 116.51,183.22 v1(117.21,183.22)
  BOTTOM w0.102: v1(117.21,183.22) 116.67,183.22 116.27,182.81 116.27,182.46 117.72,181 117.81,181 118.06,180.75 118.06,179.68 119.27,178.47 119.35,178.47 120.16,177.67 120.68,177.67 121.22,177.13 122.32,177.13 R712.1 123.26,176.95 124.46,176.95 124.53,176.88 U64.6
T5_NODE3_EN_R: length 25.1
  TOP w0.102: v1(108,183.99) 107.81,183.8 R902.2
  BOTTOM w0.102: C665.1 106.67,184.78 107.46,183.99 v1(108,183.99) 108.27,184.26 108.27,187.12 108.13,187.26 108.13,189.91 106.87,191.18 v2(106.87,199.12) 107.05,199.3 J35.A2
T5_NODE4_EN: length 28.4
  TOP w0.102: R905.1 107.59,186.81 v1(107.73,186.66)
  IN1 w0.114: v1(116.7,182.63) 116.37,182.3 113.37,182.3 113.15,182.52 106.37,182.52 106.11,182.78 106.11,185.1 107.68,186.66 v1(107.73,186.66)
  BOTTOM w0.102: v1(116.7,182.63) 118.7,180.64 118.7,179.4 119.38,178.73 120.55,178.73 121.21,178.07 122.4,178.07 R713.1 123.27,177.59 123.35,177.66 124.57,177.66 124.7,177.53 U64.7
T5_NODE4_EN_R: length 19.8
  TOP w0.102: R905.2 105.84,186.83 105.21,187.46 v1(105.21,187.95)
  BOTTOM w0.102: J35.A3 106.05,200.22 106.05,200.21 v2(106.05,195.61) 105.11,194.67 105.11,188.06 v1(105.21,187.95) 105.34,187.82 C668.1
T6_NODE1_EN: length 13.7
  TOP w0.102: R884.1 123.78,183.97 124.02,183.72 124.02,183.23 123.51,182.72 122.97,182.72 122.59,182.34 v1(120.52,182.34)
  IN3 w0.114: v1(123.97,178.41) 121.88,180.5 121.88,180.82 120.52,182.17 v1(120.52,182.34)
  BOTTOM w0.102: R714.1 123.77,178.6 v1(123.97,178.41) 124.19,178.18 U64.8
T6_NODE1_EN_R: length 20.7
  TOP w0.102: R884.2 123.78,185.79 124.28,186.29 124.28,188.03 C647.1 123.78,192.76 122.38,194.15 122.38,197.72 v1(122.41,197.74) 122.05,198.1 J18.B76
T6_NODE2_EN: length 16
  TOP w0.102: R887.1 122.86,184.81 123.32,184.35 123.32,183.9 122.13,182.71 120.77,182.71 120.7,182.77 120.34,182.77 120.05,182.48 v1(119.83,182.48)
  IN3 w0.114: v1(120.55,179.67) 120.38,179.85 120.38,180.22 118.71,181.88 118.71,182.4 118.97,182.66 119.66,182.66 v1(119.83,182.48)
  BOTTOM w0.102: U64.9 124.65,178.83 124.48,179 123.91,179 123.29,179.62 R715.1 122.37,179.1 121.12,179.1 v1(120.55,179.67)
T6_NODE2_EN_R: length 21.1
  TOP w0.102: J18.B77 121.05,196.34 v1(120.81,196.1) 120.76,196.05 120.76,193.99 122.63,192.12 C650.1 122.96,188.53 123.18,188.31 123.18,186.15 R887.2
T6_NODE3_EN: length 10.2
  TOP w0.102: v1(121.06,183.14) 121.06,183.14 121.06,183.14 121.06,183.14 120.92,183.27 120.92,184.06 121.49,184.62 R890.1
  BOTTOM w0.102: v1(121.06,183.14) 121.06,183.14 121.06,183.14 121.06,183.13 121.21,182.98 121.21,181.42 120.98,181.2 120.98,180.44 121.25,180.18 122.36,180.18 122.82,180.63 R716.1 122.95,180.57 122.96,180.57 124.05,179.48 U64.10
