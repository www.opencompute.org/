# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
P3V3_STB_NODE1_EN: length 1.4
  TOP w0.254: PU2.6 v1(57.64,107.7) 57.64,107.69 PJ2.2
P3V3_STB_NODE1_FB: length 4.3
  TOP w0.254: PR7.1 PC21.1 53.89,111.87 54.55,111.2 PR8.1 v1(55.39,110.96) 55.82,110.96 56.05,110.73 PU2.1
P3V3_STB_NODE1_SS: length 2.4
  TOP w0.254: PU2.3 55.91,109.73 55.3,109.12 v1(55.3,108.86) 54.97,108.53 PC20.2
P3V3_STB_NODE1_VREG5: length 7
  TOP w0.254: PR5.1 55.27,106.08 54.83,106.51 54.82,106.51 v1(54.58,106.75) 53.98,107.36 53.98,108.87 54.6,109.5 PC19.1 54.76,110.02 55.49,110.02 55.69,110.23 PU2.2
P3V3_SUS_NODE1: length 299.5
  TOP w0.305: v1(74.78,83.95) 74.33,83.95 U2.L42 U2.N42 U2.P42 U2.T42
  TOP w0.508: v1(90.63,108.31) 89.91,108.31 88.74,109.48 88.74,116.09 88.24,116.58 v1(88.24,116.77) ; R136.1 v1(96.73,88.7) ; R1023.2 47.37,173.02 47.62,172.76 v1(47.62,171.68) ; R195.1 v1(28.37,36.04) ; v1(46.68,152.24) 46.22,152.7 40.66,152.7 40.2,152.24 35.36,152.24 34.28,151.15 29.02,151.15 27.26,149.39 27.26,145.85 27.33,145.78 27.33,145.26 27.26,145.2 27.26,139.5 23.9,136.14 22.87,136.14 21.96,135.22 17.86,135.22 17.5,135.58 v1(13.15,135.58) ; R138.1 v1(96.8,89.87) ; R112.1 v1(93.6,86.97)
  IN1 w0.508: 93.44,95.41 93.44,98.99 91.14,101.3 91.14,107.79 v1(90.63,108.31) ; v1(88.24,116.77) 87.61,116.14 63.34,116.14 59.68,119.8 59.68,120.29 53.6,126.37 52,126.37 50.45,127.92 50.45,134.87 50.63,135.05 50.63,135.58 47.91,138.31 47.91,143.12 47.11,143.92 47.11,151.81 v1(46.68,152.24) 47.11,152.66 47.11,171.17 v1(47.62,171.68)
  IN2 w0.508: v1(13.15,135.58) 13.15,73.17 13.63,72.69 24.77,72.69 25.32,72.13 25.32,69.43 26.85,67.91 26.85,64.6 25.31,63.05 25.31,40.86 26.69,39.48 26.69,37.36 28.01,36.04 v1(28.37,36.04)
  BOTTOM w0.508: v1(78.94,99.94) 78.59,99.58 R75.1 ; v1(93.64,93.41) 93.64,93.11 91.63,91.1 90.62,91.1 88.33,88.81 R144.2 88.33,87.01 88.57,86.76 88.57,85.82 v2(88.37,85.62) 87.21,84.46 86.79,84.46 86.64,84.61 v2(85.65,84.61) 84.71,84.61 84.08,83.97 R77.1
  vias: v1(93.15,94.53) v1(93.89,94.47)
P3V3_USB_NODE1: length 2.9
  TOP w0.178: v1(173.81,102.33) 174.01,102.14 U32.6 ; v1(182.01,95.88) 181.68,96.22 U32.32
P3V_COIN_CELL: length 5.8
  TOP w0.508: BT1.1 140.4,70.97 R147.1
P5V_CRT: length 10.7
  TOP w0.381: R634.1 30.25,45.09 30.72,44.62 v1(30.95,44.62)
  TOP w0.508: U44.2 34.53,57.84 33.74,58.63 C509.2 33.74,59.6 33.48,59.86 v1(33.21,59.86) ; U47.2 33.14,47.24 v1(33,47.1) ; R635.1 v1(26.33,61.69) ; U45.2 v1(35.12,50.73) ; U48.2 v1(33.92,54.32) ; U50.2 v1(32.13,60.43) ; U46.2 v1(33.63,43.61)
  vias: v1(27.77,67.97) v1(31.9,71.56) v1(31.9,70.89) v1(31.94,70.11)
P5V_NODE1: length 134.4
  TOP w0.254: v1(153.21,45.53) 153.52,45.53 153.79,45.81 U43.4 ; 138.04,48.57 138.29,48.31 U43.35
  TOP w0.381: U132.8 37.14,56.18 v1(36.67,56.65)
  TOP w0.508: R1284.1 v1(146.1,156.31) ; R1005.1 162.26,40.37 v1(162.79,40.9) 162.21,41.48 R1011.1 ; 138.04,48.57 138.04,48.79 137.83,48.99 C536.1 138.47,49.67 v1(138.82,49.33) ; R722.2 v1(138.99,180.49) ; R615.1 145.26,52.12 v1(145.8,52.67) ; R720.2 R721.2 v1(138.89,181.5) ; R1017.1 v1(153.74,52.71) ; R777.1 v1(150.34,52.58) ; R614.1 v1(147.29,52.45) ; v1(150.57,57.59) 149.16,57.59 148.22,56.65 147.61,56.65 147.14,56.18 R1134.1 ; R1015.1 153.87,54.53 v1(153.19,53.86) ; R1283.1 124.35,160.82 124.76,161.23 v1(124.77,161.23) ; R1009.1 v1(162.63,43.66) ; R1282.1 v1(141.07,155.85) ; R723.2 v1(139.21,179.47) ; R1020.1 v1(151.71,52.59) ; R1323.1 v1(142.13,51.87)
  IN1 w1.016: 73.67,14.26 67.51,14.26 64.54,17.24 49.17,17.24 45.25,21.16
  IN2 w0.508: v1(121.46,174.54) 121.49,174.51 121.74,174.51 122.11,174.14 122.11,172.24 121.92,172.06 121.92,166.11 120.54,164.73 120.54,163.53 121.92,162.15 123.72,162.15 124.65,161.23 v1(124.77,161.23)
  IN3 w0.508: v1(141.07,155.85) 141.8,156.58 141.8,157.19 141.43,157.56 137.95,157.56 135.03,160.47 130.27,160.47 130.17,160.37 129.64,160.37 128.78,161.23 v1(124.77,161.23)
  BOTTOM w0.508: v1(136.76,177.71) 136.51,177.46 R724.2 ; R740.2 R736.2 v1(153.04,177.08) ; R741.2 v1(161.42,179.8) ; v1(146.47,45.29) R1136.1 146.46,46.56 R1322.1 ; R689.2 v1(89.83,170.47) ; R715.2 v1(121.44,179.62) ; R747.2 166.98,174.54 167.11,174.41 v1(167.11,174.41) ; R714.2 v1(121.42,178.6) ; R728.2 v1(153.08,170.98) ; R729.2 v1(153.08,172) ; R1132.1 v1(149.7,45.75) ; R691.2 v1(89.83,172.51) ; R725.2 v1(136.84,176.44) ; R713.2 v1(121.41,177.59) ; v1(153.21,45.53) 153.2,45.55 153.2,46.47 C481.1 ; R690.2 v1(89.83,171.49) ; R711.2 v1(121.47,175.55) ; R745.2 v1(167.12,176.57) ; R692.2 v1(89.79,173.52) ; v1(121.44,180.63) R716.2 R717.2 ; v1(167.18,173.72) 166.98,173.52 R748.2 R749.2 ; R732.2 v1(153.09,175.05) ; R726.2 R727.2 136.57,174.41 v1(136.79,174.63) ; R696.2 R695.2 R694.2 v1(89.75,175.55) ; v1(141.07,155.85) 142.49,155.85 142.75,155.6 144.2,155.6 144.91,156.31 v1(146.1,156.31) ; R733.2 v1(153.07,176.06) ; R712.2 v1(121.46,176.57) ; v1(160.39,179.8) 160.39,179.3 R742.2 ; R1264.1 v1(150.72,45.72) ; R744.2 v1(159.14,179.8) ; R731.2 v1(153.07,174.03) ; R1263.1 141.52,51.26 v1(142.13,51.87) ; v1(142.23,45.44) 142.23,46.09 R1325.1 ; R730.2 v1(153.06,173.01) ; R746.2 v1(167.12,175.55) ; R710.2 v1(121.46,174.54) ; R693.2 v1(89.75,174.54)
  vias: v1(33,73.18) v1(33.01,72.5) v1(44.09,21.16) v1(44.09,20.41) v1(73.94,161.67) v1(74.66,161.72) v1(75.3,161.71) v1(75.99,161.72) v1(76.08,163.66) v1(76.63,161.73) v1(76.74,163.68) v1(77.17,162.4) v1(77.19,163.19) v1(77.44,14.25) v1(77.59,13.64) v1(81.24,174.72) v1(81.29,176.21) v1(82.02,177.24) v1(82.91,176.1) v1(103.87,178.78) v1(103.86,172.95) v1(103.89,170.51) v1(103.99,173.96) v1(104.38,178.39) v1(106.26,5.23) v1(106.31,4.52) v1(149.75,23.76) v1(151.09,24.54) v1(155.78,24.59) v1(156.73,49.58) v1(157.52,49.58) v1(161.38,35.25) v1(183.12,144.19) v1(183.15,142.88) v1(183.22,141.56) v1(183.89,47.8) v1(184.18,144.2) v1(184.21,142.88) v1(184.34,141.59) v1(184.78,47.8) v1(185.3,49.43) v1(185.3,48.57) v1(187.16,49.43) v1(187.16,48.55) v1(188.19,47.34) v1(189.29,47.36) v1(201.28,27.99) v1(201.21,27.16) v1(201.2,26.34) v1(201.95,25.47) v1(202.04,27.99) v1(202.83,27.99) v1(202.81,25.47)
P5V_STB_NODE1: length 303.6
  TOP w0.178: PU8.18 118.5,138.21 v1(118.2,138.52) ; v1(120.25,138.7) 120.1,138.55 PU8.14
  TOP w0.254: v1(94.31,149.79) 94.31,150.88 94.06,151.13 PR3.2 PC10.2 93.8,152.68 93.64,152.53 92,152.53 91.61,152.92 PU1.16 ; 177.63,78.75 177.24,78.36 U130.10 ; U119.10 108.37,132.29 108.75,131.9 C809.1
  TOP w0.508: R1090.1 80.06,99.28 v1(80.1,99.24) ; 177.63,78.75 177.97,79.09 C883.1 v1(178.43,80.03) ; v1(19.72,9.58) C180.1 20.59,9.58 U11.5 ; R1115.1 v1(50.42,119.24) ; R1111.1 v1(76.21,112.67)
  IN1 w1.016: 201.42,79.42 198.4,82.44 180.84,82.44 v1(178.43,80.03)
  IN2 w0.254: v1(78.09,153.16) 78.09,150.03 80.14,147.97 84.57,147.97 85.25,147.29 92.54,147.29 94.31,149.05 v1(94.31,149.79)
  IN2 w0.508: v1(80.1,99.24) 80.1,100.17 80.94,101.01 83.28,101.01 83.72,101.46 85.61,101.46 85.97,101.82 85.97,110.08 84.97,111.08 77.07,111.08 76.69,111.46
  IN2 w1.016: 115.97,152.06 118.86,152.06 120.1,153.3 122.01,153.3 122.23,153.52 141.51,153.52 142.23,152.79 142.97,152.79 144.52,154.34 145.45,154.34 145.57,154.47 155.19,154.47 159.97,149.68 161.34,149.68 161.86,149.16 161.86,146.46 163.18,145.14 167.19,145.14 169.09,143.24 169.09,140.61 169.88,139.82 189.64,139.82 191.64,137.82 193.53,137.82 208.3,123.05 208.3,82.45 205.34,79.49 203.84,79.49
  IN3 w1.016: v1(138.89,32.68) 138.89,32.33 139.27,31.96 139.27,31.13 137.66,29.53 135.37,29.53 135.35,29.54 134.69,29.54 133.47,28.33 133.47,18.31 131.54,16.37 131.54,14.69 130.3,13.45 128.87,13.45 123.59,8.16 101.62,8.16
  BOTTOM w0.508: R628.1 v1(138.89,32.68)
  vias: v1(26.34,126.48) v1(26.98,126.48) v1(38.4,103.09) v1(38.38,102.3) v1(38.42,101.5) v1(39.52,101.86) v1(40.26,101.88) v1(43.81,124.32) v1(44.47,124.32) v1(51.72,11.62) v1(52.08,12.16) v1(56.79,113.85) v1(57.49,113.83) v1(78.57,156.88) v1(78.57,156.12) v1(78.57,154.59) v1(78.57,153.83) v1(78.95,159.17) v1(78.95,158.4) v1(80.29,153.93) v1(80.47,158.23) v1(81.12,10.3) v1(81.55,162.58) v1(81.51,161.66) v1(81.61,160.8) v1(81.76,10.3) v1(94.12,143.38) v1(94.1,142.62) v1(99.95,9.15) v1(100.07,9.79) v1(109.47,131.54) v1(115.38,150.92) v1(115.38,150.2) v1(115.98,132.53) v1(116.7,132.52) v1(116.97,128.22) v1(116.99,129.05) v1(202.64,79.84) v1(202.62,79.08) v2(116.44,138.52) v2(118.37,137.52)
P5V_STB_NODE1_EN: length 23.3
  TOP w0.254: PC25.1 90.45,158.46 v1(90.45,158.46) PJ1.1 ; R1083.1 93.07,151.7 R1082.1 92.1,151.46 92.29,151.27 v1(92.29,150.91)
  BOTTOM w0.254: v1(92.29,150.91) 95.76,150.91 96.63,151.78 96.63,158.68 94.94,160.38 91.35,160.38 90.45,159.48 v1(90.45,158.46)
P5V_STB_NODE1_EN_P: length 1.4
  TOP w0.254: PU1.6 v1(91.11,157.02) 91.11,157.03 PJ1.2
P5V_STB_NODE1_FB: length 4.6
  TOP w0.254: PU1.1 92.69,153.99 93.24,153.44 v1(93.34,153.44) 93.65,153.76 PR4.1 94.2,153.52 94.86,152.85 PC10.1 PR3.1
P5V_STB_NODE1_SS: length 2.3
  TOP w0.254: PC9.2 93.55,155.96 v1(93.44,155.86) 93.44,155.6 92.84,154.99 PU1.3
P5V_STB_NODE1_VREG5: length 7.1
  TOP w0.254: PU1.2 93.3,154.49 93.34,154.52 93.94,154.52 PC8.1 94.22,155 94.77,155.55 94.77,157.36 v1(94.16,157.97) 93.93,158.21 93.92,158.21 93.48,158.64 PR1.1
P12V_AUX: length 140.7
  TOP w0.457: v1(75.28,159.64) 74.87,159.64 R1107.1
  TOP w0.508: v1(127.83,150.57) 127.95,150.44 R1249.1 ; R1099.1 92.53,104.79 v1(92.34,104.98) ; R1130.1 v1(119.96,148.92) ; R1129.1 v1(118.06,161.95) ; R1039.2 v1(131.71,150.87) ; R1026.2 v1(204.69,115.71) ; R655.2 v1(109.32,162.63) ; R657.2 v1(120.02,154.54)
  IN1 w0.508: v1(103.56,100.55) 100.61,103.5 100.61,107.22 102.88,109.49 102.88,132.32 102.28,132.91 102.28,137.07 109.64,144.43 110.77,144.43 v1(111.09,144.11)
  IN2 w0.508: v1(75.28,159.64) 73.69,159.64 73.12,159.06 69.2,159.06 68.29,159.97 68.29,161.71 66.92,163.08 66.92,166.13 63.81,169.24 56.16,169.24 55.97,169.06 51.8,169.06 51.25,168.51 50.5,168.51 v1(49.66,167.67)
  IN3 w0.508: v1(105.03,103.54) 93.53,103.54 93.16,103.91 93.16,104.16 v1(92.34,104.98)
  BOTTOM w0.508: v1(130.55,131) 130.6,131.06 130.6,139.21 127.06,142.75 112.38,142.75 111.09,144.03 v1(111.09,144.11) ; v1(105.03,103.54) 105.03,101.66 103.93,100.55 v1(103.56,100.55)
  vias: v1(24.02,118.68) v1(24.12,117.82) v1(24.53,120.07) v1(24.63,119.24) v1(24.69,118.24) v1(25.16,117.57) v1(49.75,171.71) v1(50.35,173.34) v1(50.53,174.65) v1(50.62,171.47) v1(50.7,172.31) v1(51.57,173.1) v1(51.65,171.4) v1(51.98,172.25) v1(52.57,173.49) v1(52.7,174.74) v1(52.7,171.45) v1(53.18,172.33) v1(53.44,173.83) v1(53.71,174.76) v1(53.95,171.68) v1(53.98,173.05) v1(54.1,175.59) v1(54.53,173.98) v1(54.87,174.77) v1(55.03,179.15) v1(55.06,178.06) v1(55.03,177.14) v1(55.12,176.11) v1(57.12,114.79) v1(57.78,114.79) v1(58.24,113.04) v1(58.24,112.41) v1(58.9,112.25) v1(61.53,3.29) v1(61.52,2.59) v1(62.47,3.9) v1(63.3,3.88) v1(64.05,3.5) v1(64.1,2.69) v1(82.08,13.4) v1(82.09,12.75) v1(82.51,9.51) v1(82.51,8.88) v1(83.17,8.72) v1(89.81,152.47) v1(90.93,149.92) v1(91.01,150.89) v1(91.64,150.89) v1(91.59,149.92) v1(112.54,161.91) v1(113.22,149.13) v1(113.33,152.5) v1(113.49,161.88) v1(113.91,149.11) v1(113.99,152.34) v1(113.99,151.71) v1(116.05,161.9) v1(117.38,161.6) v1(118.77,161.55) v1(129.78,130.99) v1(130.78,130.35) v1(130.82,129.55) v1(130.8,128.73) v2(58.35,111.56) v2(82.71,7.88) v2(113.94,153.32)
P12V_AUX_EN: length 37.7
  TOP w0.254: 45.67,183.41 U100.3
  TOP w0.508: 45.67,183.41 45.65,183.44 R1022.1 ; C778.1 v1(45.65,186.18) ; U109.D 48.57,170.55 49.15,169.98 v1(49.68,169.98) ; U93.D v1(55.51,181.78)
  IN1 w0.457: v1(55.51,181.78) 54.12,183.16 46.49,183.16 45.64,184.01 v1(45.64,186.18)
  IN1 w0.508: v1(49.68,169.98) 53.89,169.98 54.46,170.55 55.69,170.55 57.49,172.36 v1(57.49,174.91) 55.77,176.63 55.77,181.53 55.52,181.78 v1(55.51,181.78)
P12V_DBG: length 103.9
  TOP w0.508: R1070.2 v1(53.89,168.3)
  IN2 w0.508: v1(17.5,93.72) 17.41,93.82 17.41,94.97 17.36,95.02 17.36,136.88 18.05,137.57 18.05,137.97 19.06,138.98 19.06,140.79 22.6,144.33 24.44,144.33 32.6,152.49 32.6,165.91 34.93,168.24 43.94,168.24 45.17,167.01 50.83,167.01 52.01,168.18 53.78,168.18 v1(53.89,168.3)
  vias: v1(15.36,95.47) v1(15.38,94.66) v1(16.1,93.77) v1(16.69,93.08) v1(18.09,93.03) v1(20.52,93.3) v1(21.11,92.61) v1(21.76,91.99) v1(22.37,91.33)
P12V_NODE1_PWRGD_EN:
  vias: v1(202.21,115.65)
P12V_PDB: length 8.9
  TOP w0.254: 46.67,183.15 U100.1
  TOP w0.508: R1012.2 58.85,176.74 v1(58.25,177.34) ; D20.3 50.16,186 49.71,185.56 48.76,185.56 47.7,184.5 C777.1 47.7,183.83 47.29,183.42 46.94,183.42 46.67,183.15 ; v1(58.2,176.49) 58,176.29 R1006.2
  vias: v1(14.38,167.21) v1(14.41,166.1) v1(15,166.71) v1(15.43,100.98) v1(15.58,98.71) v1(15.59,167.23) v1(15.63,166.11) v1(15.65,100.3) v1(15.62,99.52) v1(16.66,98.18) v1(24.18,101.3) v1(24.66,169.78) v1(24.67,98.38) v1(24.95,100.52) v1(25.17,97.74) v1(25.58,99.86) v1(26.98,198.91) v1(27.08,198.07) v1(27.37,197.32) v1(27.85,198.03) v1(27.97,198.8) v1(28.49,197.3) v1(29.01,198.81) v1(29.22,197.98) v1(48.77,186.93) v1(48.87,188.15) v1(49.44,189) v1(51.25,189.06) v1(51.46,188.03) v1(51.39,187.19) v1(52.41,188.96) v1(52.39,185.62) v1(53.18,185.62) v1(53.34,188.96) v1(54.09,185.54) v1(54.59,188.81)
VCC5_CRTXX:
  vias: v1(29,75.56) v1(30.37,75.54) v1(31.68,76)
A_CPU0_NODE1_THERMDA: length 27.6
  TOP w0.254: U9.1 64.89,98.93 65.11,98.71 C137.1 v1(66.59,98.71) ; U2.AD39 v1(72.43,77)
  IN1 w0.254: v1(66.59,98.71) 66.9,98.71 67.59,98.02 67.59,94.11 69.4,92.29 69.4,89.16 71.78,86.77 71.78,81.5 71.95,81.34 71.95,77.48 v1(72.43,77)
A_CPU0_NODE1_THERMDC: length 28.1
  TOP w0.254: U9.2 64.42,99.58 64.77,99.51 C137.2 67.21,99.51 v1(67.43,99.29) ; U2.AC38 v1(72.43,77.8)
  IN1 w0.254: v1(67.43,99.29) 67.61,99.1 67.61,98.79 68.29,98.12 68.29,94.22 70.17,92.34 70.17,91.61 70.68,91.1 70.68,88.92 72.15,87.45 72.15,85.58 72.14,85.57 72.14,81.65 72.59,81.2 72.59,79.92 72.92,79.6 72.92,79.1 72.43,78.62 v1(72.43,77.8)
A_CPU1_NODE1_THERMDA: length 32.6
  TOP w0.254: v1(73.23,75.4) 73.23,75.41 72.85,75.8 U2.AG39 ; U9.3 64.96,100.23 65.19,100.47 C138.1 v1(66.49,100.47)
  IN1 w0.254: v1(73.23,75.4) 72.93,75.7 72.02,75.7 70.34,77.38 70.34,79.84 69.8,80.38 69.8,87.16 67.3,89.66 67.3,92.44 65.29,94.45 65.29,99.26 v1(66.49,100.47)
A_CPU1_NODE1_THERMDC: length 31.3
  TOP w0.254: v1(66.67,101.51) 66.67,101.51 66.43,101.27 C138.2 65.17,101.27 64.78,100.88 U9.4 ; U2.AF38 v1(71.63,77)
  IN1 w0.254: v1(66.67,101.51) 66.78,101.51 67.13,101.17 67.13,100.26 65.88,99.01 65.88,94.71 67.9,92.69 67.9,89.56 70.15,87.3 70.15,80.56 70.83,79.88 71.03,79.88 71.43,79.48 71.43,77.2 v1(71.63,77)
A_CPU_NODE1_AE64_PU: length 9.5
  TOP w0.102: U2.AE64 85.28,76.75 85.7,76.33 86.88,76.33 87.27,75.94 88.18,75.94 89.84,74.29 v3(89.96,74.29) 91.54,74.29 91.54,74.29 91.81,74.29 91.82,74.29 93.36,74.29 R103.2
A_CPU_NODE1_HV_GPIO_RCOMP: length 3
  TOP w0.305: v1(72.62,83.1) 72.25,83.47 U2.M38
  BOTTOM w0.102: v2(70.52,83.47) 70.72,83.67 R98.1
  BOTTOM w0.381: R98.1 72.05,83.67 v1(72.62,83.1)
A_CPU_NODE1_LV_GPIO_RCOMP: length 4.2
  TOP w0.254: v1(77.32,78.65) 77.32,78.55 77.03,78.26 U2.AC47
  BOTTOM w0.102: v2(80.18,77.98) 79.74,77.98 79.28,77.51 78.52,77.51 R101.1
  BOTTOM w0.381: v1(77.32,78.65) 77.32,78.44 77.79,77.97 R101.1
A_CPU_NODE1_MV_GPIO_RCOMP: length 4.3
  TOP w0.305: U2.P34 70.26,82.34 v1(70.64,82.71)
  BOTTOM w0.102: v2(70.05,81.65) 70.05,82.13 v1(70.64,82.71)
  BOTTOM w0.381: R100.1 69.89,83.02 70.19,82.71 v1(70.64,82.71)
A_CPU_NODE1_NTB_CROSSLK_MODE: length 8.5
  TOP w0.305: 73.46,89.86 73.6,89.72 73.6,88.68 73.67,88.61 U2.B41
  TOP w0.508: R104.2 75.21,95.96 73.77,94.53 v1(73.77,93.57) 73.46,93.26 73.46,89.86
A_CPU_NODE1_RTC_EXTPAD: length 6.7
  TOP w0.102: U2.L65 85.89,84.09 88.04,84.09 v1(88.08,84.13) 88.08,84.17 88.92,85.01 89.37,85.01 90.39,86.03 91.5,86.03 C23.1
A_CPU_NODE1_SOC_THERMREFNPAD: length 3.1
  TOP w0.102: U2.R22 64.3,82.04 v1(64.86,82.6)
  BOTTOM w0.102: R200.1 63.73,82.5 R120.1 64.77,82.5 v1(64.86,82.6)
A_NODE1_RP0_RCOMP: length 4.6
  TOP w0.305: U2.AT23 v1(64.43,71.4)
  BOTTOM w0.102: R36.2 64.28,69.66 63.79,69.17 62.38,69.17 v2(62.29,69.26)
  BOTTOM w0.381: R36.2 64.28,71.25 v1(64.43,71.4)
A_SOC_NODE1_THERMDA: length 25.1
  TOP w0.254: U2.R21 63.36,81.71 62.95,81.71 v1(62.89,81.65)
  TOP w0.305: U9.10 59.55,100.23 59.44,100.12 C139.1 58.53,100.03 58.07,100.03 57.86,99.82 v1(57.86,99.81)
  IN1 w0.254: v1(62.89,81.65) 61.58,82.95 61.58,86.66 61.29,86.96 61.29,88.91 61.47,89.09 61.47,91.06 59.76,92.77 59.76,99.25 58.78,100.23 58.26,100.23 57.86,99.84 v1(57.86,99.81)
A_SOC_NODE1_THERMDC: length 25.1
  TOP w0.254: v1(62.98,82.28) 63.05,82.34 63.23,82.34 U2.P21
  TOP w0.305: v1(57.86,101.11) 57.86,101.1 58.05,100.92 58.62,100.92 C139.2 59.38,100.92 59.42,100.88 U9.9
  IN1 w0.254: v1(57.86,101.11) 58.28,100.68 58.96,100.68 60.16,99.48 60.16,92.94 61.87,91.23 61.87,88.99 61.64,88.76 61.64,87.1 61.94,86.81 61.94,83.1 62.76,82.28 v1(62.98,82.28)
ATTENTION_LED_N: length 10
  TOP w0.102: v1(111.33,178.29) 110.89,178.73 110.89,179.74 110.5,180.14 R146.1 110.74,181.97 U131.1
  BOTTOM w0.102: v1(111.33,178.29) 110.78,178.84 U65.10 107.41,178.84 107.24,179.01 v2(106.61,179.01)
ATTENTION_LED_R: length 453.1
  TOP w0.102: U131.6 113.32,181.97 112.33,180.97 112.33,180.72 v1(112.32,180.7)
  IN1 w0.114: D18.1 30.76,4.44 33.88,1.33 193.88,1.33 194.86,2.31 v1(194.86,6.33) ; v1(112.32,180.7) 113.18,181.56 120.59,181.56 121.1,182.07 124.41,182.07 125,182.66 128.57,182.66 129.8,183.89 129.8,184.3 131.21,185.72 131.21,187.09 132.43,188.3 163.98,188.3 165.24,187.04 165.24,186.94 166.25,185.93 173.3,185.93 173.33,185.96 175.99,185.96 179.77,182.18 179.77,170.41 180.97,169.21 180.97,168.48 181.87,167.58 182.61,167.58 184.47,165.71 195.21,165.71 206.31,154.61 206.31,141.03 206.72,140.63 206.72,93.22 206.5,92.99 v1(206.5,91.74)
  IN2 w0.114: v1(206.5,91.74) 206.84,91.4 206.84,83.8 204.11,81.06 201.05,81.06 189.37,69.38 189.37,52.82 189.71,52.47 189.71,52.11 188.74,51.14 188.74,46.32 188.66,46.23 188.66,33.52 192.6,29.57 192.6,13.38 192.36,13.14 192.36,8.83 v1(194.86,6.33)
BMC_DEBUG_RXD: length 5
  TOP w0.102: v1(80.11,145.02) 80.21,145.02 81.4,143.83 81.4,143.49 81.37,143.47 U14.G1
  BOTTOM w0.102: v1(80.11,145.02) 79.7,145.43 PJ18.2
BMC_DEBUG_TXD: length 9.1
  TOP w0.102: U14.H5 v5(80.97,140.46)
  BOTTOM w0.102: v5(80.97,140.46) 79.62,141.81 v2(79.62,142.74) 79.62,142.97 82.35,145.7 82.35,146.55 82.35,146.55 82.54,146.74 PJ19.1
BMC_NODE1_ADCAV33: length 0.6
  TOP w0.381: U14.P3 v5(76.18,142.07)
  vias: v2(76.98,145.89)
BMC_NODE1_ADCREXT: length 7
  TOP w0.102: U14.P2 76.2,142.88 76.2,143.88 76.82,144.5 76.82,146.54 v1(77.99,147.71) 77.63,148.08 R313.2
BMC_NODE1_CLK_24M: length 5.7
  TOP w0.102: R312.2 68.37,121.74 v1(68.53,121.9) 68.56,121.94 68.56,122.95 69.41,123.8 69.41,125.85 69.37,125.89 U14.AB22
BMC_NODE1_CLK_24M_R: length 1.9
  TOP w0.102: OSC3.3 v1(67.41,120.36) 67.82,120.77 R312.1
BMC_NODE1_DACAV33: length 11.3
  TOP w0.406: v5(73.77,142.06) 74.17,141.66 U14.T3
  TOP w0.457: v1(75.51,144.44) 75.51,143.52 U14.P1
  TOP w0.508: v1(75.51,144.44) 75.76,144.69 75.76,146.89 75.24,147.42 74.32,147.42 73.92,147.81 C264.1 C263.1
  IN3 w0.508: v5(73.77,142.06) 73.77,143.08 74.35,143.66 74.76,143.66 75.51,144.41 v1(75.51,144.44)
  vias: v1(73.7,149.8)
BMC_NODE1_DACRSET: length 9.9
  TOP w0.102: U14.R1 74.98,143.26 75.04,143.32 75.04,146.49 74.59,146.95 73.8,146.95 73.55,147.2 70.07,147.2 v1(69.72,147.55) 69.49,147.77 R315.2
BMC_NODE1_DDR3_ZQ: length 5.2
  TOP w0.178: 57.27,133.36 56.24,133.36
  TOP w0.356: U15.L8 57.27,133.36
  TOP w0.381: 56.24,133.36 v5(55.62,133.99)
  BOTTOM w0.381: v5(55.62,133.99) 55.62,133.29 v2(56.1,132.8) 56.43,133.13 R260.1
BMC_NODE1_DDR_BA0: length 22
  TOP w0.102: U15.M2 53.26,131.93 53.55,131.79 53.78,131.76 54.28,131.37 54.38,131.06 v1(54.75,130.64) ; U14.W14 v5(71.37,132.46)
  IN1 w0.102: 67.89,132.8 68.45,133.37 68.99,133.37 69.17,133.19 70.09,132.86 70.67,132.86 70.78,132.8 70.83,132.77 v5(71.37,132.46)
  IN1 w0.114: v1(54.75,130.64) 54.69,131.51 54.69,132.17 54.97,132.45 58.04,132.45 58.66,132.38 64.73,132.38 64.91,132.57 65.57,132.8 67.89,132.8
BMC_NODE1_DDR_BA1: length 20.7
  TOP w0.102: v1(65.78,131.2) 65.78,131.31 65.21,131.88 65.21,132.93 65.45,133.18 66.43,133.18 66.67,132.94 66.67,132.54 66.49,132.36 66.1,132.36 65.95,132.21 65.95,132.03 66.23,131.75 67.13,131.75 67.3,131.91 67.3,132.78 67.48,132.97 68.09,132.97 68.59,132.47 69.6,132.47 69.99,132.86 U14.AA14 ; U15.N8 v5(58.06,130.96)
  IN1 w0.114: v1(65.78,131.2) 65.78,130.93 65.01,130.16 60.86,130.16 60.37,129.67 58.92,129.67 58.54,130.05 58.54,130.65 58.22,130.96 v5(58.07,130.96)
BMC_NODE1_DDR_BA2: length 21.4
  TOP w0.102: U15.M3 54.83,132.16 v1(55.11,131.88) ; U14.Y14 v5(70.57,132.46)
  IN1 w0.114: v5(70.57,132.46) 68.96,132.46 68.24,131.74 65.55,131.74 64.96,131.14 64.96,130.75 64.79,130.58 63.48,130.58 63.19,130.86 63.19,131.05 63.01,131.23 62.75,131.23 62.57,131.05 62.57,130.86 62.39,130.68 62.13,130.68 61.95,130.86 61.95,131.05 61.77,131.23 61.51,131.23 61.33,131.05 61.33,130.86 61.14,130.68 60.59,130.68 60,130.1 59.2,130.1 58.96,130.33 58.96,130.81 58.35,131.42 57.77,131.42 57.63,131.28 56.73,131.28 56.47,131.55 55.45,131.55 v1(55.11,131.88)
BMC_NODE1_DDR_CAS_L: length 20.1
  TOP w0.102: v1(67.74,134.32) 67.74,134.32 67.4,133.98 67.4,133.75 67.5,133.66 U14.AB13 ; U15.K3 53.67,133.85 53.95,134.13 54.91,134.13 55.5,133.53 55.5,133.12 55.31,132.93 55.05,132.93 54.86,133.12 v5(54.86,133.54)
  IN1 w0.114: v1(67.74,134.32) 67.74,134.32 67.2,133.79 64.6,133.79 64.18,133.36 56.77,133.36 56.59,133.19 55.22,133.19 v5(54.86,133.54)
BMC_NODE1_DDR_CKE: length 21.3
  TOP w0.102: U15.K9 58.88,133.76 58.99,133.88 58.99,134.09 59.15,134.25 59.4,134.25 59.61,134.04 59.61,133.54 59.84,133.31 60.22,133.31 60.37,133.47 60.37,134.2 60.47,134.3 60.88,134.3 60.98,134.2 60.98,133.42 61.08,133.31 61.44,133.31 61.59,133.46 61.59,135.19 61.29,135.5 60.8,135.5 60.66,135.36 v1(60.66,135.01) ; U14.Y12 70.97,134.45 70.58,134.06 v5(70.57,134.06)
  IN1 w0.114: v5(70.57,134.06) 70.01,134.06 68.69,135.38 63.8,135.38 63.24,134.82 62.84,134.82 62.74,134.92 62.74,135.24 62.61,135.37 62.26,135.37 62.11,135.22 62.11,134.9 61.94,134.72 60.95,134.72 v1(60.66,135.01)
BMC_NODE1_DDR_CLK_DN: length 20.4
  TOP w0.104: U15.K7 56.67,133.76 v1(56.33,134.11) ; v5(66.42,134.26) 66.42,134.44 66.75,134.77 68.12,134.77 68.83,134.06 69.42,134.06 U14.AA12
  IN3 w0.104: v5(66.42,134.26) 66.23,134.07 66.23,133.57 65.25,131.92 63.1,129.77 59.07,129.77 58.51,130.32 58.51,131.83 56.47,133.87 56.47,133.97 v1(56.33,134.11)
BMC_NODE1_DDR_CLK_DP: length 20.2
  TOP w0.104: U14.AB12 69.05,134.46 68.3,135.21 66.25,135.21 65.7,134.66 v1(65.7,134.25) ; U15.J7 v5(56.41,134.96)
  IN3 w0.104: v5(56.41,134.96) 56.41,134.6 56.82,134.19 56.82,134.02 58.87,131.98 58.87,130.47 59.21,130.12 62.95,130.12 64.97,132.14 65.87,133.67 65.87,134.08 v1(65.7,134.25)
BMC_NODE1_DDR_CS_L: length 21.3
  TOP w0.102: U14.AA13 69.79,133.28 69.1,133.28 69.04,133.34 67.05,133.34 66.8,133.58 64.14,133.58 63.69,134.04 63.69,134.19 63.81,134.32 v1(64.17,134.32) ; U15.L2 v5(53.27,132.56)
  IN1 w0.114: v5(53.27,132.56) 53.27,132.39 53.46,132.2 53.79,132.2 54,132.4 54,133.46 54.52,133.99 55,133.99 55.43,133.56 56.47,133.56 56.61,133.7 58.5,133.7 58.68,133.88 63.93,133.88 64.17,134.12 v1(64.17,134.32)
BMC_NODE1_DDR_D0: length 21.6
  TOP w0.102: U14.W12 71.77,134.46 v5(71.37,134.06) ; U15.H7 56.87,135.36 v5(57.27,134.97)
  IN3 w0.114: v5(71.37,134.06) 70.96,134.48 68.35,134.48 67.95,134.88 64.04,134.88 63.72,134.56 63.72,132.78 63.9,132.6 63.9,131.97 62.71,130.78 60.68,130.78 59.98,131.48 59.98,131.82 58.57,133.22 58.57,134.28 57.88,134.97 v5(57.27,134.97)
BMC_NODE1_DDR_D1: length 25.3
  TOP w0.102: U15.H3 54.14,135.36 v1(54.27,135.23) ; U14.V12 72.57,134.45 72.18,134.06 v5(72.17,134.06)
  IN3 w0.114: v5(72.17,134.06) 71.43,134.8 68.76,134.8 68.24,135.32 63.86,135.32 63.27,134.73 63.27,132.09 62.49,131.31 61.08,131.31 60.54,131.85 60.54,132.07 59.48,133.13 59.1,134.32 58.22,135.21 57.92,135.21 57.55,135.57 54.61,135.57 v1(54.27,135.23)
BMC_NODE1_DDR_D2: length 20.2
  TOP w0.102: v1(62.72,136.43) 65.31,136.43 65.75,136.87 66.16,136.87 66.84,136.2 67.74,136.2 67.97,135.96 68.44,135.96 69.15,135.26 U14.AB11 ; U15.F8 v5(58.07,136.56)
  IN3 w0.114: v5(58.07,136.56) 58.07,136.37 58.33,136.11 59.08,136.11 59.25,136.28 59.65,136.28 59.79,136.14 60.72,136.14 60.77,136.19 61.37,136.19 61.59,135.97 61.59,135.64 61.48,135.53 61.22,135.53 61.1,135.41 61.1,135.02 61.22,134.91 61.48,134.91 61.59,134.79 61.59,134.4 61.48,134.28 60.9,134.28 60.71,134.1 60.71,133.84 60.9,133.66 62.08,133.66 62.22,133.8 62.22,135.93 v1(62.72,136.43)
BMC_NODE1_DDR_D3: length 20.1
  TOP w0.102: U14.AA11 69.96,135.26 69.59,134.88 69.18,134.88 68.44,135.62 66.67,135.62 v1(65.97,136.33) ; v5(56.26,137.74) 56.26,137.57 U15.F7
  IN3 w0.114: v5(56.26,137.74) 56.44,137.93 57.24,137.93 57.98,138.67 59.23,139 59.69,139 60.23,138.46 61.84,138.46 62.23,138.85 64.25,138.85 66.12,136.98 66.9,136.98 67.2,136.69 67.2,136.5 67.03,136.33 v1(65.97,136.33)
BMC_NODE1_DDR_D4: length 20.7
  TOP w0.102: U14.Y11 70.97,135.26 v5(70.57,135.66) ; v1(54.77,137.85) 54.38,137.85 53.91,137.38 53.28,137.38 52.87,136.97 U15.F2
  IN3 w0.114: v5(70.57,135.66) 69.82,135.66 69.23,136.25 68.66,136.25 67.5,137.4 66.29,137.4 64.26,139.43 59.29,139.43 57.91,139.01 57.25,138.34 55.66,138.34 55.17,137.85 v1(54.77,137.85)
BMC_NODE1_DDR_D5: length 23.3
  TOP w0.102: U15.G2 v1(52.46,136.56) ; v5(71.37,135.66) 71.77,135.26 U14.W11
  IN3 w0.102: 70.34,136.06 70.67,136.06
  IN3 w0.114: v5(71.37,135.66) 70.98,136.06 70.67,136.06 ; v1(52.47,136.56) 53.88,137.66 54.54,138.32 55.2,138.32 56.35,139.47 56.78,139.47 56.96,139.29 57.33,139.29 59.29,140.04 59.65,140.1 62.35,140.57 64.97,140.57 66.76,139.44 67.24,139.14 70.33,136.06 70.34,136.06
BMC_NODE1_DDR_D6: length 22.7
  TOP w0.102: v1(58.98,135.63) 58.88,135.73 58.04,135.73 U15.H8 ; v5(72.17,135.66) 72.57,135.26 U14.V11
  IN3 w0.114: v1(58.98,135.63) 58.98,135.09 59.95,134.12 59.95,133.42 60.28,133.08 61.68,133.08 61.85,132.91 61.85,132.71 61.6,132.46 61.29,132.46 61.11,132.28 61.11,132.02 61.29,131.84 62.06,131.84 62.85,132.63 62.85,134.93 63.67,135.75 68.74,135.75 69.27,135.22 71.74,135.22 v5(72.17,135.66)
BMC_NODE1_DDR_D7: length 21.5
  TOP w0.102: U15.E3 53.66,137.76 53.27,138.16 v1(53.27,138.16) ; v5(70.57,136.46) 70.97,136.06 U14.Y10
  IN3 w0.114: v1(53.27,138.16) 54.65,138.77 55.16,138.77 55.92,139.53 56.54,139.91 56.78,140.8 57,141.02 65.1,141.02 66.58,140.14 66.76,140 67.41,139.52 68.09,138.72 70.36,136.46 v5(70.57,136.46)
BMC_NODE1_DDR_D8: length 21.5
  TOP w0.102: U15.D7 v1(56.47,138.96) ; v5(72.17,136.46) 72.57,136.06 U14.V10
  IN1 w0.102: 70.51,136.06 70.8,136.06 ; 71.27,136.06 71.55,136.06
  IN1 w0.114: v1(56.46,138.96) 55.34,137.84 55.34,137.45 55.71,137.08 60.74,137.08 61.76,138.11 65.66,138.11 66.91,136.86 69.07,136.86 69.87,136.06 70.51,136.06 ; v5(72.17,136.46) 71.77,136.06 71.55,136.06 ; 70.8,136.06 71.27,136.06
BMC_NODE1_DDR_D9: length 19
  TOP w0.102: v1(58.07,140.56) 58.07,140.57 57.67,140.17 U15.B8 ; v1(66.88,138.23) 67.42,137.69 68.19,137.69 68.9,136.97 69.26,136.97 U14.AB9
  IN1 w0.114: v1(66.88,138.23) 67.11,138.46 67.11,138.62 66.53,139.21 66.27,139.21 66.17,139.1 65.91,139.1 65.73,139.29 65.73,139.54 65.83,139.65 65.83,139.91 65.68,140.06 64.62,140.9 64.2,141.11 63.96,141.04 63.78,140.69 63.53,140.61 63.3,140.73 63.23,140.98 63.41,141.32 63.33,141.57 63.1,141.69 62.85,141.61 62.69,141.29 62.44,141.21 62.21,141.33 62.13,141.57 62.3,141.9 62.23,142.15 62.04,142.24 60.62,142.24 60.43,142.06 60.1,142.06 59.92,142.24 59.48,142.24 59.21,141.98 59.21,141.72 59.42,141.51 59.42,141.25 59.24,141.07 58.98,141.07 58.77,141.28 58.51,141.28 58.07,140.83 58.07,140.57 v1(58.07,140.56)
BMC_NODE1_DDR_D10: length 18.9
  TOP w0.102: v1(56.02,140.18) 56.02,140.29 56.69,140.96 U15.A7 ; U14.AA9 69.78,137.26 69.06,137.26 68.13,138.18 67.64,138.18 v5(67.6,138.13)
  IN1 w0.114: v1(56.02,140.18) 56.02,140.31 57.56,141.86 59.35,142.66 62.21,142.66 64.72,141.36 66.41,140.02 66.76,139.66 67.6,138.83 v5(67.6,138.13)
BMC_NODE1_DDR_D11: length 20.6
  TOP w0.102: v5(70.57,137.26) 70.97,136.86 U14.Y9 ; U15.C3 v1(54.48,140.43)
  IN1 w0.114: v1(54.48,140.43) 55.69,141.21 55.93,141.38 56.7,141.93 59.25,143.08 62.57,143.08 64.86,141.78 66.76,140.27 68.26,139.09 v5(70.57,137.26)
BMC_NODE1_DDR_D12: length 22.7
  TOP w0.102: U15.C2 v5(53.27,139.76) ; v5(71.37,137.26) 71.77,136.86 U14.W9
  IN1 w0.102: 70.98,137.93 70.98,138.16
  IN1 w0.114: v5(71.37,137.26) 70.98,137.82 70.98,137.93 ; 70.98,138.16 70.98,138.25 70.64,138.59 67.24,140.82 66.21,141.49 62.68,143.5 59.08,143.5 59.01,143.43 56.49,142.3 55.63,141.68 55.36,141.49 54.58,141.1 54.26,140.91 54.06,140.7 v5(53.27,139.76)
BMC_NODE1_DDR_D13: length 21.8
  TOP w0.102: U15.C8 57.78,139.36 58.19,138.96 58.83,138.96 59.27,138.52 v1(59.49,138.52) ; U14.V9 72.57,136.86 v5(72.17,137.26)
  IN1 w0.102: 70.79,136.86 70.48,136.86 ; 71.49,136.86 71.24,136.86
  IN1 w0.114: 70.48,136.86 69.96,136.86 69.54,137.28 67.18,137.28 66.28,138.18 66.28,138.33 65.98,138.63 65.32,138.63 65.21,138.74 65.21,138.85 65.03,139.04 64.77,139.04 64.59,138.85 64.59,138.74 64.47,138.63 61.54,138.63 60.54,137.63 57.88,137.63 57.51,138 57.51,138.27 57.82,138.58 59.43,138.58 v1(59.49,138.52) ; 71.24,136.86 70.79,136.86 ; v5(72.17,137.26) 71.77,136.86 71.49,136.86
BMC_NODE1_DDR_D14: length 20.3
  TOP w0.102: U15.A3 v1(55.07,141.92) ; v5(70.57,138.06) 70.97,137.66 U14.Y8
  IN3 w0.114: v1(55.07,141.92) 55.96,142.3 57.75,142.92 63.77,142.92 64.23,142.45 66.82,142.45 67.4,141.87 68.26,140.68 69.62,138.8 70.36,138.06 v5(70.57,138.06)
BMC_NODE1_DDR_D15: length 21.9
  TOP w0.102: v5(71.37,138.06) 71.77,137.66 U14.W8 ; U15.A2 v1(53.75,141.55)
  IN3 w0.102: 70.2,137.66 70.97,137.66
  IN3 w0.114: 70.2,137.66 69.04,138.81 66.85,141.78 66.59,142.03 63.96,142.03 63.53,142.46 57.82,142.46 56.34,141.97 55.26,141.41 54.02,141.41 v1(53.75,141.55) ; 70.97,137.66 v5(71.37,138.06)
BMC_NODE1_DDR_DM0: length 23.2
  TOP w0.102: v1(55,139.36) 55.27,139.36 U15.E7 ; U14.W10 71.77,136.06 v5(71.37,136.46)
  IN3 w0.102: v5(71.37,136.46) 70.97,136.86 70.39,136.86
  IN3 w0.114: v1(55,139.36) 55,139.46 55.63,140.47 56.41,141.25 57.96,142.04 60.36,142.04 60.81,141.59 66.29,141.59 66.54,141.34 68.82,138.43 70.39,136.86
BMC_NODE1_DDR_DM1: length 24.5
  TOP w0.102: U14.V8 72.57,137.66 v5(72.17,138.06) ; U15.D3 54.81,139.96 v1(55.95,142.93)
  IN3 w0.102: 70.39,138.46 71.6,138.46 v5(72.17,138.06)
  IN3 w0.114: 70.39,138.46 70.15,138.7 68.09,142.21 66.96,143.34 57.55,143.34 v1(55.95,142.93)
BMC_NODE1_DDR_DQS0_DN: length 20.1
  TOP w0.104: v1(63.93,137.15) 64.02,137.24 64.02,137.72 64.39,138.09 66.18,138.09 67.13,137.15 68.3,137.15 69.02,136.42 69.51,136.42 70.1,136.1 U14.AA10 ; U15.G3 53.67,136.17 53.86,136.36 54.34,136.36 v5(54.46,136.24)
  IN3 w0.104: v1(63.93,137.15) 64.13,137.35 64.13,137.59 63.96,137.76 62.55,137.76 61.61,136.81 60.96,136.81 60.29,137.48 59.59,137.48 59.21,137.11 57.05,137.11 56.79,136.84 55.92,136.84 55.85,136.76 55.57,136.76 55.14,136.34 54.55,136.34 v5(54.46,136.24)
BMC_NODE1_DDR_DQS0_DP: length 19.9
  TOP w0.104: v5(54.46,137.04) 54.21,136.79 53.84,136.79 U15.F3 ; U14.AB10 69.18,135.87 68.97,135.87 68.19,136.64 67.02,136.64 66,137.66 v1(65.55,137.66) 64.57,137.66 64.46,137.54 64.46,137.24 64.55,137.15 v5(64.69,137.15)
  IN3 w0.104: v5(64.69,137.15) 64.49,137.35 64.49,137.74 64.11,138.11 63.93,138.11 63.81,138.23 63.5,138.23 63.38,138.11 63.07,138.11 62.95,138.23 62.64,138.23 62.52,138.11 62.4,138.11 62.01,137.73 61.86,137.73 61.64,137.5 61.64,137.5 61.64,137.35 61.46,137.17 61.11,137.17 60.44,137.84 59.44,137.84 59.06,137.46 56.9,137.46 56.64,137.2 55.77,137.2 55.7,137.12 55.42,137.12 54.99,136.69 54.58,136.69 54.46,136.81 v5(54.46,137.04)
BMC_NODE1_DDR_DQS1_DN: length 18.4
  TOP w0.104: U15.B7 v1(57.27,140.56) ; v5(63.46,139.99) 63.59,139.99 63.74,139.84 63.74,139.26 64.2,138.8 64.34,138.8 64.44,138.7 64.76,138.7 64.86,138.8 65.17,138.8 65.28,138.7 65.59,138.7 65.69,138.79 66.02,138.79 66.12,138.7 66.43,138.7 66.54,138.8 67.9,138.8 68.13,138.58 68.13,138.58 69.05,137.66 U14.AB8
  IN1 w0.104: v5(63.46,139.99) 63.57,139.88 63.57,139.75 63.43,139.61 61.93,139.61 61.63,139.91 61.63,140.15 61.75,140.26 61.75,140.56 61.63,140.68 61.63,141.07 61.23,141.48 60.68,141.48 60.31,141.11 60.31,140.76 60.19,140.65 60.19,140.35 60.31,140.23 60.31,139.8 60.19,139.69 59.94,139.69 59.86,139.76 59.53,139.76 59.46,139.69 59.28,139.69 59.16,139.8 58.81,139.8 58.69,139.69 58.36,139.69 57.77,140.28 57.42,140.28 57.27,140.43 v1(57.27,140.56)
BMC_NODE1_DDR_DQS1_DP: length 18.4
  TOP w0.104: v5(57.27,139.77) U15.C7 ; v1(64.18,139.99) 64.18,139.45 64.38,139.24 68.07,139.24 69.21,138.09 69.74,138.09 U14.AA8
  IN1 w0.104: v5(57.27,139.77) 57.42,139.92 57.62,139.92 58.21,139.33 60.34,139.33 60.66,139.65 60.66,140.96 60.82,141.12 61.08,141.12 61.28,140.92 61.28,139.76 61.79,139.25 63.58,139.25 63.93,139.6 63.93,139.74 v1(64.18,139.99)
BMC_NODE1_DDR_IOZ: length 9.9
  TOP w0.381: U14.V16 v5(72.17,130.86)
  BOTTOM w0.102: v5(72.17,130.86) 72.17,131.04 71.95,131.26 70.03,131.26 69.89,131.12 R257.2 69.89,130.88 70.31,130.46 71.55,130.46 71.94,130.86 v5(72.17,130.86) ; v5(72.17,130.86) 72.17,130.72 71.77,130.32 71.77,127.92 71.99,127.7 71.99,127.23 v2(72,127.22)
BMC_NODE1_DDR_MA0: length 19.7
  TOP w0.102: U15.N3 53.67,131.19 54.13,130.73 54.13,130.09 54.32,129.9 54.96,129.9 55.29,130.23 55.29,131.11 55.75,131.57 55.75,131.96 v5(55.81,132.02) ; U14.AB14 68.83,132.86 v1(68.77,132.92)
  IN1 w0.114: v5(55.81,132.02) 56.83,132.02 56.98,132.17 57.58,132.17 57.88,131.87 58.51,131.87 59.18,131.2 59.85,131.2 59.97,131.32 59.97,131.53 60.15,131.71 64.79,131.71 65.34,132.26 67.98,132.26 68.64,132.92 v1(68.77,132.92)
BMC_NODE1_DDR_MA1: length 20.7
  TOP w0.102: v1(57.27,130.16) 57.26,130.16 U15.P7 ; U14.W15 71.77,132.06 v5(71.37,131.66)
  IN1 w0.102: 69.05,132.06 70.98,132.06 v5(71.37,131.66)
  IN1 w0.114: v1(57.27,130.16) 57.41,130.31 57.41,130.68 57.3,130.79 56.72,130.79 56.56,130.63 56.56,129.82 58.16,128.22 63.47,128.22 63.88,128.63 64.34,128.63 64.82,129.1 65.44,129.1 66.34,130 66.99,130 69.05,132.06
BMC_NODE1_DDR_MA2: length 26.8
  TOP w0.102: U15.P3 53.25,131.34 53.25,131.49 52.99,131.75 52.76,131.75 52.64,131.87 52.64,131.88 52.52,132 v5(52.46,132.56) ; U14.V15 72.57,132.06 v5(72.17,131.66)
  IN1 w0.102: 71.77,134.12 71.77,133.91 ; 71.77,133.43 71.77,133.11 ; 71.77,132.58 71.77,132.32
  IN1 w0.114: v5(72.17,131.66) 71.77,132.06 71.77,132.32 ; 71.77,133.91 71.77,133.43 ; v5(52.46,132.56) 54.88,134.98 54.89,134.98 56.07,135.41 57.68,135.41 58.94,135.2 59.78,135.2 60.14,135.36 60.31,135.43 61.82,135.8 68.9,135.8 69.3,135.4 71.01,134.62 71.49,134.54 71.77,134.26 71.77,134.12 ; 71.77,133.11 71.77,132.58
BMC_NODE1_DDR_MA3: length 22.6
  TOP w0.102: v5(52.47,130.97) 52.87,131.36 U15.N2 ; U14.Y16 v5(70.57,130.86)
  IN1 w0.114: v5(70.57,130.86) 70.06,130.86 67.98,128.78 66.1,127.17 65.04,126.72 64.67,126.65 57.62,126.65 54.5,129.77 53.95,130.19 53.18,130.97 v5(52.47,130.97)
BMC_NODE1_DDR_MA4: length 19.1
  TOP w0.102: U15.P8 v1(58.07,130.16) ; U14.AB15 68.52,132.06 68.05,132.53 67.86,132.53 67.76,132.42 67.76,131.44 67.47,131.15 v1(67.31,131.15)
  IN1 w0.114: v1(58.07,130.16) 57.54,129.64 57.54,129.45 58.26,128.73 60.19,128.73 61.1,129.64 61.4,129.64 61.58,129.46 61.58,128.92 61.76,128.74 62.01,128.74 62.2,128.93 62.2,129.46 62.39,129.64 62.64,129.64 62.83,129.46 62.83,128.92 63,128.74 63.26,128.74 63.45,128.93 63.45,129.53 63.56,129.64 63.71,129.64 64.1,129.25 64.23,129.25 64.62,129.64 65.23,129.64 66.1,130.51 66.74,130.51 67.31,131.07 v1(67.31,131.15)
BMC_NODE1_DDR_MA5: length 22.6
  TOP w0.102: U15.P2 v1(53.27,130.16) ; U14.W16 v5(71.37,130.86)
  IN1 w0.102: 70.5,130.46 70.78,130.46
  IN1 w0.114: v1(53.27,130.16) 54.33,129.2 57.4,126.13 64.85,126.13 66.27,126.73 68.18,128.4 68.26,128.47 68.61,128.78 70.29,130.46 70.5,130.46 ; 70.78,130.46 70.97,130.46 v5(71.37,130.86)
BMC_NODE1_DDR_MA6: length 20.4
  TOP w0.102: U14.AA15 69.77,131.66 68.55,131.66 67.6,130.71 65.64,130.71 64.79,131.56 64.79,133 64.61,133.18 64.27,133.18 64.15,133.06 v3(64.15,132.67) 64.15,132.3 64.05,132.2 63.53,132.2 63.4,132.33 63.4,132.72 63.25,132.87 62.94,132.87 62.7,132.64 62.7,132.12 62.59,132.01 61.31,132.01 60.73,131.43 60.73,130.78 60.19,130.24 60.19,129 59.66,128.47 58.43,128.47 58.08,128.82 58.08,129.35 U15.R8
BMC_NODE1_DDR_MA7: length 19.3
  TOP w0.102: U14.AB18 67.75,128.04 v3(64.92,128.04) 63.16,128.04 62.79,127.9 62,127.6 60.74,126.35 56.49,126.35 55.19,127.65 55.19,127.66 54.45,128.81 54.45,128.82 53.9,129.36 53.58,129.36 53.23,129.56 U15.R2
BMC_NODE1_DDR_MA8: length 19.4
  TOP w0.102: U14.AB16 68.79,131.26 67.76,130.23 65.55,130.23 64.09,131.69 63.68,131.69 63.49,131.51 61.51,131.51 61.24,131.24 61.24,131 61.35,130.9 v3(62.05,130.9) 62.72,130.9 62.83,130.79 62.83,130.47 62.65,130.29 61.79,130.29 61.45,129.94 61.31,129.94 61.06,130.19 60.86,130.19 60.71,130.03 60.71,129.68 60.87,129.51 60.87,129.37 60.87,128.96 59.94,128.03 58.21,128.03 57.67,128.57 U15.T8
BMC_NODE1_DDR_MA9: length 19.7
  TOP w0.102: U14.AA17 69.77,130.05 69.18,130.05 67.76,128.64 v3(62.72,128.64) 62.44,128.64 60.57,126.77 56.88,126.77 55.08,128.57 55.08,129.37 54.97,129.48 54.17,129.48 53.89,129.76 U15.R3
BMC_NODE1_DDR_MA10: length 21
  TOP w0.102: U14.Y15 70.97,132.06 v5(70.57,131.66) ; v1(56.04,130.99) 56.04,131.37 56.58,132.68 U15.L7
  IN1 w0.114: v1(56.04,130.99) 56.04,130.42 56.28,129.45 56.29,129.45 58.05,127.69 63.68,127.69 64.07,128.08 64.53,128.08 65.03,128.57 65.67,128.57 66.61,129.52 67.24,129.52 69.38,131.66 v5(70.57,131.66)
BMC_NODE1_DDR_MA11: length 20
  TOP w0.102: U15.R7 57.18,129.76 57.31,129.64 57.31,129.11 57.26,129.06 57.26,127.87 57.53,127.59 60.11,127.59 61.41,128.89 61.41,129.32 61.52,129.44 61.66,129.44 61.96,129.73 62.81,129.73 62.97,129.9 63.13,129.9 63.3,129.73 63.65,129.73 63.79,129.87 63.79,130.14 63.34,130.59 63.34,130.87 63.47,131 63.83,131 v3(64.18,130.65) 64.4,130.43 64.4,129.82 64.5,129.72 64.68,129.72 64.81,129.85 64.95,129.85 65.08,129.72 67.9,129.72 69.02,130.84 69.75,130.84 U14.AA16
BMC_NODE1_DDR_MA12: length 22.6
  TOP w0.102: U14.W17 71.77,130.46 v5(71.37,130.06) ; v1(55.74,129.68) 56.62,131.12 56.87,131.36 U15.N7
  IN1 w0.102: 71.77,130.94 71.77,130.68 ; 71.27,131.26 71.48,131.26 ; 70.46,131.26 70.81,131.26
  IN1 w0.114: 71.77,130.94 71.77,131.11 71.63,131.26 71.48,131.26 ; v5(71.37,130.06) 71.38,130.06 71.77,130.45 71.77,130.68 ; 70.81,131.26 71.27,131.26 ; 70.46,131.26 69.72,131.26 67.78,129.32 65.81,128.03 65.45,128.03 64.11,127.17 57.83,127.17 56.06,128.94 55.96,129.17 v1(55.74,129.68)
BMC_NODE1_DDR_MA13: length 21
  TOP w0.102: v5(70.57,130.06) 70.97,130.46 U14.Y17 ; U15.T3 v1(54.12,128.56)
  IN1 w0.102: 69.71,128.86 69.84,128.86 ; 70.18,129.17 70.18,129.42
  IN1 w0.114: v1(54.12,128.56) 54.13,128.55 57.08,125.6 65.32,125.6 67.38,126.74 68.64,127.43 69.31,128.11 69.31,128.63 69.54,128.86 69.71,128.86 ; 70.18,129.42 v5(70.57,130.06) ; 69.84,128.86 70,128.86 70.18,129.03 70.18,129.17
BMC_NODE1_DDR_MA14: length 18.8
  TOP w0.102: U15.T7 56.87,129.25 56.54,129.57 56.22,129.57 55.91,129.26 55.64,129.26 55.5,129.12 55.5,128.88 55.96,128.43 56.1,128.43 56.24,128.57 56.68,128.57 56.84,128.4 56.84,127.53 57.19,127.18 60.31,127.18 62.34,129.21 v3(64.17,129.21) 67.93,129.21 69.18,130.46 U14.AB17
BMC_NODE1_DDR_ODT: length 25.3
  TOP w0.102: U14.V14 v5(72.17,132.46) ; v5(52.46,134.17) 52.46,134.16 U15.K1
  IN1 w0.102: 72.57,133.41 72.57,133.08 ; 72.55,134.26 72.57,134.24 72.57,133.9 ; 57.87,136.16 58.27,136.16
  IN1 w0.114: 72.57,133.08 v5(72.17,132.46) ; v5(52.46,134.17) 54.09,135.63 54.09,135.64 54.28,135.69 56.05,135.82 57.87,136.16 ; 72.55,134.26 72.27,134.55 71.48,134.87 70.96,134.99 70.1,135.44 69.77,135.62 68.98,136.18 68.56,136.41 66.73,136.41 65.55,137.59 62.91,137.59 60.25,136.15 59.6,136.15 59.51,136.19 59.15,136.19 59.08,136.11 58.32,136.11 58.27,136.16 ; 72.57,133.9 72.57,133.41
BMC_NODE1_DDR_RAS_L: length 22.2
  TOP w0.102: v1(55.08,134.54) 55.48,134.94 55.48,135.7 55.25,135.93 54.93,135.93 54.7,135.7 54.7,135.04 54.22,134.56 U15.J3 ; U14.W13 71.77,133.65 71.38,133.26 v5(71.37,133.26)
  IN1 w0.102: v1(55.08,134.54) 56.51,134.54 57.49,134.56 ; 70.4,133.66 70.72,133.66
  IN1 w0.114: 57.49,134.56 57.56,134.63 58.4,134.63 58.72,134.3 63.31,134.3 63.96,134.95 68.61,134.95 69.91,133.66 70.4,133.66 ; v5(71.37,133.26) 70.97,133.66 70.72,133.66
BMC_NODE1_DDR_RST_L: length 8
  TOP w0.102: U16.4 v1(55.14,123.87) 55.14,123.87 R259.1 53.58,123.87 52.87,124.59 U15.T2
BMC_NODE1_DDR_WE_L: length 20.9
  TOP w0.102: U14.Y13 v5(70.57,133.26) ; v1(54.41,132.97) 54.41,133.63 54.33,133.71 54.13,133.71 53.82,133.4 53.54,133.4 53.43,133.29 53.43,133.07 53.54,132.96 U15.L3
  IN1 w0.114: v1(54.41,132.97) 54.6,132.77 56.54,132.77 56.83,133.06 58.42,133.06 58.67,132.8 59.77,132.8 59.91,132.94 60.73,132.94 60.87,132.8 64.38,132.8 64.94,133.36 67.86,133.36 68.12,133.62 68.12,134.09 68.46,134.44 68.62,134.44 69.8,133.26 v5(70.57,133.26)
BMC_NODE1_GFX_BLUE: length 173.1
  TOP w0.102: L39.1 28.86,56.27 28.81,56.32 C501.1 28.81,57.29 29.15,57.64 30.78,57.64 31.22,57.19 v1(31.22,55.5) ; v5(74.57,141.26) 74.97,140.86 U14.R4
  IN2 w0.114: v1(31.22,55.5) 31.22,54.5 31.49,54.23 31.49,52.12 31.69,51.92 32.36,51.92 32.56,52.12 32.56,55.88 35.22,58.54 35.22,75.92 30.43,80.7 30.43,82.47 30.66,82.7 30.95,82.7 31.18,82.47 31.18,81.02 31.4,80.8 31.71,80.8 31.93,81.02 31.93,84.29 31.75,84.47 31.75,87 21.11,97.65 21.11,132.49 25.44,136.83 28.82,136.83 31.31,139.31 44.61,139.31 50.23,144.93 52.04,144.93 52.9,145.79 55.6,145.79 56.25,146.44 56.85,146.44 57.21,146.8 61.29,146.8 62.09,146 66.82,146 67.81,145.01 71.22,145.01 73.25,142.98 73.25,142.01 73.81,141.45 74.38,141.45 v5(74.57,141.26)
  BOTTOM w0.102: v5(74.57,141.26) 74.17,141.66 74.17,142.22 73.76,142.63 73.71,142.63 71.43,144.91 v2(70.98,144.91) 70.91,144.98 R290.1
BMC_NODE1_GFX_GREEN: length 171.2
  TOP w0.102: U14.R3 74.97,141.66 v5(74.57,142.06) ; C500.1 30.02,49.61 v1(29.54,50.09) 28.94,50.69 L40.1
  IN2 w0.114: v1(29.54,50.09) 29.54,53.36 29.98,53.8 29.98,56.02 30.71,56.75 31.53,56.75 33.82,59.03 33.82,60.7 33.27,61.25 33.27,64.23 33.97,64.94 33.97,75.41 28.96,80.41 28.96,86.33 29.18,86.55 29.49,86.55 29.71,86.33 29.71,84.54 29.86,84.39 30.31,84.39 30.46,84.54 30.46,86.53 19.86,97.13 19.86,133.25 23.15,136.55 23.15,137.72 23.76,138.33 27.75,138.33 30.01,140.6 44.13,140.6 44.21,140.67 48.3,144.76 49.71,146.17 51.52,146.17 52.38,147.03 53.45,147.03 54.08,147.66 54.42,147.66 55.54,148.78 61.49,148.78 62.35,147.92 63.83,147.92 63.89,147.98 66.69,147.98 68.41,146.27 71.74,146.27 74.98,143.03 74.98,142.46 v5(74.57,142.06)
  BOTTOM w0.102: v5(74.57,142.06) 74.57,142.27 74.11,142.74 74.11,142.93 v2(73.71,143.32) 72.03,145 R291.1
BMC_NODE1_GFX_HSYNC: length 139.8
  TOP w0.102: U132.5 39.09,58.74 40.6,60.25 40.6,64.68 38.65,66.64 v1(38.59,66.64)
  IN2 w0.114: v1(38.59,66.64) 38.05,66.64 36.53,68.16 36.53,77.25 33.21,80.57 33.21,87.6 22.21,98.6 22.21,131.69 24.18,133.65 25.78,133.65 27.1,134.98 33.64,134.98 34.33,134.28 41.42,134.28 51.09,143.94 56.07,143.94 56.14,144.02 56.14,144.86 56.4,145.11 56.71,145.11 57.25,145.65 59.12,145.65 61.13,143.65 62.89,143.65 63.8,144.56 66.75,144.56 v1(67.65,143.66)
  BOTTOM w0.102: R670.2 67.83,143.85 v1(67.65,143.66)
BMC_NODE1_GFX_HSYNC_R: length 7.5
  TOP w0.102: v5(73.77,140.46) 74.17,140.86 U14.T4
  BOTTOM w0.102: R670.1 69.09,144.81 v2(69.9,144) 71.08,142.82 71.41,142.82 v5(73.77,140.46)
BMC_NODE1_GFX_RED: length 171
  TOP w0.102: v5(74.57,142.86) 74.97,142.46 U14.R2 ; L41.1 28.72,42.66 28.65,42.59 C499.1 v1(30.2,41.8)
  IN2 w0.114: v1(30.2,41.8) 30.51,42.11 30.51,50.77 30.2,51.07 30.2,53.11 30.6,53.51 30.6,55.76 30.97,56.12 31.84,56.12 34.47,58.75 34.47,61.1 33.98,61.59 33.98,62.42 34.59,63.04 34.59,75.66 29.65,80.6 29.65,82.8 31.1,84.25 31.1,86.77 20.48,97.39 20.48,132.83 25.26,137.61 28.71,137.61 30.97,139.87 31.07,139.97 44.39,139.97 44.47,140.05 49.86,145.44 49.97,145.55 51.78,145.55 52.64,146.41 55.34,146.41 55.99,147.06 56,147.06 56.58,147.64 57.45,147.64 57.9,148.09 61.29,148.09 62.29,147.09 66.63,147.09 68.09,145.63 71.49,145.63 74.27,142.86 v5(74.57,142.86)
  BOTTOM w0.102: v5(74.57,142.86) 74.57,143.14 73.48,144.23 v2(73.48,144.85) 73.48,145.15 73.12,145.51 R292.1
BMC_NODE1_GFX_VSYNC: length 143
  TOP w0.102: U132.2 37.79,53.01 39.6,54.81 39.6,58.45 41.15,60 41.15,65.02 38.7,67.48 v1(38.52,67.48)
  IN2 w0.114: v1(65.57,144) 64.14,144 63.25,143.11 60.75,143.11 58.73,145.13 57.47,145.13 57.16,144.82 57.16,144.3 56.28,143.42 51.3,143.42 41.54,133.66 33.29,133.66 32.5,134.46 27.34,134.46 26,133.12 24.4,133.12 22.75,131.47 22.75,98.82 33.75,87.82 33.75,80.79 37.06,77.47 37.06,68.36 37.94,67.48 v1(38.52,67.48)
  BOTTOM w0.102: R675.2 67.09,145.85 65.57,144.34 v1(65.57,144)
BMC_NODE1_GFX_VSYNC_R: length 6.5
  TOP w0.102: U14.U2 72.99,142.85 72.99,143.43 72.57,143.85 v5(71.8,143.85)
  BOTTOM w0.102: v5(71.8,143.85) 71.25,144.4 70.53,144.4 69.08,145.85 R675.1
BMC_NODE1_HPLLAV33: length 0.6
  TOP w0.381: U14.V17 72.57,130.46 v5(72.17,130.06)
  vias: v1(68.98,124.93)
BMC_NODE1_JTAG_TCK: length 6.1
  TOP w0.102: R304.2 82.67,146.58 83.07,146.19 v1(83.07,145.91) 82.57,145.41 82.57,143.11 82.17,142.72 U14.F2
BMC_NODE1_JTAG_TDI: length 5.1
  TOP w0.102: R300.2 81.58,146.09 v1(81.71,145.96) 82.17,145.49 U14.F1
BMC_NODE1_JTAG_TMS: length 6.3
  TOP w0.102: U14.G2 81.74,142.82 81.74,144.1 80.51,145.33 v1(80.51,146.41) R302.2
BMC_NODE1_JTAG_TRST: length 5.8
  TOP w0.102: U14.E1 82.97,143.96 83.23,144.22 83.23,144.22 v1(84.56,145.54) 84.56,146.17 83.74,146.98 R298.2
BMC_NODE1_MPLLAV33: length 0.7
  TOP w0.368: U14.AB19 69.35,128.86 v5(68.85,128.36)
  vias: v2(66.19,126.58)
BMC_NODE1_OSC1_EN:
  vias: v1(64,117.47)
BMC_NODE1_OSC1_VDD:
  vias: v1(62.11,118.27)
BMC_NODE1_USBVREF: length 1.7
  TOP w0.356: v5(69.76,127.66) 70.16,128.06 U14.AA20
  BOTTOM w0.508: R294.1 69.78,127.64 v5(69.76,127.66)
BMC_NODE1_V1PLLAV12: length 15.2
  TOP w0.356: v5(70.57,127.66) 70.97,128.06 U14.Y20 U14.W19
  BOTTOM w0.102: L19.1 63.72,120.93 v2(63.75,120.9)
  BOTTOM w0.381: 67.82,122.75 67.92,122.65 70.27,122.65 70.73,123.12 70.73,123.19 70.76,123.22 70.76,127.47 v5(70.57,127.66)
  BOTTOM w0.508: L19.1 64.45,122.29 C296.1 C297.1 C295.1 67.82,122.75
BMC_NODE1_VCC_1V8_PCIE: length 1.7
  TOP w0.368: U14.H22 80.57,126.44 80.96,126.06 v5(80.98,126.06)
  TOP w0.381: U14.G20 v5(81.78,127.66) ; v5(80.97,126.86) 80.57,127.25 U14.H21
  vias: v2(81.59,126.49)
BMC_NODE1_VCC_1V8_PCIEA: length 1.1
  TOP w0.305: U14.C21 v5(84.97,126.86) ; U14.F20 82.17,128.04 82.56,127.66 v5(82.57,127.66)
  vias: v1(85.19,125.9) v1(87.56,126.64) v1(88.29,125.95)
BMC_ROMA0: length 7.6
  TOP w0.102: U14.R20 74.97,128.06 v5(74.57,127.66)
  BOTTOM w0.102: v5(74.57,127.66) 73.91,126.99 73.91,126.86 73.63,126.58 v2(73.63,126.06) 73.63,125.76 73.56,125.69 73.56,123.32 74.54,122.34 R316.2
BMC_ROMA1: length 11.9
  TOP w0.102: U14.R21 74.97,127.07 74.61,126.7 74.61,126.27 73.98,125.63 73.98,125.47 73.63,125.13 73.63,124.24 72.05,122.67 72.05,121.98 71.85,121.78 71.85,119.05 R317.2 72.39,117.77 72.59,117.57 v1(72.59,116.93)
BMC_ROMA2: length 6.1
  TOP w0.102: U14.R22 74.97,126.25 74.23,125.51 74.23,124.4 72.82,122.98 v3(72.82,122.62) 72.39,122.19 R318.2
BMC_ROMA3: length 14
  TOP w0.102: U14.P18 v5(75.37,129.26)
  BOTTOM w0.102: R319.2 72.88,119.13 72.88,122.71 72.21,123.39 v2(72.21,125.59) 72.61,126 72.61,126.4 73.37,127.16 73.37,128.62 73.61,128.86 74.98,128.86 v5(75.37,129.26)
BMC_ROMA4: length 11.9
  TOP w0.102: U14.P19 v5(75.37,128.46)
  BOTTOM w0.102: v5(75.37,128.46) 74.97,128.06 74.97,127.49 74.34,126.86 74.34,126.58 74.14,126.38 v2(74.14,124.8) 74.14,123.37 75.23,122.27 75.23,119.02 R320.2
BMC_ROMA5: length 7.6
  TOP w0.102: U14.P20 75.77,128.06 v5(75.37,127.66)
  BOTTOM w0.102: R321.2 75.86,122.29 74.65,123.51 v2(74.65,123.64) 74.65,126.78 75.37,127.51 v5(75.37,127.66)
BMC_ROMA6: length 13.8
  TOP w0.102: R322.2 73.5,118.2 73.87,117.83 v1(73.87,116.91) 73.87,116.91 73.54,116.91 72.99,117.46 72.99,121.91 73.38,122.29 73.38,123.1 74.49,124.22 74.49,125.29 75.38,126.18 75.38,126.87 U14.P21
BMC_ROMA7: length 6
  TOP w0.102: R323.2 73.48,121.96 73.64,122.12 73.64,122.41 v3(74.11,122.88) 74.24,123.01 74.24,123.1 74.82,123.69 74.82,125.24 75.77,126.19 U14.P22
BMC_ROMA8: length 11.7
  TOP w0.102: U14.M19 v5(76.97,128.46)
  BOTTOM w0.102: R324.2 78.74,118.94 78.74,122.19 77.59,123.33 77.59,123.79 77.26,124.12 v2(77.26,126.02) 77.26,127.32 77.39,127.45 77.39,127.83 76.97,128.24 v5(76.97,128.46)
BMC_ROMA9: length 7.5
  TOP w0.102: v5(76.97,127.66) 77.37,128.06 U14.M20
  BOTTOM w0.102: v5(76.97,127.66) 76.97,127.17 76.7,126.9 76.7,124.8 v2(76.75,124.75) 76.75,124.17 77.34,123.58 77.34,123.08 78.23,122.19 R325.2
BMC_ROMA10: length 11.7
  TOP w0.102: R326.2 75.51,118.38 75.2,118.08 v1(74.63,118.08) 74.63,118.08 74.63,119.23 75.26,119.85 75.26,121.68 76.19,122.61 76.19,125.41 77,126.22 77,126.88 U14.M21
BMC_ROMA11: length 5.6
  TOP w0.102: R327.2 75.86,121.84 76.82,122.79 v3(76.82,122.84) 76.82,125.6 77.37,126.16 U14.M22
BMC_ROMA12: length 3.5
  TOP w0.102: U14.L18 78.17,129.66 v5(78.57,129.26)
  BOTTOM w0.102: v2(79.34,130.95) 78.97,130.58 78.97,129.89 78.57,129.5 v5(78.57,129.26) 78.44,129.39 R328.2
BMC_ROMA13: length 11.9
  TOP w0.102: v5(78.57,128.46) 78.46,128.57 78.17,128.86 U14.L19
  BOTTOM w0.102: v5(78.57,128.46) 78.1,127.99 v2(78.1,127.04) 78.1,126.68 78.02,126.61 78.02,124.46 78.94,123.54 78.94,122.74 79.86,121.81 79.86,118.91 R329.2
BMC_ROMA14: length 7.9
  TOP w0.102: v5(78.57,127.66) 78.51,127.72 78.17,128.06 U14.L20
  BOTTOM w0.102: R330.2 80.39,122.03 v2(79.65,122.77) 79.65,123.19 78.28,124.56 78.28,126.48 78.68,126.89 78.68,127.55 v5(78.57,127.66)
BMC_ROMA15: length 11.1
  TOP w0.102: v1(77.45,117.22) 77.46,117.23 77.46,120.92 R331.2 77.74,122.25 77.74,125.48 78.56,126.3 78.56,126.88 78.18,127.26 U14.L21
BMC_ROMA16: length 11.8
  TOP w0.102: U14.T18 v5(73.77,129.26)
  BOTTOM w0.102: v5(73.77,129.26) 73.54,129.26 73.14,128.86 72.81,128.86 72.58,128.62 72.58,126.93 71.7,126.05 v2(71.7,124.37) 71.7,122.95 72.03,122.62 72.03,121.16 71.8,120.93 R332.2
