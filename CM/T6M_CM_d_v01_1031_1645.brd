# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BMC_ROMA17: length 12.7
  TOP w0.102: U14.N18 v5(76.17,129.26)
  BOTTOM w0.102: v5(76.17,129.26) 76.57,128.86 76.57,127.31 76.37,127.12 76.37,125.34 76.12,125.08 76.12,124.07 v2(76.8,123.38) 76.8,123.1 77.72,122.19 77.72,118.87 R333.2
BMC_ROMA18: length 11.9
  TOP w0.102: U14.N19 v5(76.17,128.46)
  BOTTOM w0.102: v5(76.17,128.46) 76.17,128.44 75.77,128.04 75.77,127.49 75.18,126.9 v2(75.18,126.58) 75.08,126.48 75.08,123.91 76.42,122.57 76.42,118.87 R334.2
BMC_ROMA19: length 9.4
  TOP w0.102: U14.M18 v5(76.97,129.26)
  BOTTOM w0.102: v5(76.97,129.26) 76.97,129.05 77.69,128.34 77.69,127.32 77.59,127.22 77.59,126.68 77.77,126.51 77.77,124.14 78.23,123.69 v2(78.23,123.48) 78.23,123.07 79.32,121.98 R335.2
BMC_ROMA20: length 5.9
  TOP w0.102: R336.2 74.54,121.82 v3(75.46,122.73) 75.68,122.95 75.68,125.3 76.57,126.2 U14.N22
BMC_ROMA21: length 7.7
  TOP w0.102: U14.N20 76.57,128.06 v5(76.17,127.66)
  BOTTOM w0.102: v5(76.17,127.66) 76.17,127.55 75.74,127.12 75.74,125.46 v2(75.61,125.34) 75.41,125.13 75.41,123.99 76.93,122.47 R337.2
BMC_ROMA22: length 12.5
  TOP w0.102: R338.2 76.93,117.97 76.93,117.44 76.55,117.06 v1(75.98,117.06) 76.01,117.09 76.01,117.58 76.42,117.99 76.42,121.68 76.88,122.13 77.14,122.13 77.42,122.41 77.42,125.7 U14.L22
BMC_ROMA23: length 13.3
  TOP w0.102: U14.K18 78.97,129.66 v5(79.37,129.26)
  BOTTOM w0.102: R339.2 80.94,118.92 80.94,122.25 78.54,124.66 78.54,125.75 v2(79.32,126.53) 79.32,126.99 78.98,127.33 78.98,128.86 79.11,129 v5(79.37,129.26)
BMC_ROMD0: length 6.2
  TOP w0.102: U14.T22 74.17,126.24 73.72,125.79 73.72,125.58 73.32,125.18 73.32,124.37 71.52,122.57 v1(71.52,122.16) 71.29,121.93 R340.2
BMC_ROMD1: length 12.5
  TOP w0.102: U14.T21 73.8,126.88 73.8,126.27 73.47,125.94 73.47,125.69 73.05,125.26 73.05,124.52 70.61,122.09 70.61,117.71 v1(70.82,117.5) 71.29,117.97 R341.2
BMC_ROMD2: length 7.4
  TOP w0.102: U14.T20 74.17,128.06 v5(73.77,127.66)
  BOTTOM w0.102: v5(73.77,127.66) 73.66,127.54 73.66,126.96 73.07,126.38 73.07,123.83 v2(72.92,123.67) 72.92,123.34 73.48,122.78 R342.2
BMC_ROMD3: length 8.5
  TOP w0.102: U14.U22 73.37,126.2 73.21,126.04 73.21,125.79 72.72,125.29 72.72,124.57 70.1,121.96 v1(70.1,121.84) 70.1,119.45 R343.2
BMC_ROMD4: length 9.7
  TOP w0.102: R344.2 68.92,119.41 69.5,120 v1(69.5,120.04) 69.5,122.21 72.46,125.17 72.46,125.4 72.96,125.9 72.96,126.85 U14.U21
BOT_85OHM: length 207.3
  BOTTOM w0.102: 1.55,163.05 1.24,163.05
  BOTTOM w0.127: 1.55,163.05 1.55,162.55 -2.31,140.69 1,121.94 -0.42,113.87 -1.21,109.36 -1.05,108.45 4.93,74.47 3.08,63.91 3.08,61.41 3.15,61.34 J29.3 ; 1.24,163.05 1.24,162.56 -2.62,140.69 0.17,124.91 0.69,121.94 -0.73,113.87 -1.52,109.36 -1.36,108.45 4.62,74.47 2.78,63.96 2.77,63.93 2.77,61.41 2.7,61.34 J29.2
CLK_14M_CPU_NODE1: length 100.1
  TOP w0.102: v1(155.62,104.83) 155.3,104.83 152.15,107.97 R10.2 ; U2.P46 76.47,82.71 v1(76.71,82.48)
  IN3 w0.114: v1(76.71,82.48) 76.71,81.25 78.08,79.88 90.08,79.88 91.05,78.91 96.9,78.91 97.37,78.44 99.18,78.44 99.79,77.84 99.79,77.47 101.04,76.22 103.65,76.22 105.71,78.28 108.09,78.28 115.03,85.22 121.72,85.22 138.25,101.75 152.63,101.75 155.62,104.74 v1(155.62,104.83)
CLK_14M_CPU_NODE1_R: length 8.9
  TOP w0.102: R10.1 R22.1 150.57,108.9 150.57,110.93 150.32,111.18 R26.2 149.56,112.19 v1(149.23,112.52) 147.81,112.52 147.19,113.15 U1.13
CLK_25M_SATA_NODE1: length 53.8
  TOP w0.102: v1(152.26,98.79) 144.95,106.1 144.95,108.56 144.07,109.44 R9.2 ; U30.35 162.22,66.76 162.81,67.35 162.92,67.35 v1(162.93,67.35)
  BOTTOM w0.102: v1(152.26,98.79) 152.26,98.61 152.64,98.24 152.64,88.16 160.36,80.45 161.95,80.45 164.03,78.37 164.03,72.85 162.95,71.78 162.95,69.86 162.36,69.26 162.36,67.92 v1(162.93,67.35)
CLK_25M_SATA_NODE1_R: length 4.1
  TOP w0.102: R9.1 144.07,110.57 143.74,110.91 143.74,111.53 v1(143.59,111.68) 143.82,111.91 143.82,112.78 143.59,113.01 U1.4
CLK_33K_CPLD23: length 67
  TOP w0.102: U128.64 92.53,163.56 92.76,163.32 92.76,162.15 93.66,161.25 98.98,161.25 v1(99.81,162.08) ; U129.64 150.06,163.36 v1(150.06,161.45) R1055.2
  IN1 w0.114: v1(150.06,161.45) 144.45,161.45 144.17,161.73 141.64,161.73 141.58,161.67 138.31,161.67 137.07,160.43 132.05,160.43 130.59,161.89 128.88,161.89 127.7,163.07 123.97,163.07 123.7,162.79 122.26,162.79 121.56,163.49 119.45,163.49 119.22,163.72 115.6,163.72 114.7,164.62 110.74,164.62 109.56,163.43 108.99,163.43 108.7,163.15 107.2,163.15 106.02,161.97 101.15,161.97 100.94,161.76 100.13,161.76 v1(99.81,162.08)
CLK_33K_CPU_NODE1_SUSCLK: length 148.7
  TOP w0.102: R1052.2 v1(91.59,95.05) 91.19,93.49 90.02,92.32 89.81,92.32 89.53,92.03 89.52,92.03 89.03,91.54 89.03,91.54 87.73,90.23 87.73,86.6 v1(87.84,86.48) ; v1(192.57,120.9) 192.04,120.37 U102.E2
  IN3 w0.114: v1(87.84,86.48) 88.87,87.52 90.14,87.52 90.47,87.85 90.83,87.85 91.13,87.54 93.99,87.54 94.17,87.72 97.9,87.72 100.43,85.19 109.85,85.19 111.85,87.19 121.18,87.19 137.6,103.61 149.88,103.61 153.41,107.14 153.49,107.14 153.49,107.14 154.91,107.14 160.77,113.01 160.77,117.21 172.48,128.92 172.99,128.92 173.77,129.7 177.03,129.7 177.76,130.43 178.42,130.43 178.98,129.87 187.43,129.87 188.51,128.79 188.51,127.35 189.07,126.8 189.07,123.65 189.35,123.36 191.77,123.36 192.04,123.09 192.04,121.42 v1(192.57,120.9)
  BOTTOM w0.102: R139.1 91.58,95.06 v1(91.59,95.05)
CLK_33K_CPU_NODE1_SUSCLK_R: length 1.9
  TOP w0.102: R1052.1 91.19,97.06 v1(90.9,97.36) 90.42,96.89 OSC5.3
CLK_33K_CPU_NODE1_SUSCLK_RR: length 138.8
  TOP w0.102: v1(78.63,83.44) 78.63,83.44 78.06,83.44 77.85,83.23 77.85,81.45 78.08,81.22 78.54,81.22 78.85,81.53 U2.T52
  BOTTOM w0.102: R139.2 92.38,94.28 91.99,93.89 91.41,93.89 90.99,94.32 90.99,96.72 91.3,97.03 92.24,97.03 92.67,97.46 92.67,98.88 92.47,99.08 91.21,99.08 91.01,99.28 91.01,99.74 91.21,99.94 92.47,99.94 92.87,100.35 93.18,100.35 93.39,100.15 93.39,96.38 93.54,96.23 93.95,96.23 94.11,96.38 94.11,100.15 94.31,100.35 94.62,100.35 94.82,100.15 94.82,95.97 94.98,95.81 95.39,95.81 95.54,95.97 95.54,100.15 95.75,100.35 96.06,100.35 96.26,100.15 96.26,95.23 96.47,95.02 96.78,95.02 96.98,95.23 96.98,97.23 98.54,98.79 101.73,98.79 101.97,99.02 101.97,99.38 101.7,99.65 98.79,99.65 98.62,99.83 98.62,100.08 98.79,100.26 102.2,100.26 102.38,100.44 102.38,100.69 102.2,100.87 98.79,100.87 98.62,101.05 98.62,101.3 98.79,101.48 103.75,101.48 103.9,101.63 103.9,101.94 103.75,102.09 98.57,102.09 98.39,102.27 98.39,102.52 98.57,102.7 103.31,102.7 103.49,102.88 103.49,103.13 103.31,103.31 98.37,103.31 98.17,103.51 98.17,103.84 98.37,104.05 103.75,104.05 103.95,104.25 103.95,104.58 103.75,104.78 97.24,104.78 96.57,104.11 96.57,101.19 96.37,100.99 87.99,100.99 86.87,99.87 84.29,99.87 83.94,99.52 83.01,99.52 82.66,99.87 80.06,99.87 79.38,99.19 79.38,98.24 79.7,97.92 79.7,97.12 79.33,96.75 79.33,94.6 78.92,94.19 78.92,89.51 v2(78.32,87.27) 78.08,87.02 78.08,85.11 78.34,83.83 78.34,83.73 v1(78.63,83.44)
CLK_33M_PORT80: length 69.8
  TOP w0.102: R188.2 v1(146.89,107.24) ; U115.43 99.9,125.82 100.52,126.44 101.58,126.44 102.59,127.45 105.36,127.45 106.14,126.67 107.6,126.67 v1(107.67,126.59)
  IN1 w0.114: v1(108.28,109.44) 107.65,110.07 107.65,116.92 106.89,117.67 106.89,118.04 107.42,118.57 107.42,120.42 107.6,120.59 107.6,126.51 v1(107.67,126.59)
  IN2 w0.114: v1(108.28,109.44) 108.37,109.44 110.84,106.97 131.24,106.97 133.5,104.71 144.05,104.71 146.58,107.24 v1(146.89,107.24)
CLK_48M_SIO: length 101.7
  TOP w0.102: R135.2 154.05,113.4 157.17,110.28 157.17,102.1 151.93,96.86 151.93,85.42 150.15,83.64 148.89,83.64 147.64,82.4 147.64,78.33 142.84,73.53 142.84,71.42 141.32,69.9 136.57,69.9 129.81,63.14 129.81,59.43 126,55.62 126,53.16 124,51.17 124,43.47 124.42,43.05 124.42,38.78 124.97,38.23 129.35,38.23 v1(129.35,38.25) 130.13,38.25 131.02,39.14 R815.1
CLK_100M_BMC_NODE1_DN: length 80.1
  TOP w0.127: v1(85.07,119.54) 84.87,119.34 84.1,119.34 81.51,121.93 81.51,125.45 81.76,125.7 81.76,126.88 U14.G21 ; U1.43 140.76,120.11 140.71,120.07 140.39,120.07 139.27,121.19 134.49,121.19 v1(133.98,121.69)
  IN3 w0.127: v1(85.07,119.54) 85.31,119.31 87.33,119.31 89.59,117.05 92.78,117.05 93.02,117.3 93.94,117.3 98.73,112.5 104.23,112.5 104.32,112.6 111.74,112.6 112.89,111.44 130.12,111.44 133.02,114.34 133.02,115.05 132.27,115.8 132.27,120.46 133.02,121.2 133.85,121.2 133.98,121.34 v1(133.98,121.69)
CLK_100M_BMC_NODE1_DP: length 80
  TOP w0.127: U1.44 140.76,119.71 140.71,119.76 140.27,119.76 139.14,120.88 134.44,120.88 v1(133.98,120.42) ; U14.G22 81.45,126.38 81.45,125.83 81.2,125.58 81.2,125.32 81.06,125.17 81.06,124.79 81.2,124.64 81.2,124.26 81.06,124.11 81.06,123.73 81.2,123.58 81.2,121.8 81.63,121.38 81.63,121.19 81.9,120.92 82.09,120.92 83.97,119.03 84.82,119.03 v1(85.07,118.78)
  IN3 w0.127: v1(85.07,118.78) 85.31,119.02 87.21,119.02 89.47,116.76 92.9,116.76 93.14,117.01 93.82,117.01 98.61,112.21 104.35,112.21 104.44,112.31 111.62,112.31 112.77,111.15 130.24,111.15 133.31,114.22 133.31,115.17 132.57,115.92 132.57,120.34 133.14,120.91 133.84,120.91 133.98,120.77 v1(133.98,120.42)
CLK_100M_CPU_NODE1_DN: length 109.7
  TOP w0.127: U2.V20 63.31,80.46 v1(63.61,80.16) ; v1(134.28,107.23) 134.77,107.71 134.77,115.56 136.08,116.87 139.14,116.87 139.55,117.28 140.97,117.28 141.01,117.31 U1.50
  IN3 w0.127: v1(63.61,80.16) 63.89,80.44 63.89,80.82 63.65,81.07 63.65,87.22 65.54,89.11 65.54,90.61 66.45,91.53 74.45,91.53 76.16,93.23 81.49,93.23 82.22,92.5 89.79,92.5 90.52,91.78 97.74,91.78 97.97,91.55 103.15,91.55 103.82,90.87 110.52,90.87 112.23,89.17 120.32,89.17 134.77,103.62 134.77,106.74 v1(134.28,107.23)
CLK_100M_CPU_NODE1_DP: length 109.6
  TOP w0.127: U2.V21 v1(64.43,80.2) ; U1.51 140.99,116.91 140.93,116.97 139.68,116.97 139.27,116.57 136.2,116.57 135.07,115.43 135.07,114.74 135.22,114.59 135.22,114.21 135.07,114.06 135.07,113.05 135.2,112.92 135.2,112.54 135.07,112.41 135.07,112.03 135.2,111.9 135.2,111.52 135.07,111.39 135.07,111.01 135.2,110.88 135.2,110.5 135.07,110.37 135.07,107.71 v1(135.55,107.23)
  IN3 w0.127: v1(135.55,107.23) 135.06,106.74 135.06,103.5 120.44,88.88 112.11,88.88 110.4,90.58 103.7,90.58 103.03,91.26 97.85,91.26 97.62,91.48 90.39,91.48 89.67,92.21 82.1,92.21 81.37,92.94 76.28,92.94 74.57,91.23 66.57,91.23 65.83,90.49 65.83,88.99 63.94,87.1 63.94,81.19 64.18,80.94 64.18,80.45 v1(64.43,80.2)
CLK_100M_DDR3_NODE1_DN: length 107.3
  TOP w0.127: v1(138.3,98.7) 138.81,99.2 138.81,100.14 136.29,102.65 136.29,114.52 137.51,115.73 139.32,115.73 139.65,116.06 140.92,116.06 140.98,116.11 U1.53 ; U2.BF45 75.76,66.61 v1(75.39,66.98)
  IN3 w0.102: v1(75.39,66.98) 75.49,66.98 75.59,67.08 75.59,67.57 75.5,67.67 75.5,67.97 75.59,68.06 75.59,68.44 75.5,68.54 75.5,68.84 75.59,68.94 75.59,69.25 76.37,70.03 77.59,70.03 77.77,69.85 78.5,69.85 78.56,69.91 78.56,71.74 78.84,72.01 80.05,72.01 80.1,72.06 80.12,72.06
  IN3 w0.127: 80.12,72.06 83.18,72.06 83.74,72.62 83.74,73.08 84.26,73.6 84.26,74.43 85.35,75.52 88.39,75.52 88.86,75.99 95.68,75.99 96.61,75.06 97.63,75.06 98.42,74.27 98.42,73.92 98.78,73.55 99.4,73.55 99.69,73.26 106.83,73.26 115.56,81.99 115.56,81.99 115.82,82.25 123.05,82.25 123.42,82.62 123.42,82.72 123.42,82.82 123.69,83.09 123.89,83.09 124.16,83.36 124.16,83.46 124.16,83.56 124.43,83.83 124.63,83.83 124.9,84.1 124.9,84.2 124.9,84.3 125.17,84.57 125.37,84.57 125.64,84.84 125.64,84.94 125.64,85.04 125.91,85.31 126.11,85.31 126.38,85.58 126.38,85.68 126.38,85.78 126.65,86.05 126.85,86.05 127.12,86.32 127.12,86.42 127.12,86.52 127.39,86.79 127.59,86.79 127.86,87.06 127.86,87.16 127.86,87.26 128.13,87.53 128.33,87.53 138.81,98.01 138.81,98.18 v1(138.3,98.7)
CLK_100M_DDR3_NODE1_DP: length 107.2
  TOP w0.127: U2.BG45 75.76,65.84 v1(75.39,66.22) ; U1.54 140.91,115.71 140.87,115.75 139.78,115.75 139.45,115.42 137.63,115.42 136.6,114.39 136.6,112.19 136.73,112.06 136.73,111.67 136.6,111.54 136.6,111.16 136.73,111.03 136.73,110.65 136.6,110.52 136.6,110.14 136.73,110.01 136.73,109.63 136.6,109.5 136.6,109.11 136.73,108.98 136.73,108.6 136.6,108.47 136.6,108.09 136.73,107.96 136.73,107.58 136.6,107.45 136.6,102.78 139.11,100.27 139.11,99.15 v1(139.57,98.7)
  IN3 w0.102: 80.12,71.77 80.1,71.77 80.05,71.81 78.92,71.81 78.77,71.66 78.77,69.83 78.59,69.64 77.68,69.64 77.5,69.82 76.46,69.82 75.8,69.16 75.8,66.81 75.39,66.4 v1(75.39,66.22)
  IN3 w0.127: 80.12,71.77 83.3,71.77 84.03,72.5 84.03,72.96 84.56,73.48 84.56,74.31 85.47,75.23 88.51,75.23 88.98,75.7 95.56,75.7 96.49,74.76 97.51,74.76 98.13,74.15 98.13,73.8 98.66,73.26 99.27,73.26 99.57,72.97 106.95,72.97 115.68,81.7 115.69,81.7 115.94,81.96 123.17,81.96 139.11,97.89 139.11,98.23 v1(139.57,98.7)
CLK_100M_NIC1_NODE1_DN: length 123.3
  TOP w0.127: v1(145.37,125.25) 145.16,125.25 144.88,124.98 144.88,122.64 144.73,122.48 144.73,121.62 144.79,121.57 U1.36 ; U35.25 61.79,155.17 61.89,155.27 62.79,155.27 63.33,155.82 64.6,155.82 v1(65.09,155.32)
  IN1 w0.127: v1(145.37,125.25) 145.11,125.25 144.88,125.49 144.88,126.25 144.88,126.25 144.88,126.57 144.14,127.31 143.39,127.31 131.16,139.54 131.16,144.05 128.46,146.75 101.01,146.75 96.59,151.16 96.59,158.93 95.96,159.56 93.1,159.56 92.39,160.28 91.06,160.28 90.57,159.78 87.98,159.78 83.41,164.34 79.73,164.34 78.56,165.51 74.83,165.51 73.6,164.28 67.42,164.28 65.66,162.53 65.66,160.01 64.02,158.36 64.02,156.15 64.36,155.81 64.61,155.81 v1(65.09,155.32)
CLK_100M_NIC1_NODE1_DP: length 123.3
  TOP w0.127: v1(144.1,125.25) 144.33,125.25 144.58,125.01 144.58,122.76 144.43,122.61 144.43,121.57 144.39,121.53 U1.37 ; v1(65.09,156.59) 64.62,156.12 63.21,156.12 62.66,155.58 61.89,155.58 61.79,155.67 U35.26
  IN1 w0.127: v1(65.09,156.59) 64.61,156.11 64.48,156.11 64.31,156.28 64.31,158.24 65.96,159.89 65.96,162.41 67.54,163.99 73.72,163.99 74.95,165.22 78.44,165.22 79.61,164.05 83.29,164.05 87.85,159.49 90.69,159.49 91.19,159.98 92.27,159.98 92.98,159.27 95.84,159.27 96.3,158.81 96.3,151.04 100.88,146.45 128.34,146.45 130.86,143.93 130.86,139.42 131.23,139.05 131.23,138.85 131.5,138.58 131.71,138.58 131.98,138.31 131.98,138.1 132.25,137.83 132.45,137.83 133.33,136.95 133.33,136.77 133.6,136.5 133.78,136.5 134.05,136.23 134.05,136.05 134.32,135.78 134.5,135.78 134.77,135.51 134.77,135.33 135.04,135.06 135.22,135.06 135.49,134.8 135.49,134.61 135.76,134.35 135.94,134.35 136.21,134.08 136.21,133.9 136.48,133.63 136.66,133.63 136.93,133.36 136.93,133.18 137.2,132.91 137.38,132.91 137.65,132.64 137.65,132.46 137.92,132.19 138.1,132.19 138.37,131.92 138.37,131.74 138.64,131.47 138.82,131.47 139.09,131.2 139.09,131.02 139.36,130.75 139.54,130.75 139.81,130.48 139.81,130.3 140.08,130.03 140.26,130.03 140.53,129.76 140.53,129.58 140.79,129.31 140.98,129.31 143.27,127.01 144.02,127.01 144.58,126.45 144.58,126.13 144.59,126.13 144.59,125.47 144.37,125.25 v1(144.1,125.25)
CLK_100M_NIC2_NODE1_DN: length 52.5
  TOP w0.127: v1(162.87,152.58) 163.37,152.08 166.52,152.08 167.18,152.75 167.76,152.75 167.86,152.85 U37.25 ; v1(159.06,130.08) 158.58,129.59 158.58,129.24 155.38,126.04 147.63,126.04 146.87,125.27 146.87,122.94 146.33,122.41 146.33,121.56 146.39,121.5 U1.32
  BOTTOM w0.127: v1(159.06,130.08) 158.58,130.56 158.58,135.69 159.64,136.76 159.64,143.31 161.1,144.77 163.68,144.77 164.48,145.57 164.48,151.32 163.71,152.09 163.36,152.09 v1(162.87,152.58)
CLK_100M_NIC2_NODE1_DP: length 52.5
  TOP w0.127: U37.26 167.8,152.35 167.7,152.44 167.31,152.44 166.64,151.78 163.35,151.78 v1(162.87,151.31) ; U1.33 145.99,121.52 146.03,121.57 146.03,122.53 146.56,123.07 146.56,125.4 147.5,126.34 155.25,126.34 158.27,129.36 158.27,129.59 v1(157.79,130.08)
  BOTTOM w0.127: v1(162.87,151.31) 163.36,151.79 163.58,151.79 164.18,151.2 164.18,150.82 164.03,150.68 164.03,150.3 164.18,150.15 164.18,149.77 164.03,149.63 164.03,149.25 164.18,149.1 164.18,145.7 163.56,145.08 163.03,145.08 162.9,145.21 162.51,145.21 162.38,145.08 162,145.08 161.86,145.21 161.48,145.21 161.35,145.08 160.98,145.08 159.34,143.44 159.34,136.89 158.27,135.82 158.27,130.56 v1(157.79,130.08)
CLK_100M_PCIE_RP0_NODE1_DN: length 160.5
  TOP w0.114: v1(56.04,66.7) 56,66.7 55.69,67.02 55.56,67.02 55.49,66.95 U2.BF4
  TOP w0.127: U1.41 142.79,121.74 142.74,121.79 142.74,122.57 141.99,123.32 141.99,123.32 141.53,123.77 141.53,123.77 141.4,123.9 141.4,126.51 141.66,126.76 v1(141.88,126.76)
  IN3 w0.127: v1(56.04,66.7) 56.28,66.94 56.31,66.97 56.31,67.3 56.71,67.7 57.81,67.7 58.21,68.1 59.58,68.1 60,68.51 60,69.09 61.24,70.33 61.24,70.94 60.57,71.61 55.53,71.61 54.7,72.44 54.7,84.99 55.6,85.89 55.6,90.87 56.59,91.87 63,91.87 65.43,94.3 71.17,94.3 71.67,94.8 74.21,94.8 74.78,94.23 90.43,94.23 91.73,92.93 98.63,92.93 99.52,93.82 102.98,93.82 103.23,93.57 109.8,93.57 113.1,90.27 113.53,90.27 113.67,90.4 114.05,90.4 114.18,90.27 114.56,90.27 114.69,90.4 115.08,90.4 115.21,90.27 115.59,90.27 115.72,90.4 116.1,90.4 116.24,90.27 116.62,90.27 116.75,90.4 117.13,90.4 117.27,90.27 117.65,90.27 117.78,90.4 118.16,90.4 118.29,90.27 118.67,90.27 118.81,90.4 119.19,90.4 119.32,90.27 120.11,90.27 131.38,101.54 131.38,101.74 131.65,102.01 131.85,102.01 132.12,102.28 132.12,102.48 132.39,102.75 132.59,102.75 133.46,103.62 133.46,104.77 133.15,105.08 133.15,107.64 136.86,111.35 136.86,114.04 138.73,115.9 138.73,118.67 141.15,121.1 141.15,122.37 142.96,124.17 142.96,127.02 142.29,127.69 141.71,127.69 141.4,127.38 141.4,126.94 141.57,126.76 v1(141.88,126.76)
CLK_100M_PCIE_RP0_NODE1_DP: length 160.6
  TOP w0.114: U2.BE5 56.05,67.12 56.22,67.12 56.63,66.71 v1(56.81,66.71)
  TOP w0.127: v1(140.61,126.76) 140.87,126.76 141.09,126.53 141.09,123.78 141.41,123.47 141.41,123.47 141.68,123.19 142.43,122.44 142.43,121.79 142.39,121.74 U1.42
  IN3 w0.127: v1(140.61,126.76) 140.91,126.76 141.1,126.96 141.1,127.5 141.59,127.98 142.41,127.98 143.25,127.14 143.25,124.05 141.44,122.24 141.44,120.98 139.02,118.55 139.02,115.78 137.15,113.92 137.15,111.23 133.44,107.52 133.44,105.2 133.75,104.89 133.75,103.5 120.23,89.98 112.98,89.98 109.67,93.28 103.11,93.28 102.86,93.53 99.64,93.53 98.75,92.64 91.61,92.64 90.31,93.94 74.66,93.94 74.08,94.51 71.79,94.51 71.29,94.01 65.55,94.01 63.12,91.58 56.71,91.58 55.89,90.75 55.89,85.76 55,84.87 55,72.56 55.65,71.9 60.7,71.9 61.54,71.06 61.54,70.21 60.29,68.97 60.29,68.39 59.7,67.81 58.33,67.81 57.93,67.4 56.83,67.4 56.6,67.18 56.6,66.91 v1(56.81,66.71)
CLK_100M_PCIE_SW_NODE1_C_DN: length 5.9
  TOP w0.127: U125.93 138.55,138.58 138.81,138.84 138.81,138.84 139.42,138.84 v1(139.88,138.39)
  BOTTOM w0.127: C193.2 141.15,137.5 141.15,138.47 140.51,139.11 140.16,139.11 139.88,138.83 v1(139.88,138.39)
CLK_100M_PCIE_SW_NODE1_C_DP: length 6
  TOP w0.127: U125.91 138.56,139.38 138.79,139.15 139.37,139.15 v1(139.88,139.66)
  BOTTOM w0.127: C192.2 141.46,137.5 141.46,138.59 140.64,139.41 140.12,139.41 v1(139.88,139.66)
CLK_100M_PCIE_SW_NODE1_DN: length 47.7
  TOP w0.127: v1(157.43,119.21) 156.94,118.71 149.88,118.71 149.63,118.47 149.11,118.47 149.07,118.51 U1.24
  BOTTOM w0.127: v1(157.43,119.21) 157.91,118.73 158.8,118.73 159.51,119.44 159.51,120.48 158.37,121.62 158.11,121.62 156.58,120.09 156.06,120.09 155.7,120.45 155.7,120.97 157.23,122.5 157.23,122.76 155.99,124 153.59,124 151.46,126.12 146.72,126.12 145.92,126.92 142.91,126.92 141.03,128.79 141.03,129.21 140.9,129.35 140.9,129.73 141.03,129.86 141.03,130.24 140.9,130.38 140.9,130.76 141.03,130.89 141.03,131.27 140.9,131.41 140.9,131.79 141.03,131.92 141.03,132.3 140.9,132.44 140.9,132.82 141.03,132.95 141.03,135.06 141.14,135.16 141.14,136 C193.1
CLK_100M_PCIE_SW_NODE1_DP: length 47.8
  TOP w0.127: U1.23 149.07,118.11 149.12,118.17 149.76,118.17 150,118.41 156.96,118.41 v1(157.43,117.94)
  BOTTOM w0.127: v1(157.43,117.94) 157.91,118.42 158.04,118.42 158.04,118.42 158.92,118.42 159.81,119.31 159.81,120.6 158.5,121.92 157.98,121.92 156.45,120.39 156.19,120.39 156.01,120.58 156.01,120.84 157.53,122.37 157.53,122.89 156.12,124.3 153.71,124.3 151.59,126.42 146.85,126.42 146.05,127.22 143.03,127.22 141.34,128.92 141.34,132.84 141.34,132.84 141.34,134.93 141.44,135.04 141.44,135.97 C192.1
CLK_100M_SATA_NODE1_DN: length 73.7
  TOP w0.127: v1(148.69,124.03) 148.46,124.03 148.21,123.79 148.21,122.87 147.14,121.8 147.14,121.56 147.19,121.52 U1.30 ; U30.46 157.96,69.46 158.01,69.64 158.01,70.81 157.54,71.27 157.54,76.19 157.12,76.61 157.12,79.61 158.4,80.88 160.79,80.88 161.38,81.48 161.38,81.88 161.16,82.1 v1(160.87,82.1)
  BOTTOM w0.127: v1(160.87,82.1) 161.23,82.1 161.36,82.23 161.36,84.64 161.15,84.84 161.15,85.23 161.36,85.43 161.36,85.81 161.15,86.02 161.15,86.4 161.36,86.61 161.36,86.99 161.15,87.2 161.15,87.58 161.36,87.78 161.36,88.16 161.15,88.37 161.15,88.75 161.36,88.96 161.36,89.34 161.15,89.55 161.15,89.93 161.36,90.13 161.36,90.96 154.52,97.79 154.52,118.94 154.04,119.42 154.04,122.18 151.03,125.2 148.69,125.2 148.21,124.72 148.21,124.24 148.41,124.03 v1(148.69,124.03)
CLK_100M_SATA_NODE1_DP: length 73.6
  TOP w0.127: U1.31 146.79,121.46 146.84,121.51 146.84,121.93 147.91,122.99 147.91,123.79 147.66,124.03 v1(147.42,124.03) ; U30.45 158.36,69.49 158.32,69.64 158.32,70.93 157.85,71.4 157.85,76.31 157.43,76.73 157.43,79.48 158.52,80.58 160.91,80.58 161.68,81.35 161.68,81.93 161.86,82.1 v1(162.14,82.1)
  BOTTOM w0.127: v1(162.14,82.1) 161.66,82.59 161.66,91.09 154.83,97.92 154.83,119.07 154.35,119.55 154.35,122.31 151.16,125.5 148.56,125.5 147.91,124.85 147.91,124.2 147.74,124.03 v1(147.42,124.03)
CLK_100M_USB_NODE1_DN: length 57.4
  TOP w0.127: v1(155.38,128.05) 154.9,128.53 153.81,128.53 152.84,127.56 148.82,127.56 148.65,127.39 148.27,127.39 148.1,127.56 147.72,127.56 147.55,127.39 147.17,127.39 147.01,127.56 146.63,127.56 146.46,127.39 146.08,127.39 145.91,127.56 145.53,127.56 145.36,127.39 144.98,127.39 144.81,127.56 144.19,127.56 143.33,126.69 143.33,124.32 143.72,123.93 143.72,122.89 143.94,122.66 143.94,121.57 143.99,121.53 U1.38 ; U32.5 174.82,102.54 174.72,102.63 174.27,102.63 173.55,103.35 172.71,103.35 v1(172.23,102.87)
  BOTTOM w0.127: v1(172.23,102.87) 171.75,103.35 171.49,103.35 170.91,103.93 170.91,108.12 167.93,111.11 167.93,118.22 158.45,127.7 157.01,127.7 156.19,128.53 155.87,128.53 v1(155.38,128.05)
CLK_100M_USB_NODE1_DP: length 57.4
  TOP w0.127: v1(155.38,129.32) 154.9,128.83 153.68,128.83 152.71,127.87 144.07,127.87 143.02,126.82 143.02,124.19 143.41,123.81 143.41,122.76 143.64,122.54 143.64,121.55 143.59,121.49 U1.39 ; v1(172.23,104.14) 172.71,103.66 173.68,103.66 174.4,102.94 U32.4
  BOTTOM w0.127: v1(155.38,129.32) 155.87,128.83 156.31,128.83 157.14,128.01 158.58,128.01 168.23,118.35 168.23,111.23 171.22,108.25 171.22,104.06 171.62,103.66 171.75,103.66 v1(172.23,104.14)
CLK_100M_XDP_NODE1_DN: length 70.3
  TOP w0.127: v1(126.3,67.85) 126.3,68.2 126.17,68.33 125.4,68.33 125.22,68.15 125.22,67.47 124.27,66.52 123.93,66.52 123.82,66.41 J3.42 ; U1.46 141.03,118.91 140.99,118.88 139.83,118.88 139.55,118.6 136.38,118.6 136.16,118.37 134.81,118.37 134.68,118.5 v1(134.68,118.86)
  BOTTOM w0.127: v1(126.3,67.85) 126.3,68.2 126.42,68.33 127.81,68.33 129.34,69.86 129.34,80.36 130.4,81.42 130.4,95.01 136.84,101.44 136.84,108.88 136.23,109.49 136.23,117.63 135.48,118.37 134.81,118.37 134.68,118.5 v1(134.68,118.86)
CLK_100M_XDP_NODE1_DP: length 70.2
  TOP w0.127: J3.40 123.82,66.91 123.9,66.82 124.14,66.82 124.92,67.59 124.92,68.28 125.28,68.64 126.17,68.64 126.3,68.76 v1(126.3,69.12) ; U1.47 141.05,118.51 140.99,118.57 139.96,118.57 139.68,118.29 136.51,118.29 136.28,118.07 134.81,118.07 134.68,117.94 v1(134.68,117.59)
  BOTTOM w0.127: v1(126.3,69.12) 126.3,68.76 126.42,68.64 127.69,68.64 129.04,69.99 129.04,72.89 128.91,73.02 128.91,73.4 129.04,73.53 129.04,73.91 128.91,74.04 128.91,74.42 129.04,74.54 129.04,74.93 128.91,75.05 128.91,75.43 129.04,75.56 129.04,80.49 130.1,81.55 130.1,95.13 136.53,101.57 136.53,108.75 135.92,109.36 135.92,111.08 135.79,111.21 135.79,111.59 135.92,111.72 135.92,112.1 135.79,112.23 135.79,112.61 135.92,112.74 135.92,113.12 135.79,113.25 135.79,113.64 135.92,113.77 135.92,114.15 135.79,114.28 135.79,114.66 135.92,114.79 135.92,115.17 135.79,115.3 135.79,115.68 135.92,115.81 135.92,116.19 135.79,116.32 135.79,116.7 135.92,116.83 135.92,117.5 135.36,118.07 134.81,118.07 134.68,117.94 v1(134.68,117.59)
CLK_FSLB_NODE1: length 6.4
  TOP w0.102: U1.9 145.59,113.3 145.87,113.01 145.87,112.28 146.34,111.81 v1(146.64,111.81) 147.02,111.44 R16.2 147.02,111.18 147.58,110.63 147.58,109.35 R14.1
CLKREQA_NODE1_N: length 7.4
  TOP w0.102: R19.1 148.81,109.39 148.81,110.9 148.53,111.18 R23.2 148.29,111.59 v1(148.01,111.87) 147.58,111.87 147.07,112.38 146.46,112.38 146.15,112.69 146.15,113.16 145.99,113.33 U1.10
CLKREQB_NODE1_N: length 6.6
  TOP w0.102: U1.19 149.38,116.51 149.68,116.21 v1(150.73,116.21) 150.95,116.21 151.3,115.86 R15.2 152.53,116.45 153.78,116.45 R13.1
CLKREQC_NODE1_N: length 5.9
  TOP w0.102: R135.1 R21.1 R25.2 151.21,114.78 v1(151.09,114.9) 150.7,115.3 149.68,115.3 149.27,115.71 U1.17
CLP_ITP_EN_NODE1: length 7.2
  TOP w0.102: R11.1 R188.1 146.89,108.85 v1(146.41,109.34) 146.41,109.65 146.3,109.76 146.3,110.9 146.01,111.18 R17.2 145.6,111.34 145.6,112.91 145.19,113.32 U1.8
CM_CABLE_DET_N: length 2.8
  BOTTOM w0.102: R779.1 92.21,168.44 v1(92.34,168.31) 92.4,168.25 U73.16
CM_PWR_CTL_IN: length 48.2
  TOP w0.102: v1(29.02,193.45) 29.02,194.83 30.32,196.13 30.32,199.03 29.05,200.3 J35.B78 ; R1281.1 42.88,170.4 v1(42.78,170.31)
  IN1 w0.114: v1(34.84,194.54) 30.11,194.54 v1(29.02,193.45)
  BOTTOM w0.102: v1(34.84,194.54) 34.84,194.54 34.84,193.95 43.5,185.29 43.5,170.91 42.89,170.31 v1(42.78,170.31)
CM_PWR_CTL_IN_R: length 5.6
  TOP w0.102: R1251.1 43.55,169.41 43.94,169.8 44.12,169.8 44.45,170.12 R1281.2 45.33,170.4 v1(45.57,170.64) 45.93,171 U109.G 45.82,171.67 C794.1
CM_STATUS_LED_N: length 133.7
  TOP w0.102: v1(186.56,117.89) 187.04,118.37 U102.C7 ; v1(111.62,175.97) 112.12,176.47 112.12,178.73 v1(111.53,179.31) 111.56,179.34 U131.3
  IN1 w0.114: v1(111.62,175.97) 113.11,175.97 113.67,176.53 118.04,176.53 118.74,175.84 119.96,175.84 120.31,176.19 121.22,176.19 121.28,176.13 122.31,176.13 124.36,178.18 146.67,178.18 150.05,174.8 150.05,170.8 152.76,168.09 153.59,168.09 154.72,166.96 158.72,166.96 159.01,166.67 159.42,166.67 160.35,165.74 v1(160.35,165.72) ; v1(186.56,117.89) 186.56,118.24 185.11,119.69 185.11,119.81 180.18,124.75 179.62,124.75 179.37,125.01 179.37,125.09 177.32,127.13 177.32,128.73 176.95,129.1 176.95,133.65 176.21,134.39 170.94,134.39 170.4,134.92 168.46,134.92 164.13,139.25 164.13,141.92 163.74,142.31 163.74,144.71 163,145.45 163,150.1 160.31,152.8 160.31,155.16 158.59,156.87 v1(158.59,157.49)
  IN2 w0.114: v1(160.35,165.72) 160.35,165.02 158.56,163.24 158.56,158.01 158.59,157.98 v1(158.59,157.49)
  BOTTOM w0.102: R145.1 108.32,180.99 108.32,179.95 108.78,179.49 U65.11 111.35,179.49 v1(111.53,179.31)
CM_STATUS_LED_R: length 281.8
  TOP w0.102: v1(112.65,180.07) 113.25,180.67 U131.4
  IN1 w0.114: v1(206.41,90.88) 206.34,90.94 206.34,90.93 205.96,91.31 205.96,116.59 206.34,116.97 206.34,140.21 205.96,140.59 205.96,154.58 195.1,165.45 184.23,165.45 182.54,167.13 181.78,167.13 180.59,168.33 180.59,169.09 179.39,170.28 179.39,173.74 178.28,174.85 178.28,176.76 179.39,177.88 179.39,181.16 178.82,181.74 177.75,181.74 173.8,185.69 173.44,185.69 173.41,185.67 165.38,185.67 164.36,186.68 164.36,186.78 163.1,188.04 133.51,188.04 132.53,187.06 132.53,186.55 130.43,184.45 130.33,184.45 130.07,184.2 130.07,183.78 128.61,182.33 125.21,182.33 124.69,181.81 121.21,181.81 120.71,181.3 113.88,181.3 v1(112.65,180.07)
  IN2 w0.114: v1(206.41,90.88) 206.41,83.74 203.99,81.33 200.94,81.33 188.63,69.02 188.63,52.07 188.47,51.92 188.47,48.25 187.75,47.52 187.75,47.16 188.1,46.81 188.1,33.57 192.34,29.33 192.34,13.49 192.09,13.25 192.09,12.06 190.97,10.94 190.97,5.47 D19.1
CMC_CPLD_RSV1: length 54.4
  TOP w0.102: U61.16 131.63,166.91 131.53,167 130.86,167 130.42,166.57 130.42,165.37 130.77,165.02 130.77,163.86 131.22,163.41 v1(131.22,162.09) ; v1(91.12,161.4) 91.12,162.73 91.31,162.92 91.31,163.02 91.53,163.24 U128.62
  IN2 w0.114: v1(91.12,161.4) 92.96,163.24 92.96,163.32 93.98,164.34 106.39,164.34 107.04,163.69 109.22,163.69 109.99,164.45 113.97,164.45 114.59,163.82 118.51,163.82 121.36,160.97 123.9,160.97 124.1,160.76 128.71,160.76 129.54,161.6 130.73,161.6 131.22,162.08 v1(131.22,162.09)
CMC_CPU_RST_N: length 26.3
  TOP w0.102: v1(148.32,166.5) 148.56,166.26 U129.61 ; v1(131.04,166.57) 130.68,166.21 130.68,165.47 131.03,165.13 131.03,163.96 131.33,163.66 U61.11
  IN2 w0.114: v1(148.32,166.5) 147.87,166.94 143.14,166.94 141.99,165.78 139.52,165.78 138.67,166.64 134.58,166.64 134.45,166.77 134.09,166.77 133.96,166.64 131.11,166.64 v1(131.04,166.57)
COM3_WAKEUP: length 3.9
  TOP w0.102: U61.13 v1(133.83,164.96) 134.38,165.51 R792.2 R680.1
COM4_EN_N: length 8.5
  TOP w0.305: R521.1 137.16,56.83 v1(137.18,56.85) 137.4,57.07 U135.1 ; U136.1 136.96,54.58 U103.D
  TOP w0.381: U103.D 136.02,55.3 R521.1 136.02,56.83 R1217.1
CONSOLE_SELECT_N: length 168.5
  TOP w0.102: v1(78.76,82.68) 78.42,82.33 U2.P50 ; J34.1 30.47,36.39 30.03,36.84 R195.2 ; v1(44.11,99.15) 44.2,99.24 48.88,99.24 54.26,104.62 89.83,104.62 90.8,105.59 92.48,105.59 93.19,104.89 94.32,104.89 v1(94.57,105.13)
  IN1 w0.114: v1(94.57,105.13) 95.61,104.08 95.61,93.37 94.75,92.5 92.43,92.5 90.11,90.19 90.11,90 84.7,84.58 84.39,84.58 83.85,84.04 82.61,84.04 81.91,83.34 79.25,83.34 79.01,83.1 79.01,82.93 v1(78.76,82.68)
  IN2 w0.114: v1(31.56,32.14) 32.56,32.14 42.63,42.21 42.63,69.36 41.89,70.11 41.89,82.26 42.56,82.93 42.56,98.44 43.27,99.15 v1(44.11,99.15)
  BOTTOM w0.102: J34.1 v1(31.56,32.14)
CPLD1_RSV1: length 10.5
  TOP w0.102: v1(185.99,126.34) 186.04,126.28 U102.K8 ; R627.2 v1(179.66,130.54)
  BOTTOM w0.102: v1(185.99,126.34) 185.95,126.38 182.81,126.38 179.66,129.53 v1(179.66,130.54)
CPLD1_RSV2: length 10.3
  TOP w0.102: R660.2 180.7,131.32 180.7,130.41 v1(180.69,130.41) ; U102.K7 v1(187.04,126.31)
  BOTTOM w0.102: v1(187.04,126.31) 185.98,127.37 183.11,127.37 180.69,129.79 v1(180.69,130.41)
CPLD1_RSV3: length 10.5
  TOP w0.102: U102.K6 187.9,125.51 187.9,127.4 v5(188.04,127.54) ; R661.2 v1(181.85,130.6)
  BOTTOM w0.102: v1(181.85,130.6) 183.87,128.58 186.72,128.58 187.76,127.54 v5(188.04,127.54)
CPLD2_RSV1: length 2.1
  TOP w0.102: U128.49 82.95,166.62 v1(82.82,166.75) R662.2
CPLD2_RSV2: length 2.8
  TOP w0.102: R676.2 82.39,165.66 82.88,165.17 v1(83.38,165.17) 83.6,165.17 84.28,165.85 U128.50
CPLD2_RSV3: length 7.3
  TOP w0.102: R678.2 83.33,164.62 85.28,162.67 86.43,162.67 86.67,162.91 v1(86.67,163.2) 86.67,163.21 86.28,163.21 86.03,163.46 U128.51
CPLD3_RSV1: length 3.1
  TOP w0.102: U129.49 140.82,165.61 140.21,165 v1(140.12,165) 139.87,165.26 R679.2
CPLD3_RSV2: length 3.6
  TOP w0.102: R684.2 139.62,164.23 139.65,164.2 140.81,164.2 v1(141.08,163.93) 141.81,164.65 U129.50
CPLD3_RSV3: length 3.1
  TOP w0.102: U129.51 143.19,163.36 v1(142.67,162.84) 143.33,162.17 R775.2
CPLD123_RSV1: length 255.5
  TOP w0.102: v1(173.2,132.48) 173.26,132.42 175.86,132.42 176.11,132.17 R627.1 ; v1(80.52,166.44) 80.52,166.44 80.83,166.75 R662.1 ; v1(138.19,160.93) 138.88,161.62 138.88,162.89 137.87,163.9 137.87,164.7 138.28,165.11 R679.1
  IN1 w0.114: v1(138.19,160.93) 138.61,160.93 140.45,159.09 141.29,159.09 142.63,157.76 147.92,157.76 148.89,156.79 155.65,156.79 158.55,153.89 158.55,152.07 161.41,149.21 161.41,142.99 161.08,142.66 161.08,140.81 162.09,139.81 162.09,138.37 167.98,132.48 v1(173.2,132.48) 174.36,131.33 174.36,130.96 174.61,130.7 174.61,114.73 171.1,111.22 168.23,111.22 165.31,108.3 165.31,104.43 164.51,103.63 164.51,94.11 143.66,73.26 143.66,71.52 135.65,63.5 135.65,63.24 134.43,62.03 134.43,47.61 v1(134.01,47.18)
  IN3 w0.114: v1(80.52,166.44) 80.65,166.31 83.61,166.31 84.75,165.18 84.75,164.68 85.69,163.73 90.96,163.73 91.59,163.1 91.59,162.9 92.12,162.37 92.67,162.37 93.94,161.09 100.29,161.09 101.31,162.11 107.05,162.11 109.39,164.45 116.59,164.45 116.91,164.77 118.17,164.77 120.15,162.79 122.94,162.79 124.44,164.29 126.94,164.29 127.87,163.36 128.78,163.36 129.32,163.91 133.98,163.91 134.26,163.62 134.7,163.62 135.1,163.23 136.61,163.23 138.19,161.65 v1(138.19,160.93)
  BOTTOM w0.102: v1(134.01,47.18) 134.01,47.19 134.09,47.27 136.3,47.27 141.22,42.35 141.22,39.94 142.65,38.51 143.82,38.51 143.82,38.51 144.37,38.51 146.51,36.36 R1181.1
CPLD123_RSV2: length 257.1
  TOP w0.102: R660.1 180.69,132.55 180.54,132.7 174.92,132.7 174.71,132.91 v1(174.71,132.91) ; v1(139.32,160.85) 139.17,160.99 139.17,163.09 138.28,163.99 R684.1 ; R676.1 81.05,165.66 80.85,165.86 80.05,165.86 v1(79.75,166.16)
  IN1 w0.114: v1(139.32,160.85) 140.16,160.85 142.92,158.09 144.78,158.09 145.53,158.84 147.22,158.84 149,157.06 155.76,157.06 158.82,154 158.82,152.23 161.68,149.37 161.68,142.05 162.35,141.37 162.35,138.48 167.92,132.92 173.39,132.92 173.39,132.91 v1(174.71,132.91) 174.71,131.52 174.62,131.43 174.62,131.07 174.88,130.81 174.88,114.62 171.06,110.8 168.19,110.8 165.58,108.19 165.58,104.32 164.77,103.52 164.77,94 143.93,73.15 143.93,71.4 135.96,63.44 135.96,63.07 134.71,61.81 134.71,46.9 v1(134.59,46.78)
  IN3 w0.114: v1(139.32,160.85) 139.32,160.74 138.52,159.94 137.56,159.94 135.36,162.14 133.1,162.14 132.41,162.83 130.85,162.83 130.36,162.33 126.87,162.33 126.23,162.97 124.63,162.97 123.67,162 119.63,162 118.41,163.22 115.52,163.22 115.02,162.72 114.37,162.72 113.72,163.37 113.25,163.37 112.77,163.86 112.02,163.86 111.73,163.57 109.2,163.57 107.43,161.8 101.38,161.8 100.41,160.83 93.78,160.83 92.5,162.1 89.94,162.1 89.21,162.84 87.89,162.84 87.69,162.65 86.4,162.65 84.48,164.57 84.48,165.07 83.54,166.01 79.91,166.01 v1(79.75,166.16)
  BOTTOM w0.102: R1183.1 146.83,35.59 144.16,38.25 142.51,38.25 140.89,39.88 140.89,42.18 136.29,46.78 v1(134.59,46.78)
CPLD123_RSV3: length 254.7
  TOP w0.102: v1(175.87,133.21) 180.76,133.21 R661.1 ; v1(80.62,165.42) 80.62,165.01 81.01,164.62 R678.1 ; R775.1 141.79,161.15 v1(141.75,161.11)
  IN1 w0.114: v1(141.75,161.11) 141.75,160.63 144.02,158.35 144.67,158.35 145.42,159.1 148.75,159.1 150.53,157.33 155.87,157.33 159.09,154.11 159.09,152.45 162,149.54 162,143.8 162.62,143.17 162.62,138.59 167.82,133.39 175.69,133.39 v1(175.87,133.21) 175.7,133.04 175.7,130.9 175.33,130.53 175.33,114.69 171.17,110.53 168.3,110.53 165.84,108.08 165.84,104.06 165.04,103.25 165.04,93.89 144.19,73.04 144.19,71.29 136.32,63.41 136.32,62.71 135.13,61.53 135.13,46.57 v1(135.75,45.95)
  IN3 w0.114: v1(141.75,161.11) 141.06,161.11 138.91,158.95 138.02,158.95 135.13,161.84 132.31,161.84 131.97,161.49 130.75,161.49 130.24,162 126.45,162 125.76,162.69 124.78,162.69 123.74,161.65 119.54,161.65 118.24,162.95 115.77,162.95 115.28,162.46 112.35,162.46 111.74,163.07 109.1,163.07 107.57,161.53 101.49,161.53 100.52,160.56 93.64,160.56 92.37,161.84 86.83,161.84 84.21,164.47 84.21,164.96 83.56,165.61 80.82,165.61 v1(80.62,165.42)
  BOTTOM w0.102: v1(135.75,45.95) 135.75,45.95 136.69,45.95 140.41,42.24 140.41,40 142.41,38 143.88,38 146.41,35.47 146.41,34.75 R1185.1
CPLD_CPU_THRMTRIP_N: length 11.8
  TOP w0.102: Q41.C 186.99,133.34 188,132.34 188.19,132.34 R1131.1 188.3,129.27 188.53,129.05 188.53,127.34 188.52,127.33 v1(188.52,126.73) 188.53,126.72 188.53,124.12 189.04,123.6 U102.H5
CPLD_EXT_RST_N: length 83.3
  TOP w0.102: U129.30 143.19,175.11 v1(143.58,174.73) ; U102.F8 v1(185.54,121.87)
  IN1 w0.114: v1(185.54,121.87) 185.97,122.29 185.97,124.44 180.09,130.32 180.09,131.64 176.29,135.44 172.45,135.44 167.99,139.9 167.99,146.98 167.11,147.86 167.11,150.67 167.8,151.35 167.8,151.72 167.09,152.42 167.09,155.15 159.27,162.98 156.77,162.98 156.17,163.57 153.59,163.57 152.22,164.94 148.96,164.94 145.31,168.6 145.31,173.03 146.36,174.07 146.36,174.44 146.07,174.73 v1(143.58,174.73)
CPLD_FAN_MAX_CTRL: length 35.3
  TOP w0.102: U69.13 116.35,172.2 v1(116.46,172.31) ; U128.78 100.42,167.12 100.7,166.84 100.7,165.57 101.37,164.9 v1(101.37,164.9) ; U68.2 120.86,166.45 v1(121.21,166.8)
  IN1 w0.114: v1(101.37,164.9) 101.37,164.9 101.85,164.42 105.68,164.42 106.08,164.83 108.13,164.83 108.24,164.72 108.61,164.72 109.63,165.75 111.15,165.75 112.12,166.71 113.04,166.71 113.23,166.91 118.66,166.91 119.05,167.29 120.26,167.29 120.74,166.8 v1(121.21,166.8)
  BOTTOM w0.102: v1(121.21,166.8) 120.86,167.15 120.86,168 118.72,170.14 118.72,170.68 117.19,172.21 116.56,172.21 v1(116.46,172.31)
CPLD_ROW_EN: length 146.4
  TOP w0.102: v1(79.86,83.86) 78.67,83.86 78.21,84.32 U2.K50 ; U102.J3 191.56,124.88 191.56,128.13 v1(191.84,128.42)
  IN3 w0.114: v1(79.86,83.86) 79.68,84.04 79.68,86.43 80.25,87.01 80.62,87.01 82.14,88.53 84.93,88.53 85.43,88.03 87.31,88.03 88.21,88.93 91.93,88.93 92.38,88.47 93.64,88.47 93.85,88.26 98.1,88.26 100.66,85.7 109.49,85.7 111.48,87.69 120.98,87.69 137.42,104.13 149.55,104.13 153.06,107.64 154.55,107.64 160.28,113.37 160.28,117.41 172.28,129.41 172.78,129.41 174.18,130.81 175.24,130.81 175.46,131.03 182.03,131.03 182.25,130.81 188.66,130.81 188.76,130.91 189.35,130.91 v1(191.84,128.42)
CPLD_ROW_LATCH: length 149.8
  TOP w0.102: U102.J4 190.03,124.37 v5(189.5,123.83) ; v1(78.64,84.96) 77.85,84.96 U2.K48
  IN3 w0.114: v5(189.5,123.83) 192.34,126.67 192.34,129.65 190.25,131.74 188.62,131.74 188.18,131.31 183.11,131.31 182.73,131.69 174.24,131.69 172.98,130.43 172.56,130.43 v1(165.4,123.27) 159.78,117.65 159.78,113.57 154.34,108.13 152.85,108.13 149.35,104.63 137.22,104.63 120.77,88.19 111.15,88.19 109.18,86.21 100.91,86.21 98.26,88.86 97.54,88.86 97.03,89.37 95.26,89.37 95.19,89.43 87.46,89.43 87.11,89.08 81.52,89.08 80.96,88.51 80.32,88.51 78.26,86.46 78.26,85.35 78.64,84.97 v1(78.64,84.96)
CPLD_THRMTRIP_LOG_N: length 190.6
  TOP w0.102: U102.H8 v5(185.54,123.87)
  IN1 w0.114: v1(56.6,182.94) 57.05,182.49 57.05,181.97 59.24,179.79 59.24,178.53 59.95,177.82 59.95,175.86 60.47,175.34 60.47,169.55 62.88,167.13 71.61,167.13 72.03,167.56 79.12,167.56 79.31,167.75 84.19,167.75 86.03,165.91 86.66,165.91 88.56,164.01 93.16,164.01 94.36,162.8 95.53,162.8 95.61,162.87 96.15,162.87 96.21,162.81 96.96,162.81 97.5,163.35 98.88,163.35 99.37,163.85 103.28,163.85 103.69,163.44 105.39,163.44 106.52,164.56 108.02,164.56 108.13,164.46 108.72,164.46 109.7,165.43 111.23,165.43 112.24,166.45 113.15,166.45 113.15,166.45 116.45,166.45 116.89,166 118.81,166 119.04,166.23 121.91,166.23 122.27,165.88 123.79,165.88 124.57,165.1 126.67,165.1 127.37,165.81 130.64,165.81 130.93,166.09 131.29,166.09 132.11,165.28 132.11,162.52 132.41,162.22 132.41,161.26 132.71,160.96 136.84,160.96 138.08,162.2 140.87,162.2 142.21,163.54 146.67,163.54 147.44,162.77 152.1,162.77 153.3,161.57 154.51,161.57 154.91,161.17 158.67,161.17 164.01,155.82 164.01,152.35 164.88,151.48 164.88,145.03 165.4,144.51 165.4,142.18 165.12,141.9 165.12,140.46 168.04,137.54 169.95,137.54 172.56,134.92 176.43,134.92 178.36,133 178.36,130.43 178.39,130.4 184.48,124.31 185.1,124.31 v5(185.54,123.87)
  BOTTOM w0.102: U63.19 61.07,176.64 60.43,177.28 60.27,177.28 59.25,178.3 59.25,179.89 58.61,180.53 58.61,180.94 v1(56.6,182.94)
CPLD_UART_DTR_P3_N: length 28
  TOP w0.102: v1(175.85,182.65) 176.09,182.89 176.09,183.34 176.31,183.57 177.23,183.57 177.44,183.78 R1170.2 177.44,184.34 177.18,184.6 176.9,184.6 176.64,184.86 R1171.1 ; U129.1 v1(155.56,180) 155.56,180.01 R807.1
  IN2 w0.114: v1(175.85,182.65) 175.82,182.69 169.54,182.69 168.7,181.85 167.74,181.85 167.62,181.97 165.88,181.97 165.1,181.19 161.75,181.19 161.61,181.33 159.53,181.33 158.2,180 v1(155.56,180)
CPLD_UART_DTR_P3_R_N: length 7.8
  TOP w0.102: R1170.1 175.66,184.07 v3(175.51,183.92) 175.26,183.66 175.26,179.95 176.45,178.75 U57.12
CPLD_UART_DTR_P4_N: length 89.5
  TOP w0.102: 101.44,181.35 v1(101.44,181.35) ; 101.44,181.35 101.73,181.35 102.45,180.63 R811.1 ; 101.44,181.35 101.38,181.35 100.42,180.39 R1177.1 ; U128.1 98.03,179.96 98.25,180.18 v1(98.96,180.18)
  IN1 w0.114: v1(101.44,181.35) 101.93,181.84 106.02,181.84 106.14,181.71 106.55,181.71 106.89,181.37 110.84,181.37 112,180.21 112,180.1 112.47,179.63 116.64,179.63 117.15,180.13 117.51,180.13 117.51,180.13 118.17,180.13 118.77,180.73 120.66,180.73 121.37,181.44 124.84,181.44 125.36,181.96 129.07,181.96 130.95,183.83 130.95,183.92 132.51,185.48 135.6,185.48 136.46,186.34 136.46,187.14 136.99,187.67 161.9,187.67 162.28,187.3 162.84,187.3 163.09,187.04 163.09,186.68 164.83,184.94 173.31,184.94 v1(173.62,185.25)
  BOTTOM w0.102: R1176.2 172.14,183 172.14,184.07 172.58,184.51 172.88,184.51 v1(173.62,185.25) ; v1(98.96,180.18) 100.28,180.18 v1(101.44,181.35)
CPLD_UART_DTR_P4_R_N: length 5.9
  BOTTOM w0.102: U59.12 172.36,178.75 172.86,179.25 172.86,181.9 v2(172.7,182.06) 172.23,182.06 171.76,181.6 R1176.1
CPLD_UART_RI_P3_LS_N: length 13.8
  TOP w0.102: v1(174.68,173.85) 172.58,175.94 172.58,177.9 172.38,178.1 U57.18
  BOTTOM w0.102: R1061.1 176.05,168.82 v2(175.01,169.87) ; U141.S 174.83,169.7 v2(175.01,169.87) ; v2(175.01,169.87) 175,169.87 174.65,170.23 174.65,173.82 v1(174.68,173.85)
CPLD_UART_RI_P3_N: length 222.1
  TOP w0.102: R1261.1 161.84,175.32 v1(161.77,175.4) 161.39,175.78 160.22,175.78 160.2,175.8 159.7,176.29 R806.1 158.45,176.3 158.27,176.11 U129.98 ; R521.2 134.62,56.23 U103.G 134.62,54.97 134.97,54.62 135.66,54.62 v1(135.77,54.5)
  IN1 w0.114: v1(161.77,175.4) 162.55,176.18 164.79,176.18 164.9,176.07 169.18,176.07 169.45,175.79 173.49,175.79 v1(174.58,174.71) 175.45,174.71 177.75,172.41 177.75,170.08 181.5,166.33 182.35,166.33 184.06,164.62 194.23,164.62 205.2,153.64 205.2,139.06 205.45,138.81 205.45,119.13 205.2,118.87 205.2,98.71 190.8,84.31 v1(190.28,84.31)
  IN2 w0.114: v1(190.28,84.31) 190.28,82.64 174.43,66.79 v1(174.43,63.53)
  IN3 w0.114: v1(135.77,54.5) 137.77,56.5 147.37,56.5 149.02,58.14 150.72,58.14 151.28,57.59 152.44,57.59 154.22,59.37 169.6,59.37 173.76,63.53 v1(174.43,63.53)
  BOTTOM w0.102: R1061.2 176.05,167.48 174.6,166.02 U141.D 173.81,173.95 v1(174.58,174.71)
CPLD_UART_RI_P4_LS_N: length 25.3
  IN3 w0.114: v1(175.35,174.19) 175.35,174.67 v1(178.78,178.1)
  BOTTOM w0.102: U59.18 v1(178.78,178.1) ; v1(175.35,174.19) 175.75,173.79 175.75,170.55 v2(176.46,169.84) 176.81,169.49 176.81,168.96 177.22,168.55 R1064.1 177.71,168.05 177.71,167.04 175.23,164.56 169.57,164.56 169.31,164.82 U142.S
CPLD_UART_RI_P4_N: length 104
  TOP w0.102: R1252.1 103.25,179.37 103.04,179.16 102.76,179.16 102.45,178.85 R810.1 101.93,178.59 100.46,177.12 U128.98 99.05,177.12 98.52,176.6 v1(98.33,176.6)
  IN1 w0.114: v1(98.33,176.6) 98.34,176.6 99.76,178.02 104.11,178.02 104.31,177.81 104.88,177.81 104.99,177.71 105.48,177.71 107.29,175.9 109.44,175.9 110.95,177.41 111.76,177.41 111.77,177.4 117.15,177.4 117.21,177.47 120.4,177.47 120.72,177.15 122.09,177.15 123.79,178.84 124.15,178.84 124.45,178.55 146.82,178.55 150.55,174.82 150.55,170.83 152.88,168.5 154.65,168.5 155.09,168.06 157.2,168.06 157.27,168.12 158.86,168.12 160.55,166.43 161.97,166.43 v1(162.22,166.68)
  BOTTOM w0.102: v1(162.22,166.68) 163.46,167.92 164.77,167.92 165.39,168.55 168.71,168.55 169.42,167.84 U142.D 170.33,168.68 170.87,169.22 173.23,169.22 173.48,168.97 173.48,167.44 173.13,167.08 173.13,165.32 173.46,164.99 174.72,164.99 175.2,165.47 175.2,166.08 176.87,167.75 R1064.2
CPLD_UART_RTS_P3_N: length 36.8
  TOP w0.102: v1(178.82,181.12) 178.82,181.12 178.36,181.12 R1169.2 177.44,182.25 177.22,182.47 176.91,182.47 176.64,182.74 R1172.1 ; R794.1 159.7,175.57 159.41,175.86 158.64,175.86 158.39,175.61 U129.97 156.57,175.61 156.31,175.86 156.31,177.55 156.84,178.08 156.84,181.03 v1(156.97,181.16)
  IN2 w0.114: v1(178.82,181.12) 178.82,181.12 178.52,181.12 176.06,183.57 175.13,183.57 174.56,183 169.41,183 169.06,182.65 168.17,182.65 168.1,182.72 167.74,182.72 167.3,182.29 165.74,182.29 165.66,182.2 162.71,182.2 162.31,181.8 159.34,181.8 158.7,181.16 v1(156.97,181.16)
CPLD_UART_RTS_P3_R_N: length 6.1
  TOP w0.102: U57.14 179.28,180.05 179.43,180.2 v3(179.43,180.35) 179.43,180.46 179.24,180.64 177.69,180.64 177.29,181.04 177.29,181.39 R1169.1
CPLD_UART_RTS_P4_N: length 105.4
  TOP w0.102: v1(98.14,177.9) 97.69,177.45 97.69,176.63 98.15,176.17 98.6,176.17 99.06,176.62 U128.97 100.43,176.62 101.39,177.58 R809.1 102.45,177.58 R1178.1
  IN1 w0.114: v1(163.75,168.43) 162.81,169.37 159.09,169.37 158.89,169.17 157.11,169.17 156.67,169.61 155.39,169.61 153.46,171.54 152.92,171.54 152.6,171.86 152.6,177.69 151.86,178.43 151.43,178.43 148.7,181.16 147.51,181.16 146.01,182.66 141.9,182.66 141.89,182.67 137.14,182.67 136.31,181.84 134.56,181.84 132.57,179.85 125.45,179.85 125.1,180.2 121.26,180.2 121.2,180.26 118.75,180.26 118.3,179.81 118.1,179.81 117.55,179.26 112.21,179.26 111.72,179.75 109.99,179.75 109.13,178.9 106.92,178.9 105.92,179.9 104.97,179.9 104.6,179.54 103.4,179.54 102.82,178.96 98.81,178.96 98.14,178.3 v1(98.14,177.9)
  IN3 w0.114: v1(169.72,182.25) 168.15,180.68 168.15,179.56 166.75,178.15 166.13,178.15 165.87,177.9 165.87,177.53 166.12,177.28 166.12,169.65 166.08,169.61 166.08,169.48 164.93,168.34 163.84,168.34 v1(163.75,168.43)
  BOTTOM w0.102: v1(169.72,182.25) 169.99,182.25 170.13,182.4 R1175.2
CPLD_UART_RTS_P4_R_N: length 4.7
  BOTTOM w0.102: U59.14 170.66,180.05 170.01,180.7 169.56,180.7 v2(169.07,181.19) 169.07,181.47 169.39,181.79 170.11,181.79 170.3,181.6 R1175.1
CPLD_UART_RX_P3: length 12.2
  TOP w0.102: v1(160.72,177.11) 160.47,176.86 158.57,176.86 158.32,176.61 U129.99 ; R1167.2 167.88,179.09 167.54,178.75 167.54,178.37 167.46,178.29 R1168.1 166.42,178.29 166.31,178.18 v1(166.31,177.72)
  IN1 w0.114: v1(160.72,177.11) 165.25,177.11 165.8,177.66 166.25,177.66 v1(166.31,177.72)
CPLD_UART_RX_P3_R: length 4.1
  TOP w0.102: R1167.1 168.58,178.29 v1(168.99,178.69) 170.23,177.45 U57.19
CPLD_UART_RX_P4: length 105.1
  TOP w0.102: v1(98.12,177.23) 98.72,177.23 99.11,177.62 U128.99
  IN1 w0.114: v1(163.67,167.13) 163.49,167.13 161.57,169.05 159.31,169.05 159.11,168.85 156.79,168.85 156.37,169.27 155.09,169.27 153.94,170.42 153.02,170.42 151.48,171.96 151.48,175.78 146.84,180.43 145.64,180.43 145.26,180.05 136.42,180.05 135.87,179.5 123,179.5 122.54,179.04 120.06,179.04 119.74,178.72 117.67,178.72 117.58,178.8 109.53,178.8 109.31,178.58 106.79,178.58 105.79,179.59 105.11,179.59 104.74,179.22 103.53,179.22 102.95,178.64 102.56,178.64 102.25,178.33 99.22,178.33 v1(98.12,177.23)
  IN3 w0.114: v1(163.67,167.13) 163.76,167.22 164.27,167.22 166.39,169.35 166.39,169.48 166.67,169.75 166.67,177.46 166.93,177.72 166.99,177.72 170.07,180.81 176.83,180.81 178.16,182.14 v1(178.16,182.39)
  BOTTOM w0.102: 177.44,183.03 R1174.1 ; 177.44,183.03 R1173.2 ; 177.44,183.03 178.08,182.39 v1(178.16,182.39)
CPLD_UART_RX_P4_R: length 7.4
  BOTTOM w0.102: U59.19 176.39,177.45 175.53,178.31 175.53,181.85 v2(175.54,181.87) 175.67,181.87 176.64,182.84 R1173.1
CPLD_UART_TX_P3: length 23.8
  TOP w0.102: v1(162.64,178.64) 161.69,177.68 158.65,177.68 158.08,177.11 U129.100 ; U57.13 v1(178.56,179.4)
  IN1 w0.114: v1(178.56,179.4) 177.57,179.4 176.42,178.26 163.39,178.26 163.01,178.64 v1(162.64,178.64)
CPLD_UART_TX_P4: length 94.2
  TOP w0.102: U128.100 99.78,178.61 101.27,180.11 102.65,180.11 102.69,180.07 103.55,180.07 v1(105.38,178.23)
  IN1 w0.114: v1(162.36,167.53) 162.12,167.77 159.66,167.77 158.99,168.44 156.94,168.44 156.87,168.37 155.26,168.37 154.14,169.49 152.33,169.49 150.86,170.96 150.86,175.2 147.2,178.86 134.28,178.86 133.98,179.16 123.3,179.16 122.31,178.16 120.89,178.16 120.52,178.54 120.15,178.54 120.02,178.4 117.54,178.4 117.45,178.49 117.09,178.49 116.32,177.72 112.29,177.72 112.28,177.73 109.37,177.73 109.3,177.66 107.53,177.66 106.96,178.23 v1(105.38,178.23)
  IN3 w0.114: v1(166.93,181.26) 166.73,181.05 166.66,181.05 164.5,178.9 164.5,176.84 164.09,176.43 164.09,170.8 163.2,169.9 163.2,168.37 v1(162.36,167.53)
  BOTTOM w0.102: v1(166.93,181.26) 167.17,181.02 167.62,181.02 167.95,180.69 167.95,180.23 168.77,179.4 U59.13
CPLD_WDT1: length 66.4
  TOP w0.102: R623.1 136.14,167.31 136.52,167.7 v1(136.52,168.33) 136.58,168.27 140.54,168.27 140.88,168.61 U129.43 ; v1(86.74,169.77) 86.73,169.77 86.58,169.62 U128.43
  IN1 w0.114: v1(86.74,169.77) 88.56,169.77 89.45,168.88 91.03,168.88 92.07,167.84 92.73,167.84 95.04,165.53 95.41,165.53 95.57,165.69 97.17,165.69 101.23,169.75 101.55,169.75 101.69,169.89 102.75,169.89 103.26,169.38 105.23,169.38 105.35,169.27 107.28,169.27 109.3,171.29 116.88,171.29 117.1,171.07 119.46,171.07 119.62,171.23 121.5,171.23 122.33,172.07 129.03,172.07 132.77,168.33 v1(136.52,168.33)
CPLD_WDT1_R: length 3.1
  TOP w0.102: U61.14 133.55,165.61 v1(134.27,166.33) 134.47,166.52 R623.2
CPLD_WDT2: length 118.8
  TOP w0.102: U128.44 v1(85.53,169.12) 86.7,169.12 87.17,169.59 87.17,172.62 v1(86.45,173.34) ; U129.44 v1(142.98,168.11)
  IN2 w0.114: v1(107.82,177.09) 107.66,176.94 104.18,176.94 104.12,177 102.14,177 100.39,175.25 97.24,175.25 96.96,174.97 94.55,174.97 90.63,171.05 88.74,171.05 v1(86.45,173.34)
  IN3 w0.114: v1(142.98,168.11) 138.12,168.11 138.1,168.12 137.51,168.12 135.28,165.89 131.49,165.89 131.29,166.09 130.93,166.09 130.57,165.73 126.43,165.73 126.18,165.98 126.18,165.99 126.08,166.09 123.16,166.09 122.8,165.73 119.78,165.73 119.4,165.36 117.54,165.36 116.61,166.29 116.24,166.29 115.96,166.01 v1(113.47,166.01) 112.86,165.4 109.52,165.4 107.56,163.44 101.22,163.44 101.07,163.58 100.16,163.58 98.92,162.34 98.92,161.89 98.66,161.63 94.29,161.63 92.73,163.19 92.73,163.38 91.76,164.35 87.02,164.35 85.04,166.33 85.04,168.64 v1(85.53,169.12)
  BOTTOM w0.102: v1(85.53,169.12) 84.68,168.27 84.68,164.48 85.13,164.03 87.44,164.03 87.54,164.13 R622.1 ; R755.1 109.09,181.67 108.64,182.12 106.67,182.12 106.25,181.7 106.25,181.46 105.8,181.01 105.8,179.87 106.1,179.56 106.1,178.8 107.81,177.09 v1(107.82,177.09)
CPLD_WDT2_R: length 6.9
  BOTTOM w0.102: R622.2 R793.1 89.91,163.12 90.44,163.65 92.27,163.65 v2(92.34,163.73) 92.85,164.23 92.85,164.88 92.98,165 U73.11
CPLD_WDT3: length 294.1
  TOP w0.102: v1(150.48,180) 150.06,179.58 U129.12 ; U128.12 92.53,180.64 92.83,180.94 v1(92.83,181.06)
  IN1 w0.114: v1(148.85,38.46) 148.27,39.04 148.27,47.3 147.68,47.89 147.68,49.03 148.18,49.53 148.18,50.04 147.85,50.37 147.85,56.93 147.28,57.5 147.28,63.59 147.92,64.23 147.92,69.05 152.19,73.32 152.19,75.96 160.75,84.51 164.4,84.51 164.44,84.47 188.33,84.47 188.61,84.75 190.72,84.75 203.97,98 203.97,121.07 204.31,121.41 204.31,129.03 204.1,129.25 204.1,153.34 194.07,163.37 193.76,163.37 183.88,163.37 181.92,165.34 177.44,165.34 176.93,165.85 176.1,165.85 176.02,165.94 164.03,165.94 v1(163.54,166.43)
  IN2 w0.114: v1(150.48,180) 149.8,180 148.4,178.6 125.57,178.6 124.02,180.14 123.08,180.14 121.89,181.34 121.13,181.34 120.88,181.09 118.77,181.09 117.81,180.13 117.52,180.13 117.51,180.13 117.15,180.13 115.89,178.87 110.08,178.87 109.14,179.82 107.78,179.82 107.76,179.8 102.02,179.8 101.85,179.97 99.36,179.97 99.14,179.75 98.78,179.75 98.02,180.51 93.38,180.51 v1(92.83,181.06)
  BOTTOM w0.102: v1(150.48,180) 150.48,179.44 150.03,178.99 150.03,177.11 150.97,176.17 150.97,170.35 152.92,168.4 154.82,168.4 155.02,168.2 156.04,168.2 156.21,168.04 158.15,168.04 158.31,168.19 158.89,168.19 161,166.08 162.5,166.08 162.87,166.46 163.51,166.46 v1(163.54,166.43) ; R1179.2 v1(148.85,38.46) 148.73,38.46 148.66,38.39 R1180.1
