# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Nets (continued)
N54065132: C540.1 R1273.1 R1274.1 R1275.1 R1276.1
N54134271: C541.1 R1277.1 R1278.1 R1279.1 R1280.1
N54251449: R654.2 U52.7(RIN4) U52.8(RIN5)
N54251487: R651.2 U52.23(FORCEON)
N54251489: R652.2 U52.22(FORCEOFF#)
N54251517: C546.1 U52.28(C1+)
N54251519: C546.2 U52.24(C1-)
N54251527: C547.1 U52.1(C2+)
N54251529: C547.2 U52.2(C2-)
N54251539: C544.2 U52.27(V+)
N54251541: C545.2 U52.3(V-)
N54258454: R1297.2 U55.8(RIN5)
N54258474: R1299.2 U55.23(FORCEON)
N54258476: R1298.2 U55.22(FORCEOFF#)
N54258513: C549.1 U55.28(C1+)
N54258515: C549.2 U55.24(C1-)
N54258523: C542.1 U55.1(C2+)
N54258525: C542.2 U55.2(C2-)
N54258535: C551.2 U55.27(V+)
N54258537: C548.2 U55.3(V-)
N54310531: R1300.2 U56.8(RIN5)
N54310543: R1302.2 U56.23(FORCEON)
N54310545: R1301.2 U56.22(FORCEOFF#)
N54310590: C554.1 U56.28(C1+)
N54310592: C554.2 U56.24(C1-)
N54310596: C552.1 U56.1(C2+)
N54310598: C552.2 U56.2(C2-)
N54310604: C562.2 U56.27(V+)
N54310606: C553.2 U56.3(V-)
N54365542: R1303.2 U57.6(RIN3) U57.7(RIN4) U57.8(RIN5)
N54365554: R1305.2 U57.23(FORCEON)
N54365556: R1304.2 U57.22(FORCEOFF#)
N54365601: C912.1 U57.28(C1+)
N54365603: C912.2 U57.24(C1-)
N54365611: C563.1 U57.1(C2+)
N54365613: C563.2 U57.2(C2-)
N54365623: C914.2 U57.27(V+)
N54365625: C564.2 U57.3(V-)
N54365764: R1306.2 U59.6(RIN3) U59.7(RIN4) U59.8(RIN5)
N54365772: R1308.2 U59.23(FORCEON)
N54365776: R1307.2 U59.22(FORCEOFF#)
N54365821: C916.1 U59.28(C1+)
N54365823: C916.2 U59.24(C1-)
N54365827: C915.1 U59.1(C2+)
N54365829: C915.2 U59.2(C2-)
N54365835: C919.2 U59.27(V+)
N54365837: C917.2 U59.3(V-)
N3975090755: TP8.1 U14.G3(TDO)
N3975090765: TP5.1 U14.B5(GPIOA1_MAC2LINK)
N3975090766: TP6.1 U14.A4(GPIOA2_MAC3LINK)
N3975090767: TP7.1 U14.E6(GPIOA3_MAC4LINK)

Pads without a net: BT1_BATTERY1 1; D7 2; D8 2; D20 2; H10_NUT 1; H10_SRW 1; J3 21 22 23 24 45 55; J9 4 11; J18 A13 A14 A16 B14 B15 B17; J20 6 7 8; J26 6 7 8; J27 6 7 8; J35 A67 A68 A69 B67 B70; NOREF#4 1; NOREF#15 1; NOREF#62 1; NOREF#69 1; NOREF#72 1; NOREF#83 1; NOREF#85 1; NOREF#86 1; NOREF#87 1; NOREF#88 1; NOREF#90 1; NOREF#91 1; NOREF#92 1; PCB 1; PJ18 1; PJ19 2; PU8 27 28 33 34 35 36; U1 26 27; U2 AC9 AC11 AC14 AC15 AD9 AD11 AD14 AD15 AF63 AG8 AG10 AG13 AG14 AG53 AG57 AG60 AG63 AG64 AG66 AH8 AH10 AH13 AH14 AH54 AH57 AH59 AH62 AJ63 AJ65 AL9 AL11 AL14 AL15 AL56 AL58 AM9 AM11 AM14 AM15 AR8 AR10 AR14 AR16 AT8 AT10 AT13 AT14 AW14 AW15 D48 E48 E49 G17 G18 G25 G26 H13 H17 H18 H25 H26 H38 J13 J21 J22 L17 L18 L21 L22 L25 L26 M59 N8 N10 N13 N14 N17 N18 N25 N26 N50 R9 R11 R14 R15 U9 U11 U14 U15 W8 Y8; U14 A5 A6 A7 A8 A10 A12 A13 A14 A15 A16 A17 A18 A19 A20 AA1 AA2 AA3 AA4 AA5 AA6 AA7 AA21 AA22 AB1 AB2 AB3 AB4 AB5 AB6 AB7 AB20 AB21 B6 B7 B10 B12 B13 B14 B15 B16 B17 B18 B19 B22 C6 C7 C10 C12 C13 C14 C15 C16 C17 C18 C20 C22 D6 D7 D9 D10 D12 D13 D14 D15 D16 D17 D18 D19 E7 E9 E12 E13 E14 E15 E16 E18 E19 E20 F18 G4 G18 G19 H18 H19 H20 J1 J2 J4 J5 J20 J21 K3 K4 N21 R18 R19 T5 T19 U1 U3 U4 U5 U18 U19 U20 V1 V2 V3 V4 V5 V6 V7 V20 V21 V22 W1 W2 W3 W4 W5 W6 W7 W21 W22 Y1 Y2 Y3 Y4 Y5 Y6 Y7 Y21 Y22; U16 1; U30 1 2 3 4 6 7 8 10 11 12 14 15 16 23 24 26 27 55 56 58 59 60 61 62 63 65 66 67 68 69 70 72 76; U32 21 23 25 27; U35 62; U37 62; U43 7 8 9 10 24 25 30 46 53 55 60 62 63 64 65 79 84 88 89 94 96 97 98 100 101 102 103 104 105 106 107 108 118 126; U51 15 16 20 21; U52 15 16 20 21; U55 15 20 21; U56 15 20 21; U57 15 16 17 20 21; U58 1; U59 15 16 17 20 21; U63 18 20; U65 4 5 6 7 8 9 18 19 20; U69 5 8 10; U70 5 8 10 15; U84 1; U85 1; U86 1; U87 1; U88 1; U89 1; U106 1; U115 7 8 9 10 14 15 16 17 21 23 24 27 28 31 32 33 34 38 39 40 41; U125 9 21 22 23 24 25 47 51 54 58 59 64 98 116 117 120 121; U133 1; U145 1; U146 1

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 5723 vias
v2: diameter 0.66, hole 0.33, TOP to BOTTOM, 289 vias
v3: diameter 0.762, hole 0.381, TOP to BOTTOM, 52 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 42 vias
v5: diameter 0.49, hole 0.254, TOP to BOTTOM, 301 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
AGND_HSC_NODE1: length 6.8
  TOP w0.254: R1022.2 44.85,183.37 45.17,183.04 U100.4 45.17,179.5 v1(45.67,179) U100.8
AGND_PVCCP_NODE1: length 7.8
  TOP w0.178: v1(123.47,136.87) 123.27,136.67 123.27,136.49 122.67,135.9 PU8.8
  TOP w0.381: v1(127.35,137.43) 127.05,137.13 PC110.1 ; v1(125.77,133.07) 125.91,133.21 PC101.1 ; v1(119.69,141.36) 119.69,141.36 PC111.1 ; PR62.1 121.85,140.87 v1(122.32,141.34) ; PC108.2 125.71,135.69 v1(125.91,135.89) ; PR65.1 v1(120.75,141.36)
  TOP w0.457: PC95.2 v1(123.73,128.66) ; PR60.1 v1(124.36,140.55)
  vias: v1(115.85,140.09) v1(117.02,141.28) v1(124.06,137.3)
GND: length 2257.1
  TOP w0.152: PU7.17 50.52,13.49
  TOP w0.178: U32.65 177.28,105.87 v1(177.42,106.02) 177.68,105.76 U32.64 ; PU8.10 121.23,136.7 v1(120.93,136.4) ; U1.22 149.81,117.71 v1(149.89,117.63) ; U125.81 137.02,143.38 136.71,143.69 136.71,144.15 v1(136.63,144.23) ; v1(139.04,141.2) 138.87,141.38 U125.86 ; U125.90 138.93,139.78 v1(139.04,139.88) 138.75,140.18 U125.89 ; U125.119 148.17,136.78 v1(147.83,137.12) ; U125.94 138.87,138.18 v1(139.07,137.98) 138.86,137.78 U125.95 ; U125.2 154.1,137.78 154.49,137.39 v1(154.49,137.24) ; PU8.22 118.06,136.3 v1(118.11,136.34) ; U125.53 143.77,152.26 v1(144.02,152.51) ; v1(162.62,63.75) 162.42,63.96 U30.28 ; v1(152.1,142.55) 152.12,142.58 U125.14 ; v1(150.24,134.65) 150.57,134.98 U125.125 ; U125.19 152.29,144.58 v1(152.12,144.41) ; v1(118.08,133.38) 117.7,133 PU8.31 ; U125.105 142.57,136.62 142.46,136.73 v1(142.46,137.54) ; v1(151.26,152.51) 151.37,152.4 U125.34 ; v1(145.01,152.48) 144.97,152.44 U125.50 ; U125.36 150.57,152.33 v1(150.37,152.53) ; U125.30 152.18,148.98 v1(151.97,149.18) ; U32.38 184.17,98.94 v1(184.27,99.04) 183.97,99.34 U32.39 ; v1(145.11,134.3) 144.97,134.44 U125.111 ; U125.67 138.8,148.98 v1(139,148.77) 138.8,148.58 U125.68 ; U32.56 180.88,105.71 v1(181.28,106.11) U32.55 ; U125.114 146.17,134.74 v1(145.93,134.5) ; U125.77 v1(136.67,144.98) ; U32.48 184.31,102.94 v1(184.33,102.92) 183.95,102.54 U32.47 ; U1.52 v1(140.41,116.51) ; U1.11 146.39,113.46 146.47,113.38 146.47,113.05 v1(146.66,112.86) 146.79,112.98 U1.12 ; v1(118.08,134.92) 117.86,134.7 PU8.26 ; U1.18 149.32,116.11 149.66,115.78 v1(149.89,115.78) ; v1(149.51,137.06) 149.37,136.93 U125.122 ; U125.102 141.37,136.61 140.48,137.5 v1(140.48,137.89) ; U1.40 v1(143.19,122.1) ; U125.57 v1(142.17,150.07) ; U1.29 v1(148.11,121.06) ; v1(149.43,120.3) 149.25,120.11 U1.28 ; U125.3 v1(154.54,138.18) ; U125.100 140.57,136.63 139.98,137.22 v1(139.91,137.22) ; v1(147.42,149.94) 147.42,150.07 147.37,150.12 U125.44 ; U1.56 v1(141.44,114.37) ; v1(136.66,147.07) 136.66,147.09 136.95,147.38 U125.71
  TOP w0.203: U115.5 94.9,121.64 v1(94.59,121.95) ; v1(102.24,123.64) 102.9,124.29 U115.37 ; U115.29 v1(105.7,120.14) ; U125.62 140.17,152.19 v1(140.49,152.51) 140.8,152.51 140.97,152.34 U125.60 ; U115.13 v1(97.4,115.45)
  TOP w0.254: U2.BD32 U2.BD34 70.5,67.74 v1(70.9,67.35) ; U2.G48 76.99,86.14 76.8,85.96 v1(76.8,85.93) ; U2.A9 57.86,89.87 57.52,90.21 v1(57.14,90.21) ; U2.H29 67.55,85.76 v1(67.18,85.4) 67.58,85 U2.J29 ; U2.D14 60.24,87.55 U2.C13 ; v1(57.82,78.91) 58.21,79.3 U2.Y10 ; U123.8 v1(127.42,19.73) ; PC83.2 68.22,15.33 65.78,15.33 62.22,18.9 55.89,18.9 54.14,17.14 48.09,17.14 45.57,14.62 45.57,12.57 PR34.2 ; PR71.2 125.45,141.05 126.16,141.75 129.37,141.75 133.29,137.82 133.29,119.51 130.71,116.93 128.42,116.93 127.57,116.07 127.57,112.14 128.28,111.43 PC99.2 ; U2.V46 75.92,80.71 75.34,80.71 U2.V44 ; 82.45,89.05 82.44,89.05 U2.A57 ; U2.AJ4 55.25,74.99 54.28,74.99 U2.AJ2 ; U43.74 v1(141.29,31.51) ; PU2.4 56.19,109.23 56.01,109.05 v1(56.01,108.6) ; v1(53.12,72.96) 53.45,72.63 U2.AP1 53.85,72.63 54.08,72.4 U2.AP3 ; v1(80.7,85.29) 80.61,85.29 80.32,85 U2.J54 U2.J52 ; v1(64.52,90.45) 63.99,89.92 U2.A21 64.24,88.79 U2.C22 ; U2.BB54 80.43,68.22 U2.BD54 ; v1(126.57,24.78) 126.92,24.43 U123.4 ; v1(67.18,84.63) 67.58,84.24 U2.L29 ; v1(142.94,167.36) 142.69,167.11 U129.46 ; U2.AY19 62.79,69.27 v1(63.26,69.73) ; U2.AY14 U2.AY12 ; v1(72.51,90.42) 72.51,89.56 73.01,89.06 U2.A39 ; v1(87.01,81.65) 86.82,81.84 U2.R66 86.03,81.59 U2.T64 ; v1(147.98,164.77) 148.06,164.7 U129.60 ; U2.BF23 64.57,66.6 v1(64.94,66.96) 64.54,67.36 U2.BD23 ; U2.E30 67.93,87 v1(67.17,86.24) 66.65,86.77 U2.E27 66.63,86.86 U2.E25 ; v1(98.53,174.4) 98.75,174.62 U128.93 ; v1(57.84,80.38) 58.21,80.01 U2.W10 ; U2.BB66 86.74,68.34 87.19,67.88 v1(87.19,67.74) ; U2.BE66 86.89,66.9 v1(86.99,66.79) ; U2.E34 70.56,86.86 71.08,86.34 v1(71.23,86.34) 71.84,86.96 U2.E37 ; v1(79.86,65.3) 79.65,65.1 U2.BK53 79.17,64.26 U2.BL52 78.89,64 U2.BL50 78.47,63.1 U2.BN50 78.61,63.05 79.11,62.55 U2.BP52 ; U2.BF46 76.46,66.6 v1(76.86,66.2) ; 56.56,70.38 v1(56.56,70.79) ; 56.56,70.38 56.42,70.38 U2.AW5 ; 56.56,70.38 56.87,70.07 U2.AW8 ; U2.F4 55.13,86.32 54.74,85.93 U2.G3 54.43,85.6 54.43,85.34 v1(54.24,85.16) U2.K1 53.19,84.7 v1(52.49,85.4) ; v1(86.93,85.17) 86.91,85.17 86.64,84.91 U2.J66 ; U2.BK17 61.64,64.88 v1(61.32,65.2) ; U128.79 98.72,167.62 98.39,167.95 v1(98.37,167.95) ; U2.T55 U2.R55 U2.R53 79.95,82.64 v1(80.07,82.76) ; U2.BC1 52.43,68.13 52.03,68.54 v1(48.02,68.54) ; U128.60 90.53,165.42 90.84,165.74 91.87,165.74 v1(91.99,165.62) ; U2.Y4 55.28,79.68 54.73,80.23 U2.W3 54.28,80.25 53.98,80.55 v1(53.06,80.55) ; U2.AY1 53.75,69.79 53.75,69.81 v1(53.3,70.26) ; v1(60.93,89.6) 60.93,89.13 60.92,89.12 U2.A15 ; U2.C54 80.29,88.19 80.29,88.96 U2.A54 80.39,89.06 v1(80.39,89.63) ; U129.65 v1(150.56,164.49) ; v1(57.11,74.91) 56.69,75.33 ; U2.C6 U2.D6 55.6,87.34 ; U129.32 142.87,174.11 v1(142.95,174.19) ; v1(82.73,62.05) 82.72,62.05 82.21,62.55 U2.BP58 ; U2.A42 74.43,90.24 v1(74.58,90.39) ; U128.32 v1(85.41,175.12) ; v1(77.93,89.99) 78.1,89.82 78.1,88.68 U2.B50 ; U2.E32 69.25,87.03 U2.D32 68.79,87.55 v1(68.68,87.44) ; v1(61.23,61.94) 61.23,62.45 U2.BP16 ; v1(58.98,65.82) 58.59,66.22 U2.BG11 ; U15.T9 58.77,128.96 v5(59,129.19) ; U2.Y17 62.02,79.3 v1(61.63,78.91) ; U2.BC11 U2.BC13 59.74,68.35 v1(59.31,68.78) ; PC63.2 26.47,112.13 26.8,112.45 26.8,115.13 26.33,115.6 23.22,115.6 21.09,117.73 21.09,118.71 21.09,118.71 21.09,129.99 23.93,132.84 23.93,134.26 25.16,135.49 28.5,135.49 28.93,135.05 PR27.1 ; v1(74.44,86.67) 74.63,86.86 U2.E43 74.96,86.88 U2.E45 76.22,86.88 U2.E46 76.34,87.61 U2.D46 76.22,87.73 U2.B46 75.87,88.79 U2.A45 v1(75.87,89.63) ; v1(74.44,86.67) 74.24,86.86 U2.E41 ; v1(74.44,86.67) 74.95,86.16 v1(75.15,86.16) 75.52,85.79 U2.H44 ; U128.10 93.53,178.77 v1(93.34,178.59) 93.03,178.9 U128.11 ; v1(72.88,65.44) 73.19,65.13 73.56,65.13 73.96,64.74 U2.BK42 ; U2.M64 85.4,83.7 85.55,83.55 85.78,83.55 85.86,83.47 U2.M66 86.73,83.47 v1(86.86,83.34) ; U2.AE3 54.61,77.08 54.17,77.08 54.11,77.13 U2.AE1 53.77,77.15 53.39,77.15 v1(53.23,76.98) ; U129.10 v1(151.06,177.19) ; U2.AF65 86.03,76.66 86.06,76.63 87.39,76.63 v1(87.64,76.38) ; v1(71.39,89.91) 71.39,89.53 71.33,89.47 71.33,89.17 71.37,89.13 U2.A36 ; J3.7 115.34,74.91 v1(115.13,74.69) ; U2.L48 76.93,84.44 v1(76.76,84.44) 76.42,84.44 U2.L46 U2.L44 75.17,84.59 v1(74.83,84.59) ; U2.K25 65.59,84.62 65.55,84.66 65.31,84.42 v1(64.99,84.42) ; U2.P17 61.48,82.33 v1(61.13,82.67) ; v1(78.84,65.82) 78.48,65.46 U2.BH50 ; v1(64.9,65.41) 65.12,65.18 U2.BK24 ; U2.AK5 56.35,74.48 v1(56.52,74.66) ; U2.A27 66.87,89.39 v1(66.61,89.64) ; v1(92.73,156.12) 92.73,155.66 92.56,155.49 PU1.4 ; v1(158.51,166.52) 158.42,166.52 158.34,166.61 U129.79 ; U32.34 182.48,96.59 182.71,96.36 v1(183.29,96.36) ; U2.B32 68.91,88.61 68.78,88.74 68.49,89.02 U2.A30 68.49,89.55 v1(68.62,89.68) ; U2.BP55 80.58,61.85 v1(80.52,61.78) ; v1(155.59,173.89) 155.87,173.61 U129.93 ; U2.AH7 56.54,75.19 U2.AJ5 ; PU4.4 116.08,155.52 116.25,155.7 v1(116.25,156.15) ; v1(58.85,62.89) 58.85,62.81 58.6,62.56 58.07,62.56 U2.BP10 ; v1(64.68,89.69) 64.67,89.69 U2.B23 ; U129.11 150.56,177.75 v1(150.46,177.65) ; v1(53.1,78.83) 53.1,78.9 53.25,78.76 U2.AB1 54.15,78.76 54.36,78.97 54.74,78.97 U2.AA3 54.82,78.99 U2.AA5 ; U60.8 126.1,168.07 125.52,167.49 v1(125.52,167.01) ; U2.Y60 83.74,79.54 U2.W62 ; U2.C18 v1(62.13,87.51) 62.13,87.03 62.14,87.02 U2.E18 62.12,86.86 U2.E16 61.38,86.8 61.12,86.8 v1(60.87,86.56) 60.71,86.56 U2.E14 59.76,86.86 U2.E13 59.71,87.3 v1(59.63,87.38) ; U2.N7 56.69,83.12 v1(57.45,82.36) 57.08,81.99 U2.R8 ; U2.BK60 83.32,64.92 v1(83.65,64.92) ; v1(69.96,89.62) 69.93,89.59 U2.A33 ; v1(114.07,70.42) 115.56,71.91 J3.19 ; v1(64.56,91.15) 65.43,90.29 U2.A24 ; U2.BK48 77.12,64.59 76.47,65.24 76.47,65.83 U2.BG46 ; U2.AT56 81.1,71.6 v1(81.47,71.22) ; v1(57,88.34) 57.1,88.24 U2.D8 ; v1(80.25,4.92) 80.25,5.52 80.42,5.7 PU5.4 ; U128.46 v1(85.48,168.12) ; U2.BF53 U2.BD53 ; U2.BC45 U2.BA45 U2.AY45 U2.AY46 76.49,69.65 v1(76.85,69.28) 76.46,68.89 U2.BA46 U2.BC46 76.48,68.12 v1(76.89,67.71) 76.55,67.36 U2.BD46 ; v1(86.93,77.33) 86.29,77.33 U2.AD66 ; U2.AW53 79.95,70.31 v1(80.34,70.7) ; v1(65.46,67.36) 65.83,67.73 U2.BD25 ; U2.A18 62.36,89.48 v1(62.58,89.7) ; U2.BC21 U2.BC23 64.54,68.13 v1(64.92,68.5) 64.54,68.88 U2.BA23 U2.BA21 ; U128.65 93.03,165.77 92.77,166.02 v1(92.58,166.02) ; v1(59.51,89.6) 59.49,89.58 U2.A12 ; U2.AV4 55.28,70.04 v1(55.34,69.98) ; U2.BG54 U2.BF54 ; U2.T5 56.06,81.42 v1(56.57,80.91) ; v1(72.43,76.2) U2.AF39 ; U2.E7 57.62,86.86 U2.E9 57.69,86.88 58.35,86.23 ; v1(80.23,87.42) 80.15,87.34 U2.E54
  TOP w0.279: v1(136.69,39.31) 136.69,39.31 136.61,39.39 U43.50 ; v1(147.54,45.07) 148.28,45.82 148.28,47.19 U43.15
  TOP w0.305: U2.N63 85.28,83.43 U2.M64 ; U2.AT17 U2.AT19 62.78,70.71 v1(62.71,70.64) ; U2.AT17 U2.AR17 ; U2.AT17 61.35,71.36 ; v1(118.47,61.62) 118.18,61.62 117.9,61.91 J3.59 ; U2.K34 70.36,84.52 70.36,84.51 v1(70.64,84.24) 70.84,84.03 71.35,84.03 U2.L37 U2.L38 72.42,84.07 72.98,84.07 73.53,84.62 U2.K41 U2.K42 ; U2.L50 U2.L48 ; v1(115.08,64.41) 115.08,64.41 116.33,64.41 116.33,64.4 116.76,64.4 J3.49 ; U2.BD21 U2.BD23 ; U2.AF21 63.21,76.6 U2.AF20 62.78,76.21 U2.AG19 U2.AG17 U2.AG16 61.36,76.13 61.36,76.61 v1(61.5,76.75) ; U2.AF21 64.03,76.68 63.92,76.79 63.92,77.29 U2.AD21 ; U2.AF21 U2.AG21 ; U2.AY12 U2.AW12 59.36,70.79 v1(59.27,70.88) 59.27,71.06 U2.AT11 U2.AR11 58.97,72.28 v1(58.69,72.57) ; U2.G50 78.47,86.41 78.66,86.41 78.84,86.59 v1(78.98,86.59) 78.71,86.86 U2.E50 78.47,86.91 78.47,87.33 78.26,87.55 U2.D50 ; U2.AN62 84.05,73.1 U2.AP62 84.05,72.31 84.1,72.26 U2.AR62 84.1,71.63 v1(83.88,71.41) 83.88,71.14 84.1,70.93 U2.AU62 ; v1(118.46,73.63) 118.28,73.63 118.05,73.41 J3.13 ; v1(80.33,69.24) 79.96,69.61 U2.AY53 U2.AY52 ; U2.Y19 63.19,78.9 U2.AB20 ; U2.Y19 62.73,79.35 62.07,79.35 U2.Y17 ; U2.Y19 U2.W19 ; U2.BL12 59.22,63.99 U2.BK12 ; U2.BL12 59.62,63.9 v1(59.9,64.17) 59.91,64.19 U2.BK13 60.61,64.73 U2.BK15 ; U2.BL12 59.34,63.87 U2.BN12 ; v1(58.86,85.8) 58.63,85.8 58.35,86.09 U2.G10 58.35,86.23 ; U2.AE5 55.91,76.87 54.86,76.87 54.83,76.9 U2.AE3 ; U2.BK36 71.51,64.79 72.03,65.31 72.75,65.31 v1(72.88,65.44) ; U2.G7 56.69,85.72 v1(56.45,85.48) 56.18,85.21 U2.J5 55.45,85.21 U2.H4 ; U2.U8 57.07,81.15 v1(57.84,80.38) ; U2.AD65 85.75,77.62 86.06,77.62 86.28,77.4 U2.AD66 ; U2.BJ62 84.82,64.99 U2.BJ63 84.93,65.49 v1(84.8,65.62) ; v1(118.39,76.5) 118.39,76.5 118.3,76.41 J3.1 ; U2.BM62 84.47,63.5 v1(84.08,63.89) ; v1(78.84,67.35) 78.48,66.98 U2.BE50 ; U2.C9 57.33,88.34 v1(57,88.34) ; U2.BK21 63.85,64.73 U2.BK22 64.42,64.15 v1(64.39,64.13) 64.04,64.13 U2.BL21 63.85,63.87 U2.BN21 ; U2.E41 73.92,87.38 U2.D41 73.63,87.43 v1(73.17,87.43) 72.91,87.43 U2.D39 ; U2.N11 58.97,83.26 59.33,82.9 v1(59.35,82.9) 59.35,81.99 U2.R12 U2.U12 ; U2.AD50 U2.AC50 78.43,78.26 v1(78.82,78.65) ; v1(120.48,71.39) 120.64,71.39 121.16,71.91 J3.20 ; v1(68.91,66.96) 68.52,67.36 U2.BD30 ; U2.BA42 U2.BB42 ; v1(84.08,63.89) 83.69,63.49 U2.BM61 ; v1(84.08,63.89) 84.5,64.31 U2.BK62 ; U2.BP61 v1(83.71,61.98) ; U2.AK62 83.4,74.68 U2.AL59 U2.AM59 ; U2.BL30 68.35,63.87 U2.BN30 ; v1(55.64,65.1) 56.02,65.48 U2.BH5 ; v1(55.64,65.1) 56,64.74 U2.BK6 ; v1(55.64,65.1) 55.28,65.45 U2.BG4 55.45,66.18 U2.BG5 ; U2.AG11 U2.AH11 58.97,75.3 v1(59.34,74.94) ; U2.R59 83.17,82.4 83.17,82.73 v1(83.35,82.91) 84.11,83.67 U2.M62 ; U2.C5 55.55,88.1 U2.C6 ; U2.P38 U2.R38 ; U2.R38 72.24,81.95 71.93,81.64 U2.T37 71.93,80.7 U2.V38 U2.W38 U2.AA36 ; U2.R38 72.48,81.95 72.83,81.6 U2.T39 73.07,81.3 v1(73.31,81.06) ; 56.69,75.33 U2.AH7 U2.AG7 ; U2.AM55 80.92,73.79 80.92,74.07 U2.AL55 80.94,74.52 80.94,75.42 U2.AH56 U2.AG56 81.09,77.02 v1(81.07,77.04) ; 61.35,71.36 v1(60.53,70.53) ; 61.35,71.36 U2.AT16 ; U2.BK19 62.53,64.59 U2.BK18 61.69,64.79 U2.BK17 61.16,64.26 U2.BL16 ; v1(73.31,81.06) 73.63,80.74 U2.V41 ; v1(73.31,81.06) 73.54,81.28 U2.T41 ; v1(73.31,81.06) 72.85,80.6 U2.V39 ; U2.P18 U2.P17 U2.T17 ; U2.M21 U2.M22 64.32,83.48 64.69,83.85 v1(64.69,83.86) ; U2.W62 84.25,79.74 U2.Y63 84.83,79.68 ; v1(56.56,70.79) 56.56,71.04 56.69,71.17 U2.AT7 U2.AR7 56.31,72.06 55.95,72.41 U2.AP5 ; U2.K17 U2.K18 62.92,84.62 63.07,84.77 v1(63.06,84.78) ; U2.W23 v1(64.43,79.4) U2.W21 ; U2.AN66 v1(86.97,72.84) ; J3.31 117.99,68.91 118.36,69.27 v1(118.36,69.48) ; v1(65.86,62) 65.63,62.23 U2.BP25 ; U2.BM64 U2.BP62 ; v1(56.65,72.89) 56.67,72.92 56.67,72.95 U2.AM8 ; U2.BD32 U2.BB32 ; U2.A36 71.72,88.7 U2.B37 71.72,88.36 71.77,88.31 71.77,87.78 71.75,87.76 U2.D37 71.75,87.1 U2.E37 ; U2.AY37 U2.BA37 71.79,68.88 v1(71.42,68.5) 71.79,68.13 U2.BC37 ; U2.BB62 U2.AY62 83.63,69.49 v1(83.38,69.24) ; J3.38 121.38,67.41 121.3,67.33 121.23,67.33 121.07,67.16 121.07,67.1 120.8,66.83 v1(120.8,66.58) ; U2.AU4 55.49,71.16 U2.AV5 55.86,70.57 55.34,70.57 U2.AV4 ; U2.AR56 U2.AT56 ; U2.AK20 62.78,75.15 U2.AH19 U2.AH17 U2.AH16 61.2,75.26 v1(61.2,74.78) 61.2,74.49 U2.AL17 U2.AM17 U2.AM18 U2.AM20 ; U2.AW55 80.71,70.31 v1(81.11,70.7) ; J3.32 v1(124.34,68.91) ; J3.25 118.05,70.41 118.38,70.73 v1(118.38,71.03) ; v1(53.57,61.97) 53.57,62.33 U2.BP1 53.92,63.47 ; U2.C27 66.64,86.89 U2.E27 ; U2.W14 U2.Y14 U2.Y16 61.08,79.12 61.08,78.57 v1(61.26,78.39) 61.63,78.02 U2.AC17 U2.AD17 ; U2.L29 U2.L30 68.31,84.24 68.51,84.04 68.98,84.04 U2.K32 69.87,84.31 69.87,84.21 70.22,83.86 U2.L34 U2.N34 ; U2.E22 64.12,86.72 63.92,86.52 63.59,86.52 v1(63.21,86.13) ; U2.AY19 61.88,69.27 61.87,69.28 U2.BA17 61.75,69.37 61.71,69.37 61.55,69.53 61.04,69.53 U2.AY15 60.72,69.21 60.28,69.21 60.17,69.32 U2.AY14 ; J3.37 117.99,67.41 118.37,67.79 v1(119.27,67.79) ; U2.AY55 80.72,69.61 v1(81.09,69.24) ; U2.L8 57.45,84.06 57.08,84.43 v1(57.08,84.47) 56.69,84.08 U2.L7 56.19,83.97 U2.L5 ; U2.AV65 85.73,70.73 U2.AV63 84.83,70.26 v1(84.68,70.11) ; U2.AJ2 53.78,74.49 U2.AL1 54.13,74.26 54.21,74.34 54.61,74.34 U2.AK3 ; v1(58.98,65.82) 58.95,65.82 58.59,65.46 U2.BH11 58.59,64.66 U2.BK10 58.42,64.5 U2.BL10 58.04,63.9 57.89,64.05 U2.BL8 57.14,64.22 U2.BK8 ; U43.117 156.36,39.39 156.12,39.62 154.66,39.62 v1(153.98,40.31) ; U2.C13 59.74,88.18 U2.B14 ; U2.E5 55.6,87.34 ; v1(56.52,74.66) 57.07,74.11 U2.AL8 ; v1(79.19,75.2) 78.81,75.57 U2.AH51 U2.AG51 ; U2.AC12 U2.AD12 59.35,77.32 v1(58.96,76.92) ; U2.M3 55.99,83.52 U2.M5 56.23,83.27 U2.N7 ; J3.14 121.03,73.41 120.9,73.53 v1(119.45,73.53) ; U2.AW3 54.8,70.01 54.87,69.94 55.3,69.94 v1(55.34,69.98) ; v1(86.91,78.69) 86.77,78.55 85.74,78.55 U2.AB65 ; U2.BP59 82.89,62.21 v1(82.73,62.05) ; v1(82.62,69.24) 82.99,69.61 U2.AY59 U2.AW59 ; U2.BJ66 85.69,65.13 v1(85.5,64.94) 85.33,64.77 U2.BK64 U2.BK66 ; U2.BC3 55.37,67.9 v1(55.37,67.9) 55.38,67.91 U2.BC5 56.16,67.91 U2.BD7 U2.BC7 56.69,68.59 57.07,68.97 U2.AY8 56.81,69.37 v1(56.51,69.67) ; U2.T3 55.08,81.41 55.09,81.42 U2.T5 ; U2.AW66 v1(87.04,69.96) ; U2.BF15 U2.BD15 ; U2.BD15 U2.BC15 ; U2.BD15 61.07,67.36 v1(61.24,67.53) 61.41,67.36 61.48,67.36 U2.BE17 U2.BE19 ; U2.R46 76.22,81.78 75.93,81.49 U2.T45 75.93,81.04 76.03,80.94 U2.V46 ; U2.BE63 84.1,67.38 U2.BD62 84.05,67.46 U2.BC62 ; U2.BP64 85.33,62.38 v1(85.73,61.98) 86.14,62.39 U2.BP66 U2.BM66 ; U2.AD55 U2.AC55 80.71,78.26 v1(81.11,78.65) 81.38,78.92 81.38,79.29 81.13,79.54 U2.Y56 U2.W56 ; U2.W60 U2.Y60 83.37,79.54 v1(83,79.17) 83,78.97 83.12,78.85 83.12,78.38 U2.AC59 U2.AD59 ; U2.AT66 86.74,71.4 v1(86.84,71.3) ; U2.BH60 83.65,65.37 v1(83.65,64.92) 83.65,64.26 U2.BL61 ; J3.50 v1(120.69,64.41) ; v1(79.58,70.7) 79.19,70.31 U2.AW52 78.9,70.03 U2.AW50 ; U2.Y65 84.83,79.68 ; 84.83,79.68 84.83,79.26 v1(84.65,79.08) ; v1(124.34,70.96) 123.79,70.41 J3.26 ; U2.K26 U2.K25 ; J3.8 v1(124.07,74.91) ; U2.BG63 84.81,66.24 v1(85.43,66.24) 85.33,66.14 U2.BH64 85.89,65.69 U2.BG66 ; U2.H22 U2.H21 63.31,85.47 63.24,85.4 v1(63.21,85.4) ; U2.T62 83.94,81.72 v1(83.52,81.72) 83.33,81.53 U2.T59 ; U2.AA32 U2.W34 U2.V34 70.18,80.85 70.18,81.49 U2.T34 ; U2.Y5 56.28,80 U2.W7 U2.Y7 56.75,79.24 v1(56.75,78.7) ; U2.T50 78.21,81.58 v1(78.59,81.96) 78.92,81.96 U2.R52 ; v1(58.97,74.42) 59.35,74.04 U2.AL12 59.35,74.04 59.35,73.35 U2.AM12 ; U2.AD8 U2.AC8 57.19,78.02 57.82,78.65 v1(57.82,78.91) ; v1(87.67,74.16) 87.15,74.68 86.5,74.68 U2.AK66 85.96,74.46 85.87,74.55 85.42,74.55 U2.AK64 ; J3.2 v1(124.14,76.41) ; v1(62.5,61.16) 61.99,61.67 61.99,62.21 62.33,62.55 U2.BP19 ; U2.AW17 U2.AW19 62.69,70.03 62.99,69.73 v1(63.26,69.73) 63.26,70.28 U2.AW20 63.33,70.3 U2.AU21 ; v1(78.42,79.17) 78.8,79.54 U2.Y51 U2.W51 ; U2.AY56 81.48,69.61 v1(81.85,69.24) 82.23,69.61 U2.AY58 ; U2.L14 U2.L13 59.33,84.54 v1(59.07,84.54) ; v1(59.74,72.73) U2.AR13 ; U2.AF62 83.84,76.16 83.84,76.03 U2.AH60 ; U2.BD53 79.36,67.73 v1(79.36,67.74) 79.36,68.12 U2.BB53 U2.BB54 80.33,68.32 v1(80.73,68.72) 81.09,68.35 U2.BB56 ; v1(67.18,62) 67.07,62.11 U2.BP28 ; v1(75.65,87.47) U2.E45
  TOP w0.356: v5(78.57,140.46) U14.L5 ; v5(69.77,129.26) U14.AA18 ; v5(86.57,143.66) U14.A1 ; v5(76.17,133.26) 76.57,132.86 U14.N14 ; U14.N5 v5(76.97,140.46) 77.37,140.06 U14.M5 ; U14.F4 82.18,140.86 v5(82.57,141.26) ; U14.P5 75.77,140.06 75.37,140.46 ; v5(79.37,127.66) 79.22,127.81 78.97,128.06 U14.K20 ; U2.V44 74.86,80.23 74.86,80.21 v1(74.84,80.19) 74.84,80.19 U2.V42 U2.W41 U2.AA39 72.61,78.78 72.61,78.42 U2.AC39 ; U2.AA32 v1(69.23,78.6) U2.AC32 ; v5(51.39,137.77) 51.39,137.76 U15.E1 ; v5(84.17,138.06) U14.D8 ; v5(76.97,133.26) 77.37,132.86 U14.M14 ; v5(84.97,141.26) U14.C4 ; v1(81.81,84.79) 81.85,84.74 U2.L57 81.92,84.15 81.92,83.58 U2.M57 ; U15.P9 59.39,130.56 v5(59.4,130.57) ; v5(75.37,133.26) 75.77,132.86 U14.P14 ; U14.R5 75.37,140.46 ; 75.37,140.46 v5(75.37,140.46) ; v5(85.77,138.06) U14.B8 ; v5(86.57,142.86) U14.A2 ; U14.J18 79.77,129.66 79.95,129.48 80.11,129.32 v5(80.17,129.26) ; U14.L3 78.19,141.66 v5(78.58,141.26) 78.18,140.86 U14.L4 ; v5(80.97,142.06) 80.57,141.66 U14.H3 ; v1(60.97,102.35) 61.2,102.12 U9.8 ; U70.2 v1(108.58,167.7) ; U14.J19 79.77,128.86 80.02,128.61 v5(80.17,128.46) ; v5(51.39,136.17) 51.39,136.16 U15.G1 ; U61.4 v1(127.94,164.96) ; U14.N4 v5(76.97,141.26) 77.37,140.86 U14.M4 ; v5(58.06,134.16) U15.J8 ; v5(70.57,128.46) U14.Y19 ; U14.D22 v5(84.17,126.86) U14.D21 ; v5(51.38,140.17) 51.38,140.16 U15.B1 ; U14.N1 76.58,143.26 v5(76.97,143.66) 77.37,143.26 U14.M1 ; U15.B3 53.66,140.16 53.27,140.56 v5(53.26,140.56) ; v5(59.38,131.71) 58.92,132.16 U15.M9 ; v5(83.37,136.46) U14.E10 ; U15.D8 57.67,138.56 58.06,138.16 v5(58.06,138.16) 57.67,137.77 U15.E8 ; v5(85.77,143.66) U14.B1 ; v5(79.37,140.46) U14.K5 ; v5(84.17,140.46) U14.D5 ; U14.M2 77.37,142.46 v5(76.97,142.86) U14.N2 ; v5(84.17,142.06) U14.D3 ; v5(85.77,142.06) U14.B3 ; v5(80.97,142.86) U14.H2 ; v5(81.77,140.46) U14.G5 ; U15.B9 58.47,140.17 v5(58.87,140.57) ; U15.D1 v5(51.42,138.56) ; v5(86.57,142.06) U14.A3 ; v5(80.17,142.06) U14.J3 ; v5(82.57,142.06) U14.F3 ; v5(84.97,137.26) U14.C9 ; v5(86.57,135.66) U14.A11 ; v5(84.97,140.46) U14.C5 ; U51.25 163.29,31.18 v1(163.14,31.34) ; v5(84.97,135.66) U14.C11 ; v5(52.47,138.16) U15.E2 ; U15.A9 58.47,140.97 58.95,141.45 v5(59.88,141.45) ; U15.F9 58.47,136.96 v5(58.87,136.56) U15.G9 ; v5(85.77,142.86) U14.B2 ; v5(84.17,142.86) U14.D2 ; v5(84.97,138.06) U14.C8 ; U14.M3 77.37,141.66 v5(76.97,142.06) U14.N3 ; v5(51.23,128.91) 52.01,128.91 U15.T1 ; v5(80.97,141.26) U14.H4 ; v5(85.77,137.26) U14.B9 ; U15.P1 52.07,130.56 51.31,130.56 v5(51.28,130.54) ; v1(70.83,78.6) U2.AA36 ; v5(85.77,141.26) U14.B4 ; v5(80.97,143.66) U14.H1 ; v5(83.37,138.06) U14.E8 ; v5(85.77,135.66) U14.B11 ; v5(84.97,142.86) U14.C2 ; v5(52.47,134.96) U15.J2 ; v5(84.17,143.66) U14.D1 ; v5(83.37,135.66) U14.E11 ; v5(82.57,140.46) U14.F5 ; v5(84.97,143.66) U14.C1 ; v5(83.37,142.86) U14.E2 ; U14.L2 v5(78.57,142.86) 78.17,143.26 U14.L1 ; U14.D4 v5(84.17,141.26) U14.C3 v5(84.97,142.06) ; U2.BP8 U2.BP6 ; v5(51.08,132.27) 51.18,132.17 52.06,132.17 U15.M1 ; v5(86.57,137.26) U14.A9 ; v5(83.37,140.46) U14.E5 ; v5(57.27,136.56) U15.G8 ; v5(69.77,128.46) U14.AA19 ; v5(83.37,142.06) U14.E3
  TOP w0.381: U2.BG1 v1(52.79,65.94) ; v1(146.26,186.86) 146.26,187.02 146.64,187.4 C746.2 ; v5(76.17,136.46) 76.57,136.06 U14.N10 ; U14.J12 79.77,134.46 v5(80.17,134.06) ; v5(79.37,137.26) U14.K9 ; J2.170 105.48,30.6 v1(105.39,30.69) ; U2.C3 54.73,89.06 v1(54.73,89.06) 55.4,89.06 U2.A5 U2.C5 ; J2.8 v1(54.48,30.63) ; v1(59.46,30.79) 59.88,30.36 J2.26 ; C581.2 103.25,167.11 103.65,166.7 104.14,166.7 104.59,167.15 v1(104.76,167.15) ; v5(80.17,132.46) 79.77,132.86 U14.J14 ; v1(20.63,2.33) 20.76,2.46 U10.2 ; U14.P9 75.77,136.86 v5(75.37,137.26) ; v5(187.54,119.87) U102.E6 ; J2.146 98.28,30.95 98.93,31.6 v1(99.43,31.6) 100.08,30.94 J2.152 ; v5(78.57,135.66) U14.L11 ; J2.53 v1(67.98,22.46) ; U2.E3 U2.E1 53.92,88.31 v1(53.79,88.44) ; U2.E3 54.73,86.88 v1(54.55,86.69) 54.74,86.5 U2.F4 ; U2.E3 U2.E5 ; v5(79.37,133.26) 78.97,133.66 U14.K13 ; v1(136.97,186.88) 136.88,186.97 C626.2 ; v1(74.54,23.42) 75.37,22.59 75.37,20.95 J2.73 ; v1(55.55,61.87) U2.BP5 U2.BP6 56.36,62.16 56.26,62.07 v1(56.26,61.94) ; v1(54.57,61.78) 54.73,61.95 U2.BP3 ; v5(76.97,133.26) U14.M13 ; U14.P4 75.77,140.86 75.37,141.26 v5(75.37,141.26) ; U2.BD54 80.58,67.36 v1(81.09,66.85) 80.85,66.6 U2.BF54 ; v5(78.57,137.26) U14.L9 ; v1(59.51,90.38) 59.84,90.38 60.16,90.05 U2.B14 ; v5(84.17,135.66) U14.D11 ; v1(74.04,78.58) 74.43,78.98 U2.AA42 ; J2.79 78.18,19.61 v1(78.52,19.28) ; U2.BK5 55.69,64.31 U2.BK6 ; v5(80.17,136.46) U14.J10 ; J2.195 v1(112.98,23.03) ; R17.1 v1(145.75,109.75) ; v5(78.57,132.46) 78.17,132.86 U14.L14 ; 169.85,173.55 U57.25 171.41,173.55 173.08,173.55 v1(173.13,173.61) ; v1(161.14,174.81) 160.67,175.28 R794.2 ; v5(75.37,134.06) U14.P12 ; U2.BK3 U2.BK1 53.43,64.31 v1(53.16,64.59) ; U14.N11 76.57,135.26 v5(76.17,135.66) ; v1(143.97,186.86) 144.35,187.24 C752.2 ; J2.78 77.88,30.63 v1(77.93,30.68) ; J2.201 v1(114.78,22.53) ; v5(79.37,135.66) U14.K11 ; U2.BM1 53.92,63.47 53.9,63.49 53.28,63.49 v1(53.26,63.47) ; U14.M9 77.37,136.86 v5(76.97,137.26) ; U56.25 v1(21.77,141.16) ; J2.181 v1(108.78,22.39) ; v5(76.17,133.26) U14.N13 ; v5(189.54,119.87) U102.E5 ; v5(189.54,118.87) U102.D5 ; R806.2 v1(161.13,176.3) ; v5(75.37,133.26) U14.P13 ; U2.A8 v1(57.17,89.54) ; U14.J13 79.77,133.66 v5(80.17,133.26) ; v5(80.17,137.26) U14.J9 ; U55.25 v1(21.14,156.73) ; U14.M10 77.37,136.06 v5(76.97,136.46) ; J2.175 v1(106.98,22.45) ; v1(138.02,186.98) 137.98,187.02 C623.2 ; U2.AL1 53.55,74.26 v1(53.16,74.64) ; J2.137 95.58,22.65 95.76,22.83 v1(95.76,22.83) ; U14.L13 78.17,133.66 v5(78.57,133.26) ; v5(76.97,135.66) 77.37,135.26 U14.M11 ; v1(153.04,186.84) 153.11,186.91 C636.2 ; U14.K14 78.97,132.86 v5(79.37,132.46) ; U52.25 v1(26.52,18.65) ; v5(76.97,134.06) U14.M12 ; v5(72.17,129.26) U14.V18 ; J2.9 v1(54.78,22.46) ; v1(140.58,183.93) 140.29,184.23 C761.2 ; R642.2 30.26,56.41 30.26,57.09 v1(30.36,57.19) ; v5(186.54,118.87) U102.D7 ; U14.N9 76.57,136.86 v5(76.17,137.26) ; v5(78.57,136.46) U14.L10 ; v5(76.17,134.06) U14.N12 ; U16.3 v1(59.21,123.87) ; U14.P11 75.77,135.26 v5(75.37,135.66) ; J2.178 v1(107.88,30.76) ; U2.A6 56.36,90.58 56.74,90.96 v1(57.16,90.96) ; J2.169 v1(105.18,22.47) ; v5(189.54,122.87) U102.G5 ; J2.163 v1(103.38,22.4) ; J2.149 v1(99.18,22.46) ; J2.143 v1(97.38,22.4) ; J2.187 110.58,22.31 110.94,22.66 v1(110.94,22.66) ; v5(80.17,135.66) U14.J11 ; U132.4 v1(39.09,53.54) ; U14.L12 78.17,134.46 v5(78.57,134.06) ; J2.197 v1(113.58,22.55) ; v5(79.37,136.46) U14.K10 ; J2.155 v1(100.98,22.42) ; C758.2 v1(142.12,187.08) ; v5(75.37,136.46) 75.77,136.06 U14.P10 ; R16.1 v1(147.02,109.77) ; J2.14 v1(56.28,30.62) ; v5(189.54,121.87) U102.F5 ; v5(79.37,134.06) 78.97,134.46 U14.K12
  TOP w0.406: v1(110.93,180.67) 110.98,180.72 110.98,181.05 111.24,181.32 U131.2 ; U2.BJ1 53.7,65.13 v1(53.16,64.59) ; U54.2 v1(186.68,63.95) ; U2.BK3 U2.BK5
  TOP w0.457: v1(46.45,107.03) 46.45,106.14 47.01,105.58 R1089.1 ; R229.1 R225.2 v1(126.48,59.55) ; PJ17.1 114.43,140.91 v1(114.27,140.75) ; J2.41 v1(64.38,22.4) ; v1(58.3,173.88) 58.89,173.88 59.27,174.26 U87.3 ; v1(55.34,107.73) 55.34,107.73 PC20.1 ; v1(136.76,52.71) 136.76,52.72 137.32,53.28 U136.3 ; C536.2 137.84,50.47 v1(137.84,51.21) ; C848.2 v1(78.78,106.14) 79.02,105.9 R1238.1 ; v1(69.62,30.99) 69.48,30.85 J2.58 ; R43.2 R40.2 ; C136.2 63.34,95.53 v1(63.55,95.74) ; v1(43.03,131.15) 43.02,131.14 PR17.1 ; R23.1 v1(148.29,109.71) ; v1(45.02,3.7) 45.02,3.26 45.44,2.84 Q43.2 ; v1(111.62,158.52) PC30.2 112.26,158.53 R1232.1 ; J2.64 v1(71.28,30.92) ; R1014.1 76.8,176.26 v1(76.4,175.86) 76.55,175.71 U84.3 ; PR2.2 v1(92.02,159.31) ; v1(158.09,144.2) R276.1 ; v1(26.29,134.83) 26.7,134.42 PC70.2 ; J2.32 v1(61.68,27.63) ; C1122.2 v1(107.86,120.24) ; C506.2 v1(26.7,51.9) ; U94.S v1(76.79,180.94) ; v1(68.28,99.23) 68.1,99.05 R497.1 R80.1 ; v1(96.2,76.17) 92.46,76.17 R78.2 ; R584.1 v1(178.45,162.42) ; PR19.2 v1(80.97,1.86) ; v1(96.48,31.06) 95.88,30.47 J2.138 ; v1(40.1,100.93) 40.68,100.93 C817.2 ; C620.2 66.89,170.63 v1(66.84,170.69) ; v1(103.89,175.06) 103.57,175.39 103.27,175.39 C909.2 ; R1083.2 v1(93.09,150.22) ; C811.2 v1(105.74,128.61) ; v1(41.01,122.16) 40.72,122.16 40.5,122.39 C829.2 39.48,122.87 R1233.1 ; PC86.1 v1(46.96,6.48) ; R26.1 v1(149.56,109.67) ; J2.46 65.88,27.85 65.58,27.55 v1(65.42,27.55) ; J2.52 v1(67.68,27.6) ; J2.61 v1(70.38,22.53) ; J2.196 113.28,27.78 v1(113.54,27.52) ; U38.4 v1(168.14,163.85) ; C779.2 v1(44.95,174.43) ; C497.2 v1(32.95,75.47) ; PR103.2 v1(49.92,15.24) ; C619.2 v1(73.91,170.63) ; U89.3 v1(66.23,175.81) ; R1114.1 v1(82.22,116.77) ; C197.1 128.13,66.62 v1(128.15,66.64) ; v1(151.01,55.94) 149.16,55.94 148.95,55.72 R1135.1 ; R44.2 v1(46.38,82.18) ; PC25.2 v1(88.14,158.46) ; v1(72.57,180.97) 73.1,180.44 U97.S ; J2.47 v1(66.18,22.46) ; R1120.2 v1(197.44,131) ; v1(143.9,56.94) 143.22,56.25 C539.2 ; R84.1 R83.1 66.07,97.51 v1(66.39,97.83) ; v1(92.18,97.73) 92.24,97.67 92.24,96.98 R1102.1 ; PC40.2 v1(118.51,155.51) ; C819.2 39.16,105.03 38.87,104.74 v1(38.87,104.46) 39.02,104.32 R1106.1 ; R289.1 156.07,133.18 v1(156.32,133.43) ; C502.2 v1(26.3,43.19) ; v1(116.92,157.02) 116.93,157.02 PC41.1 ; C604.2 v1(58.43,185.55) ; v1(68.82,97.82) 69.11,97.52 R82.1 ; v1(46.26,184.44) 46.51,184.19 C777.2 ; v1(72.15,97.85) 72.16,97.84 R56.2 R52.2 ; v1(115.01,159.21) 115.53,158.69 PR14.2 ; v1(116.07,180.76) 115.51,181.31 C776.2 ; C856.2 v1(130.08,19.85) ; C573.1 118.91,179.03 119.43,179.03 v1(119.56,179.16) ; v1(119.34,164.55) 119.34,164.56 119.13,164.77 R772.2 ; C877.2 v1(140.2,132.6) ; J2.23 v1(58.98,22.47) ; R1162.2 v1(138.05,59.31) ; U103.S v1(135.66,53.45) ; v1(127.39,63.26) 127.3,63.35 C183.2 ; J2.17 v1(57.18,22.42) ; v1(151.21,53.9) 150.56,53.9 R1156.2 ; v1(95.58,155.37) 95.58,155.37 95.02,154.81 PC8.2 ; PC85.1 v1(48.92,15.28) ; R1093.1 73.66,98.78 73.99,99.12 v1(73.99,99.28) ; R285.1 v1(158.02,149.21) ; C826.2 83.23,102.41 v1(83.44,102.2) ; R277.1 v1(158.22,145.22) ; v1(160.63,139.18) R284.1 R1229.2 ; v1(46.85,76.66) 47.15,76.36 47.91,76.36 C112.2 ; PC51.2 77.64,5.87 v1(77.64,5.66) ; v1(118.48,129.36) 118.48,129.34 119.07,128.75 PC88.2 ; v1(186.68,43.76) 186.68,42.72 U53.2 ; v1(93.41,156.99) 93.64,156.76 PC9.1 ; R1158.2 v1(163.09,165.96) ; v1(97.39,146.22) 97.44,146.16 C837.2 98.48,145.46 R1234.1 ; PR6.2 v1(56.73,105.39) ; v1(53.07,109.86) PC19.2 ; v1(184.64,94.71) 184.31,94.38 R526.2 ; v1(61.93,174) 62.45,174 62.83,174.38 U85.3 ; v1(138.05,154.66) 137.82,154.66 137.57,154.4 R295.1 ; v1(87.78,95.14) 87.51,94.87 R160.2 R154.2 ; C1119.1 v1(107.08,122.45) ; R288.1 v1(158.19,138.54) ; R104.1 75.21,97.24 v1(75.7,97.73) ; PR36.1 v1(45.43,11.03) ; v1(142.08,52.76) 142.08,53.67 C538.2 ; C111.2 v1(46.61,77.63) ; v1(102.6,18.99) 102.58,18.99 102.39,18.79 R207.1 ; C853.1 v1(51.11,3.85) ; C773.2 v1(57.32,177.29) ; J2.29 v1(60.78,22.48) ; C507.2 v1(28.22,58.09) ; C498.2 v1(30.41,73.13) ; C759.2 156.54,186.94 156.54,186.94 v1(156.54,186.91) ; J2.3 v1(52.98,22.72) ; v1(101.32,31.67) 101.32,31.67 101.88,31.11 J2.158 ; U44.1 34.05,55.81 v1(33.84,55.61) ; R1103.1 59.85,105.38 PC26.2 60.32,106.41 v1(60.47,106.25) ; R1105.1 v1(177.98,74.01) ; PC62.2 v1(32.77,130.33) ; C772.2 v1(57.32,178.3) ; PC52.1 79.57,4.2 v1(79.58,4.2) ; J2.190 v1(111.48,27.68) ; J2.2 v1(52.68,27.65) ; PC31.2 v1(52.21,3.04) ; v1(170.55,75.32) PR10.1 171.38,75.42 PC29.2 ; v1(58,27.63) 58.08,27.7 58.08,29.15 J2.20 ; R1033.1 v1(200.7,123.86) ; U48.1 v1(34.02,52.29) ; v1(65.38,181.06) 65.74,180.7 U98.S ; J2.70 v1(73.08,27.62) ; R1104.1 v1(105.56,132.76) ; R156.1 90.55,95.14 v1(90.55,95.14) ; R205.1 v1(111.95,18.52) ; C505.2 v1(26.58,45.9) ; PR8.2 v1(53.07,110.96) ; v1(32.87,48.7) U45.1 ; R296.1 140.12,154.59 v1(140.12,154.59) ; v1(71,98.76) 71,98.76 71.15,98.62 R55.2 ; U49.1 v1(32.24,67.97) ; R286.1 v1(158.14,140.21) ; C809.2 v1(109.55,130.76) ; R1010.1 v1(162.53,44.68) ; R1118.1 v1(49.58,112.25) ; v1(92.14,98.52) C795.2 91.03,98.52 90.55,98.04 v1(90.04,98.04) ; v1(62.56,180.97) 62.56,180.3 U96.S ; PC76.1 v1(55,12.95) ; C768.2 v1(46.27,186.62) ; U2.BB53 v1(79.57,69.02) ; C616.2 v1(70.43,170.6) ; C508.2 v1(25.76,65.29) ; C903.2 148.3,181.91 v1(148.05,181.66) 147.75,181.95 R1160.2 ; PR26.2 v1(32.77,131.34) ; J2.67 v1(72.18,22.53) ; v1(105.47,172.04) 105.7,172.27 C575.2 ; PR37.2 v1(51.3,5.38) ; R1013.1 161.07,41.47 v1(160.48,40.88) 160.98,40.37 R1008.1 ; R306.1 v1(158.02,147.2) ; v1(149.05,63.58) 149.59,64.12 C329.2 ; PR4.2 95.38,153.76 95.66,153.48 v1(95.66,153.26) ; R24.1 152.71,112.52 v1(153.5,112.52) ; R1239.2 v1(35.26,130.01) ; J2.164 v1(103.68,27.57) ; J2.35 v1(62.58,22.46) ; R1241.1 v1(50.33,2.35) ; U88.3 v1(73.12,175.94) ; C617.2 v1(77.38,170.63) ; C775.2 v1(57.32,180.33) ; J2.38 v1(63.48,27.38) ; C774.2 v1(57.32,179.32) ; C448.2 v1(192.59,143.06) ; v1(69.02,173.83) 69.69,174.5 U86.3 ; R1242.1 v1(128.26,16.86) ; C179.2 v1(18.23,4.11) ; C770.2 v1(46.27,187.64) ; U93.S v1(55.64,185.15) ; J2.184 v1(109.68,27.64) ; U99.S v1(59.72,179.92) ; C140.2 v1(114.58,18.49)
  TOP w0.508: U108.S v1(119.28,157.45) ; v1(103.72,98.83) 103.72,98.83 104,98.54 U5.4 ; R1168.2 166.31,179.09 166.22,178.99 v1(166.22,178.98) ; C934.1 v1(132.21,158.1) ; R1151.2 v1(36.41,93.42) ; v1(171.64,186.81) 171.64,187.71 C588.2 ; v1(105.11,185.79) C678.2 C690.2 ; U104.S v1(101.77,161.01) ; C582.2 81.08,168.7 v1(80.72,169.06) ; v1(154.36,186.89) 154.26,187 C765.2 ; v1(166.67,186.89) 167.08,187.31 C660.2 ; S3.4 v1(170.07,128.66) ; C530.2 v1(160.28,30.95) ; C753.2 v1(160.23,186.91) ; v1(30.05,200.33) v1(30.05,201.09) J35.A77 ; v1(128.38,184.16) 128.22,184.32 C754.2 ; C6.2 v1(151.06,122.94) ; v1(161.38,183.92) 161.38,184.8 C750.2 ; v1(174.57,187.68) R1222.2 R1223.2 ; v1(41.95,169.48) 42.36,169.07 R1251.2 ; J18.B65 v1(133.05,201.03) ; C704.2 86.57,187.36 86.15,186.94 v1(86.15,186.94) ; C499.2 v1(27.18,40.99) ; C842.2 94.77,109.12 94.77,109.73 v1(94.63,109.87) ; C608.2 61.42,181.43 v1(61.85,181) ; C589.2 v1(67.14,186.96) ; v1(107.78,200.3) v1(107.78,201.06) 107.78,202.42 108.05,202.69 J35.B1 ; R46.2 48.34,72.39 48.39,72.34 v1(48.39,71.41) ; v1(163.63,183.75) 163.66,183.77 C744.2 ; J18.B70 v1(128.05,201.03) ; v1(156.38,181.75) 156.22,181.91 R807.2 ; C743.2 147.4,184.2 v1(147.12,183.92) ; C700.2 73.98,184.8 v1(73.98,184.06) ; J35.B31 v1(76.05,201.09) ; C366.2 179.71,93.68 v1(179.71,92.93) ; C529.2 v1(163.55,146.03) ; v1(79.42,178.34) 79.59,178.51 D25.C ; C661.2 v1(93.42,186.95) ; R1297.1 v1(16.37,167.37) ; C24.2 v1(94.01,83.24) 93.68,82.9 R170.2 ; R656.1 v1(174.33,33.59) ; C191.2 v1(159.23,158.99) ; C602.2 63.71,181.47 63.25,181.02 v1(63.25,181.02) ; C574.2 119.46,174.33 v1(120.03,174.9) ; R279.1 v1(150.95,155.91) ; C566.1 136.79,172.63 v1(136.79,172.63) ; R107.2 47.4,84.3 R108.2 46.74,84.34 v1(46.71,84.38) ; v1(138.69,165.87) 138.08,166.47 C908.2 ; v1(20.78,151.71) C553.1 ; R763.2 118.77,170.8 v1(120.02,170.8) ; C706.2 v1(71.71,183.98) ; C543.2 v1(28.03,15.1) ; v1(71.05,200.33) v1(71.05,201.09) J35.B36 ; C798.2 v1(192.52,136.93) ; C557.2 v1(187.62,37.99) ; J18.B75 v1(123.05,201.03) ; v1(65.18,171.29) 65.18,171.29 65.09,171.2 C618.2 ; C438.2 v1(172.65,143.65) ; C647.2 v1(123.78,186.82) ; Q28.E v1(176.35,128.32) ; C696.2 119.01,184.81 118.75,184.55 v1(118.75,183.97) ; R41.2 v1(46.26,81.04) ; U33.4 v1(167.9,85.59) ; C902.2 v1(137.92,167.69) ; v1(81.05,200.33) v1(81.05,201.09) J35.B26 ; R556.1 55.48,145.4 v1(55.48,144.63) ; R810.2 R809.2 ; R809.2 v1(103.93,177.58) ; R809.2 103.25,176.56 R1178.2 v1(103.91,176.56) ; C913.2 169.71,173.41 169.85,173.55 ; C614.2 v1(59.13,180.97) ; v1(190.09,140.63) C799.2 190.02,139.72 189.75,139.72 188.98,138.95 U106.3 ; v1(44.31,116.85) 44.31,116.85 44.64,116.52 R1240.1 C850.2 ; C437.2 v1(175.36,143.57) ; v1(165.68,70.73) 165.15,70.2 R504.2 ; v1(138.05,201.03) J18.B60 ; C781.2 v1(204.62,113.42) ; v1(88,161.14) 88,160.87 88.64,160.22 91.18,160.22 92,161.05 C578.2 ; C500.2 v1(31.17,51.08) ; R518.1 v1(163.34,56.13) ; C742.2 v1(132.67,189.79) ; R586.1 v1(174.2,162.38) ; R1237.1 81.15,1.69 v1(80.97,1.86) ; R1300.1 v1(17.59,151.33) ; J35.B41 v1(66.05,201.09) v1(66.05,200.33) ; R1236.1 v1(72.35,165.8) ; v1(182.91,93) 182.91,93.42 C365.2 ; v1(135.97,186.86) 135.79,187.04 C629.2 ; C712.2 v1(69.42,183.91) ; R510.1 v1(148.32,62.74) ; R25.1 v1(152.02,113.23) ; v1(124.79,186.86) C763.2 ; v1(162.66,186.86) 162.51,187 C747.2 ; C755.2 143.84,183.77 v1(143.73,183.66) ; C493.2 v1(151.03,27.07) ; C558.2 v1(187.63,36.85) ; v1(21.41,155.21) 21.41,154.46 C550.2 ; v1(137.72,186.25) 137.11,185.63 C737.2 ; R1024.1 v1(152.73,52.68) ; v1(62.56,186.86) R849.2 ; U68.4 121.81,168.56 v1(121.29,169.08) ; v1(143.05,201.03) J18.B55 ; U107.S v1(123.83,156.42) ; R848.2 v1(63.71,186.86) ; C247.1 v1(62.28,119.37) ; C667.2 v1(91.14,186.9) ; v1(118.32,186.93) C699.2 ; v1(169.41,186.79) 169.41,186.86 169.37,186.9 R1220.2 ; C751.2 129.37,186.99 v1(129.49,186.86) ; R503.1 v1(165.87,60.02) ; C794.2 43.65,171.67 43.3,171.32 v1(42.74,171.32) ; C225.1 v1(57.72,121.36) ; C914.1 v1(168.22,170.67) ; R315.1 v1(68.02,147.39) ; U95.S 69.42,180.62 69.59,180.79 v1(69.59,181.22) ; v1(181.61,156.77) 181.55,156.83 R582.1 ; C23.2 v1(93.14,85.93) ; U31.4 v1(146.53,67.46) ; C715.2 v1(68.28,186.93) ; U109.S 44.83,169.54 v1(44.61,169.31) ; R1172.2 v1(178.28,183.05) ; R1038.1 v1(128.93,147.75) ; R307.1 v1(157.99,148.22) ; J35.A51 v1(56.05,201.09) v1(56.05,200.33) ; R1266.2 204.18,120.65 v1(204.44,120.4) ; U13.4 v1(152.65,152.71) ; U47.1 v1(35.12,45.2) ; C834.1 v1(41.08,131.8) ; v1(23.17,153.11) 23.28,153.22 C551.1 ; C709.2 v1(70.56,187.05) ; R808.2 v1(32.19,11.7) ; C708.2 101.43,184.35 v1(101.08,184) ; PR21.2 77.41,7.42 v1(77.38,7.45) ; C562.1 v1(23.75,137.59) ; C587.2 v1(65.99,186.9) ; C701.2 v1(87.71,183.99) ; R682.1 v1(136.79,171.6) ; C710.2 84.28,186.8 v1(84.17,186.68) ; v1(99.34,184.04) 99.34,184.53 99.14,184.73 C714.2 ; v1(180.05,201.03) J18.B18 ; C666.2 v1(164.8,186.86) ; R512.1 v1(148.35,59.69) ; C653.2 v1(121.49,186.92) ; C583.2 v1(80.65,175.52) ; C658.2 v1(94.57,186.96) ; C767.2 46.88,184.94 v1(46.85,184.92) ; v1(88.91,187.04) 88.85,187.09 C698.2 ; R557.1 v1(52.27,144.38) ; C548.1 v1(19.64,167.37) ; v1(128.52,152.2) 128.53,152.2 129.17,152.83 U111.S ; C518.2 v1(66.89,161.03) ; R1221.2 168.23,186.92 168.17,186.87 v1(168.17,186.82) ; C643.2 v1(77.42,186.95) ; C143.2 48.82,19.45 v1(49.26,19.02) R212.1 ; C484.2 v1(126.87,49.54) ; U102.G7 v5(186.54,122.87) ; C25.2 94.19,85.84 93.87,85.52 v1(93.87,85.52) ; R1029.2 v1(197.85,112.3) ; L37.1 v1(159.08,26.19) ; v1(149.2,159.93) 148.27,159.93 148.19,159.85 C906.2 ; C42.2 v1(97.43,107.91) ; C544.1 v1(29.05,15.09) ; C769.2 46.34,188.65 v1(46.25,188.57) ; v1(134.99,25.39) 134.85,25.53 R624.2 ; v1(117.17,162.51) 117.04,162.51 116.77,162.78 R1003.1 ; C246.2 v1(62.94,121.5) ; C907.2 161.02,167.09 v1(161.24,166.87) ; v1(131.78,187.04) 131.65,187.17 C745.2 ; C635.2 131.52,185.72 131.75,185.95 v1(131.75,186.39) ; J18.B80 v1(118.05,201.03) ; R792.1 136.19,165.51 136.85,166.17 v1(136.98,166.17) ; v1(104.7,177.38) 104.72,177.35 R753.2 R752.2 ; J18.B45 v1(153.05,201.03) ; v1(50.1,184.56) 50.08,184.58 D20.1 ; R1177.2 v1(99.61,181.19) ; R654.1 v1(23.92,31.22) ; R515.1 v1(159.28,56.05) ; Q24.E v1(176.14,124.97) ; C885.2 v1(80.54,170.83) ; S1.3 179.56,136.2 v1(179.61,136.15) ; R176.2 v1(173.31,117.32) ; C672.2 v1(104.33,188.86) ; R1016.1 v1(153.87,53.51) ; U50.1 v1(32,58.4) ; D10.A v1(190.26,53.88) ; C555.2 v1(21.89,138.06) ; C400.2 v1(57,164.37) ; C717.2 98,187.24 v1(97.63,186.87) ; U46.1 32.49,40.53 v1(32.06,40.1) ; U114.S v1(56.42,168.61) ; C567.1 136.58,163.48 136.77,163.66 v1(136.77,163.67) ; U105.S v1(109.97,160.02) ; PR16.2 119.23,153.8 v1(119.27,153.76) ; R1074.1 v1(82.73,182.19) ; U67.4 110.73,175.55 v1(111.09,175.19) ; R278.1 v1(157.96,150.2) ; R813.2 v1(191.66,12.85) ; v1(105.47,167.02) 105.61,167.16 C577.2 106.1,167.16 C584.2 ; R134.1 v1(173.46,118.34) ; C760.2 125.63,184.5 v1(125.63,184.09) ; C886.1 v1(106.37,162.94) ; v1(151.97,186.86) C639.2 ; v1(154.88,184.04) 155.4,184.56 C762.2 ; C537.2 v1(37.42,93.4) ; v1(24.78,161.77) 24.89,161.88 C540.2 ; J18.B7 193.05,200.95 v1(192.13,200.03) ; v1(127.23,187) 127.08,187.15 C757.2 ; C591.2 v1(95.71,186.9) ; J18.B1 199.05,202.5 198.59,202.03 v1(198.59,201.08) ; R1326.2 144.57,55.37 v1(143.93,56.01) ; R15.1 v1(153.45,115.86) ; R1227.2 v1(160.97,148.79) ; Q26.E v1(176.21,121.58) ; v1(76.47,148.88) R313.1 ; C642.2 v1(150.83,186.86) ; R588.1 v1(163.47,149.07) ; v1(172.05,201.03) J18.B26 ; C519.2 v1(66.92,162.05) ; J18.B9 v1(191.05,200.98) ; C434.2 v1(178.9,167.76) ; v1(120.35,186.72) 120.37,186.74 120.37,187.71 C656.2 ; v1(92.01,93.38) 92.01,92.61 91.83,92.43 R142.1 ; C740.2 140.08,187.35 v1(139.77,187.03) 139.46,187.03 139.07,187.43 C764.2 ; C135.1 v1(108.54,4.52) ; v1(49.56,174.63) C771.2 v1(48.56,173.46) ; C564.1 181.61,171.95 v1(181.7,171.86) ; v1(76.38,184.08) 76.38,184.7 C694.2 ; C901.2 C903.2 ; C509.1 v1(32.15,59.15) ; v1(89.89,183.96) 89.89,184.7 C695.2 ; C846.2 v1(70.35,165.78) ; R1152.1 41.23,99.57 v1(41.74,100.08) ; C681.2 v1(104.28,187.84) ; C367.2 v1(176.12,90.96) ; J35.B16 v1(91.05,201.14) ; v1(134.76,187.07) 134.7,187.13 C632.2 ; C141.2 v1(117.43,19.12) ; C605.2 v1(62.56,180.97) ; C827.2 v1(44.05,122.14) ; R1018.1 v1(154.76,52.68) ; R1235.1 v1(94.77,106.35) ; C486.2 v1(136.1,25.43) ; J1.14 v1(101.04,5.4) ; J35.A71 v1(36.05,201.09) v1(36.05,200.33) ; R218.2 v1(23.61,12.82) ; C693.2 103.54,183.78 103.54,183.34 v1(103.82,183.06) ; C802.2 v1(169.96,133.85) ; U101.1 v1(200.35,115.53) ; C134.1 v1(113.38,4.45) ; Q27.E v1(192.95,133.55) ; C904.2 160.51,173.76 160.89,173.38 v1(160.89,173.38) ; v1(111.08,173.28) 110.9,173.47 U69.2 ; v1(33.05,200.33) v1(33.05,201.09) J35.A74 ; C585.2 92.63,182.81 v1(92.7,182.88) ; C561.2 v1(190.08,56.23) ; C531.1 v1(160.33,29.9) ; R166.2 v1(93.23,90.01) ; v1(148.79,155.91) 148.79,155.91 149.62,156.74 R1226.1 ; R640.2 v1(32.61,43.84) ; v1(142.82,183.93) 142.83,183.94 C734.2 ; R850.2 v1(61.42,186.85) ; R1212.1 v1(184.73,13.69) ; v1(195.57,200.12) 196.05,200.6 J18.B4 ; S3.3 v1(165.91,127.31) ; C703.2 v1(72.85,186.98) ; R213.2 v1(19.17,7.73) ; R852.2 v1(59.13,186.86) ; R1219.2 170.52,187.72 v1(170.52,186.73) ; J18.A8 v1(192.05,200.94) ; C262.2 v1(70.4,148.24) ; D9.A v1(187.58,35.6) ; C504.2 v1(26.35,55.51) ; R587.1 177.37,161.78 v1(177.37,162.38) ; v1(149.69,186.86) C645.2 ; R1110.1 v1(75.4,164.69) ; J1.12 v1(103.04,5.42) ; v1(36.46,58.83) R658.1 ; C716.2 v1(81.99,186.85) ; C580.2 v1(90.16,160.98) ; R811.2 103.5,180.63 v1(103.85,180.98) ; R559.1 v1(52.16,163.4) ; R1171.2 177.44,185.48 178.02,186.06 v1(178.02,186.08) ; C933.2 v1(84.6,2.49) ; C900.2 v1(137.59,174.67) ; C1120.1 v1(92.54,121.62) ; C527.2 v1(163.54,148.06) ; C713.2 v1(83.14,183.93) ; R18.1 v1(153.5,117.01) ; C801.1 v1(163.61,135.16) ; v1(85.5,184.07) 85.42,184.15 C707.2 ; C264.2 v1(75.42,148.12) ; C687.2 v1(103.53,185.63) ; v1(65.38,181.06) 64.85,181.59 C600.2 ; R751.2 C573.1 ; C756.2 v1(157.69,183.91) ; R1303.1 v1(180.44,174.77) ; C664.2 v1(92.28,186.92) ; v1(105.35,173.9) 105.76,174.31 R754.2 ; J18.B40 v1(158.05,201.03) ; C545.1 v1(25.93,31.19) ; C637.2 v1(79.71,186.95) ; C503.2 v1(26.25,50.69) ; U11.2 v1(23.08,8.79) ; C684.2 v1(102.73,186.18) ; C12.2 v1(143.04,110.25) ; v1(173.12,136.72) 172.76,137.08 S1.4 ; C335.2 v1(136.19,61.69) ; C711.2 100.16,187.54 100.79,186.91 v1(100.98,186.91) ; R287.1 v1(149.81,155.89) ; v1(47.07,73.91) 47.57,73.4 R45.2 ; C501.2 v1(26.49,56.88) ; R845.2 v1(64.85,186.86) ; R1004.1 v1(123.16,149.25) ; U58.3 v1(166.79,135.04) ; v1(48.05,200.33) v1(48.05,201.09) J35.A59 ; v1(144.97,183.93) 144.97,184.43 145.11,184.57 C749.2 ; C748.2 v1(130.51,184.01) ; U36.4 v1(72.81,151.67) ; C560.2 v1(190.07,55.08) ; v1(41.05,200.33) v1(41.05,201.09) J35.A66 ; J35.A44 v1(63.05,201.09) v1(63.05,200.33) ; v1(60.78,181.01) 60.28,181.51 C611.2 ; v1(165.94,186.86) C663.2 ; U102.F6 v5(187.54,121.87) ; U110.S v1(127.33,158.68) ; C650.2 v1(122.63,186.93) ; J35.B21 v1(86.05,201.23) ; R641.2 v1(31.14,47.99) ; v1(148.05,201.03) J18.B50 ; C334.2 v1(109.31,4.45) ; R40.2 v1(46.51,79.89) ; R1037.1 v1(187.59,131.75) ; C1121.2 v1(92.54,118.78) ; C532.1 v1(169.16,27.67) ; C390.2 v1(68.2,163.16) ; R308.1 v1(158.05,146.21) ; R1153.1 v1(30.81,97.97) ; J35.A4 v1(105.05,200.91) ; C634.2 v1(80.85,186.85) ; C705.2 v1(107.43,187.82) ; R1228.2 v1(156.25,134.19) ; C797.1 v1(184.32,137.35) ; C181.2 v1(20.71,11.21) ; R1270.2 203.06,125.48 202.35,126.19 v1(202.1,126.19) R1269.2 ; U92.S v1(57.54,171.5) ; R505.1 v1(165.65,69.06) ; C180.2 v1(19.72,8.78) ; C263.2 v1(75.42,149.14) ; C13.2 v1(139.67,110.93) ; C491.2 v1(149.76,27.01) ; C565.2 v1(167.87,138.88) ; C399.2 v1(54.3,164.45) ; v1(163.05,201.03) J18.B35 ; C593.2 v1(96.85,186.92) ; C528.2 v1(163.54,147.04) ; C887.1 v1(127.29,152.56) ; C697.2 v1(75.14,186.99) ; C640.2 v1(78.57,186.91) ; R1154.1 v1(30.84,100.04) ; J35.B9 v1(100.05,200.73) ; R558.1 v1(66.82,159) ; R1231.1 84.28,100.49 v1(84.12,100.65) ; R589.1 v1(177.5,144.7) ; C517.2 v1(66.88,160.01) ; R1028.2 v1(204.52,114.56) ; C586.2 v1(94.8,182.81) ; v1(168.05,201.03) J18.B30 ; U134.4 v1(33.86,104.21) ; R851.2 v1(60.28,186.86) ; C621.2 v1(59.84,170.82)
  IN2 w0.254: v1(43.87,141.75) 43.87,141.76 ; 43.87,141.76 48.41,146.3 v1(48.87,146.3) 49.29,146.72 50.36,146.72 50.91,147.27 51.79,147.27 53.84,149.33 53.84,149.53 54.14,149.82 54.34,149.82 54.35,149.84 58.3,149.84 58.91,149.23 66.18,149.23 v1(68.02,147.39) 68.56,146.85 68.58,146.83 v1(68.79,146.83) 71.83,146.83 75.6,143.06 75.6,142.1 75.37,141.87 v5(75.37,141.26) v5(75.37,140.46) 74.57,140.46 74.07,140.95 73.62,140.95 70.76,143.82 v5(70.76,143.84) 70.08,144.51 67.53,144.51 v1(67.05,145) 61.86,145 61.07,145.78 60.09,145.78 v1(59.95,145.64) 59.49,146.1 56.89,146.1 56.29,145.5 56.16,145.5 55.9,145.24 53.13,145.24 v1(52.27,144.38) 52.24,144.35 50.45,144.35 v1(45.8,139.7) 44.95,138.84 31.93,138.84 v1(30.38,137.29) 29.02,135.93 25.47,135.93 v1(21.68,132.14) v1(21.68,115.07) 21.68,97.98 v1(26.67,92.99) 32.66,86.99 32.66,79.43 v1(35.71,76.39) 35.71,60.85 36.13,60.42 36.13,59.15 36.46,58.83 v1(36.46,58.83) 36.46,58.22 36.3,58.06 36.29,58.06 v1(33.84,55.61) 33.84,55.01 33.26,54.43 33.26,51.55 32.87,51.16 v1(32.87,48.7) 32.05,47.88 32.05,44.41 v1(32.61,43.84) 32.05,43.28 32.05,41.78 31.3,41.03 29.63,41.03 29.33,41.33 29.33,41.75 29.49,41.91 29.49,42.59 v1(29.5,42.59) 29.5,43.71 28.43,44.77 28.43,55.26 v1(30.36,57.19) 30.79,57.19 v1(32,58.4) 32,58.4 32,59 32.15,59.15 v1(32.15,59.15) 32.7,59.69 32.7,64.44 33.61,65.34 33.61,74.82 v1(32.95,75.47) 28.4,80.02 28.4,87.67 v1(24.54,91.53) 19.21,96.86 v1(19.21,111.44) v1(19.21,119.91) 19.21,134.15 21.24,136.18 21.24,136.65 21.89,137.3 v1(21.89,138.06) 22.94,139.11 27.42,139.11 v1(28.86,140.55) 29.25,140.93 43.04,140.93 43.87,141.76
  BOTTOM w0.254: C655.2 88.09,187.39 87.77,187.07 v1(87.77,187.07) ; R120.2 63.78,84.06 v1(63.06,84.78) ; U66.12 156.7,177.1 156.36,177.44 v1(156.36,178.4) ; PJ11.2 84.43,63.55 v1(84.08,63.89) ; U73.4 101.15,166.3 v1(101.37,166.08) ; U62.12 v1(93.93,177.83)
  BOTTOM w0.305: R98.2 71.71,84.47 71.37,84.13 70.95,84.13 70.83,84.24 v1(70.64,84.24) ; U59.25 v1(178.72,173.55)
  BOTTOM w0.33: U145.3 144.18,56.25 v1(143.93,56.01) ; U146.3 140.29,53.46 139.71,52.88 136.91,52.88 136.76,52.73 v1(136.76,52.71) ; U65.12 110.83,180.14 110.93,180.24 v1(110.93,180.67)
  BOTTOM w0.356: v5(75.37,140.46) 75.37,140.46 75.18,140.66 74.58,140.66 C294.2 ; v1(125.55,181.52) 125.56,181.51 125.56,180.78 U64.12 ; v1(74.42,131.36) 73.98,130.92 C268.2 73.75,130.92 C270.2 ; U63.12 v1(69,172.74)
  BOTTOM w0.381: C129.2 67.44,75.44 C121.2 ; C231.2 56.81,137.02 v5(57.27,136.56) ; v5(59,129.19) 58.93,129.12 C232.2 ; v1(85.5,184.07) 85.34,184.23 C677.2 ; C76.2 73.91,85.88 74.23,86.21 74.23,86.46 v1(74.44,86.67) ; v5(59.38,131.71) 58.99,132.09 C223.1 ; R294.2 68.96,125.73 v1(68.98,125.71) ; C788.2 189.26,121.59 v5(189.54,121.87) ; R92.1 81.91,98.22 v1(82.31,97.82) ; v1(69.96,89.62) 69.89,89.55 R100.2 ; v1(60.93,89.6) 61.36,89.18 R99.2 ; v1(78.82,78.65) 78.86,78.61 R101.2 ; v5(187.54,121.87) 187.93,121.48 C789.2 ; C101.2 75.67,72.24 v1(75.63,72.2) ; R102.2 62.01,82.93 61.39,82.93 v1(61.13,82.67) ; v1(153.04,186.84) 153.11,186.91 C741.2 ; C641.2 v1(130.51,186.94) ; v1(59.51,89.6) 60.24,88.87 R97.2 ; R260.2 58.15,134.08 v5(58.07,134.16) ; C728.2 v1(143.97,186.86) ; C235.2 59.06,130.23 v5(59.4,130.57) ; v5(69.77,129.26) 69.61,129.26 69.06,129.8 C288.2 69.09,130.04 R257.1
  BOTTOM w0.406: C122.2 74.2,72.37 v1(74.03,72.2)
  BOTTOM w0.457: v1(73.08,27.62) 73.55,28.09 R204.1 ; R208.1 98.13,31.31 98.41,31.6 v1(99.43,31.6) ; v1(150.37,152.53) 150.27,152.43 C874.2 ; C30.1 v1(50.66,95.51) ; C862.2 137.4,147.07 v1(136.66,147.07) ; v5(189.54,118.87) 188.99,119.42 C791.2 ; v1(72.43,76.2) 72.28,76.35 C52.2 ; v5(75.37,141.26) 75.37,141.26 75.43,141.21 C242.2 ; 76.14,66.27 76.79,66.27 v1(76.86,66.2) ; 76.14,66.27 C119.2 ; 76.14,66.27 76.14,65.84 76.56,65.41 76.56,64.81 C14.2 R31.2 ; R81.1 66.05,97.5 v1(66.39,97.83) ; v1(83.74,122.89) 83.74,123.22 82.9,124.06 C276.2 ; v1(131.46,164.77) 131.85,164.77 132.09,165.01 R1225.2 ; U133.3 114.44,168.8 v1(113.61,167.98) ; R96.1 87.5,94.87 v1(87.78,95.14) ; C866.2 152.17,144.36 v1(152.12,144.41) ; v1(68.28,99.23) 68.09,99.04 R54.2 ; C873.2 C930.2 145.93,135.34 v1(145.93,134.5) ; v1(139.07,137.98) 138.91,138.14 C897.2 ; C74.2 75.98,87.15 v1(75.65,87.47) ; v1(133.67,167.49) 133.07,168.1 R1244.1 ; R1188.2 v1(146.12,37.38) ; v1(99.14,74.05) 99.5,73.69 R161.1 R162.1 ; v1(77.93,89.99) 78.16,90.22 R155.1 ; v1(146.81,137.04) 146.79,137.01 C892.2 ; C864.2 C869.2 v1(146,152.48) ; C895.2 v1(143.97,137.93) ; v1(142.17,150.07) 142.15,150.09 C871.2 ; C861.2 147.78,137.06 v1(147.83,137.12) ; C236.2 60.03,140.71 60.03,141.3 v5(59.88,141.45) ; v1(75.7,97.73) 76.21,97.22 R88.1 ; C174.2 95.79,30.55 96.3,31.06 v1(96.48,31.06) ; C205.1 67.62,133.42 67.04,134.01 v5(67.04,134.34) ; C881.2 C891.2 v1(148.29,152.51) ; v1(88.6,130.51) R258.1 88.61,129.79 R1230.1 ; v1(151.32,34.4) R1186.2 R1184.2 v1(151.23,35.41) ; C27.1 v1(58.78,95.63) ; v1(154.54,138.18) 154.49,138.23 C890.2 153.67,139.2 C888.2 ; C896.2 v1(136.63,144.23) ; C199.2 v1(142.55,141.46) ; v1(141.66,145.12) 141.54,145.23 C931.2 C932.2 ; C863.2 151.99,149.2 v1(151.97,149.18) ; v1(112.74,168.03) 111.33,168.03 111.09,168.27 C766.2 ; C576.2 116.29,165.97 116.4,165.85 v1(116.42,165.85) ; C569.1 59.77,179.87 v1(59.72,179.92) ; v1(63.82,97.86) 63.82,97.86 64.02,97.66 R50.2 R79.1 ; 68.98,67.83 69.13,67.98 69.19,67.98 69.54,68.33 C94.2 ; C879.2 149.58,136.99 v1(149.51,137.06) ; v1(105.35,173.9) 106.08,173.17 R719.2 ; C875.2 v1(144.02,152.51) ; v1(82.73,62.05) 83.17,62.48 C116.2 ; C865.2 139.52,136.84 v1(139.91,137.22) ; C331.2 v1(145.01,152.48) ; C905.2 150.4,164.34 v1(150.56,164.49) ; R211.1 61.09,28.22 v1(61.68,27.63) ; R1180.2 146.26,38.39 v1(145.98,38.67) 146.72,39.41 R1191.2 ; v1(143.67,34.97) R1209.2 142.95,36.11 R1206.2 143.53,36.12 v1(143.73,35.92) ; v1(136.67,144.98) 136.91,145.22 C880.2 ; v1(152.1,142.55) 152.98,142.55 C889.2 ; R174.1 R168.1 100.26,72.31 99.78,72.31 v1(99.74,72.35) ; v1(82.34,119.85) 82.34,120.03 81.73,120.64 R253.1 ; R1210.2 v1(139.57,37.26) ; v1(136.48,143.11) 136.58,143.01 C894.2 ; C28.1 v1(48.62,95.51) ; R1192.2 146.19,41.44 v1(145.86,41.11) ; C867.2 v1(150.57,139.18) ; v1(101.31,76.66) 101.29,76.68 R141.1 ; R1098.2 v1(93.05,136.16) ; v1(150.24,134.65) 150.57,134.98 C870.2 ; v1(127.94,164.96) 128.6,165.62 R1245.1 ; v1(102.1,75.72) R167.1 ; v1(125.57,162.25) 125.57,162.26 125.57,162.25 C590.1 ; v1(80.52,61.78) 80.25,61.78 80.18,61.72 79.34,61.72 78.61,62.44 C114.2 78.61,62.46 C120.2 ; R210.1 64.83,28.15 v1(65.42,27.55) ; C115.2 77.61,70.01 77.03,69.43 77,69.43 v1(76.85,69.28) ; v5(64.88,134.34) 64.88,133.63 65.28,132.98 C204.2 ; C31.1 v1(56.75,95.65) ; C330.2 v1(154.49,137.24) ; R173.1 101.69,78.77 v1(101.99,78.47) ; C568.1 R687.2 ; C882.2 136.1,146.21 v1(135.83,146.47) ; C868.2 v1(151.26,152.51) ; C893.2 C876.2 142.83,135.24 142.82,135.23 142.82,134.36 v1(142.87,134.31) ; R1182.2 v1(151.11,36.43) ; R203.2 C142.2 78.81,28.99 78.13,29.68 C172.2 ; C26.1 v1(52.69,95.46) ; U71.4 v1(112.86,167.15) ; C878.2 139,141.16 v1(139.04,141.2) ; R256.2 v1(87.45,130.67) ; C29.1 v1(54.72,95.51)
  BOTTOM w0.508: C200.2 135.9,150.94 v1(135.32,151.51) ; v1(164.8,186.86) C654.2 ; v1(136.79,172.63) 136.54,172.38 C570.1 ; v1(122.63,186.93) 122.76,187.05 C733.2 ; v1(154.05,201.03) J18.A44 ; C736.2 C607.2 v1(119.46,183.85) ; R1306.1 169.76,177.14 v1(169.87,177.02) ; C649.2 v1(90.25,187.06) ; C449.2 180.06,149.54 v1(180.03,149.58) ; v1(139.05,201.03) J18.A59 ; C724.2 125.17,184.55 v1(125.63,184.09) ; R851.2 v1(60.28,186.86) ; C233.2 59.18,136.88 v5(58.87,136.56) ; v1(146.26,186.86) C722.2 ; J35.A24 v1(83.05,201.09) ; R1133.1 148.67,45.74 148,45.07 v1(147.54,45.07) ; C669.2 v1(170.51,183.77) ; v1(68.05,200.33) v1(68.05,201.09) J35.A39 ; C153.2 C144.2 86.64,33.07 v1(86.68,33.11) ; v1(140.49,152.51) 140.34,152.36 C872.2 ; C595.2 168.23,186.87 v1(168.17,186.82) ; J18.A8 v1(192.05,200.94) ; J35.A7 v1(102.05,200.73) ; v1(114.91,67.95) 115.1,68.14 115.94,68.14 R227.2 C184.1 ; v1(134.05,201.03) J18.A64 ; v1(181.05,201.03) J18.A17 ; C613.2 C610.2 v1(178.82,187) ; R554.1 49.56,147.9 v1(49.09,148.37) ; C587.2 v1(65.99,186.9) ; C481.2 154.01,46.5 154.01,48.52 v1(153.96,48.57) ; v1(144.07,161.2) 144.07,161.2 144.31,160.96 U140.S ; C571.1 119.02,172.5 v1(119.35,172.17) ; v1(124.79,186.86) 125.05,187.12 C727.2 ; v1(198.59,201.08) v1(198.59,200.32) ; v1(198.59,201.08) 199.05,201.54 J18.A1 ; v1(198.59,201.08) 198.05,201.62 J18.A2 ; C182.1 122.64,61.87 v1(124.45,60.06) ; R750.2 v1(167.14,171.49) ; v1(195.37,201.02) 195.05,201.34 J18.A5 ; J35.A71 v1(36.05,201.09) v1(36.05,200.33) ; J35.A66 v1(41.05,201.09) v1(41.05,200.33) ; v1(56.05,200.33) v1(56.05,201.09) J35.A51 ; C705.2 v1(107.43,187.82) ; C283.2 87.66,124.17 v1(88.54,124.17) ; C451.2 180.86,151.5 v1(180.99,151.37) ; C677.2 85.87,184.75 C671.2 ; v1(144.05,201.03) J18.A54 ; v1(62.56,186.86) R849.2 ; v1(121.47,173.87) 121.82,173.52 R718.2 ; v1(120.35,186.72) 120.48,186.85 C739.2 ; v1(88.91,187.04) 89.11,187.23 C652.2 ; v1(107.88,30.76) 107.37,30.25 R206.1 106.3,29.93 105.54,30.69 v1(105.39,30.69) ; C568.1 v1(104.02,168.94) ; v1(84.17,186.68) 84.17,186.98 84.03,187.12 C680.2 ; C732.2 v1(156.54,183.92) ; C257.2 76.83,143.8 v5(76.97,143.66) ; v1(88,161.14) 88.57,161.72 90.31,161.72 90.65,162.06 C579.1 ; J35.A44 v1(63.05,201.09) v1(63.05,200.33) ; v1(165.94,186.86) 165.94,187.1 C651.2 ; C738.2 154.37,184.55 v1(154.88,184.04) ; C606.2 v1(62.56,180.97) ; v1(149.05,201.03) J18.A49 ; C170.2 80.52,25.21 80.03,24.72 v1(80.03,22.71) ; C397.2 51.18,149.41 v1(50.62,149.98) ; v1(73.05,200.33) v1(73.05,201.09) J35.A34 ; C917.1 v1(168.81,175.02) ; C697.2 v1(75.14,186.99) ; C157.2 91.73,28.92 95.5,28.92 95.79,29.21 C174.2 ; C638.2 131.52,187.29 v1(131.78,187.04) ; C718.2 127.46,184.55 127.85,184.16 v1(128.38,184.16) ; C458.2 v1(180.91,156.09) ; C729.2 v1(157.69,186.86) ; v1(89.55,165.83) 89.58,165.81 89.58,165.15 90.35,164.38 R783.1 ; C716.2 v1(81.99,186.85) ; C715.2 v1(68.28,186.93) ; v1(91.14,186.9) 91.27,187.03 C646.2 ; v1(48.05,200.33) v1(48.05,201.09) J35.A59 ; v1(80.04,124.87) 80.38,124.53 C277.2 C278.2 ; v1(106.12,190.28) 105.84,190 C702.2 ; C725.2 144.97,184.41 v1(144.97,183.93) ; C643.2 v1(77.42,186.95) ; J18.A69 v1(129.05,201.03) ; C230.2 51.04,128.72 v5(51.23,128.91) ; v1(166.67,186.89) 167.08,187.31 C648.2 ; C712.2 v1(69.42,183.91) ; C644.2 v1(129.49,186.86) ; C706.2 v1(71.71,183.98) ; v1(125.52,167.01) 125.55,166.98 R1243.1 ; v1(59.73,178.95) 59.99,178.69 R688.2 ; v1(147.12,183.92) 147.4,184.2 C719.2 ; v1(68.98,125.71) 69.93,125.71 C269.2 ; R852.2 v1(59.13,186.86) ; C597.2 169.36,187.46 169.36,186.83 v1(169.41,186.79) ; v1(142.82,183.93) 142.83,183.94 C731.2 ; C443.2 v1(178.31,159.27) ; C9.2 141.18,124.65 v1(141.84,125.32) ; v1(90.65,87.41) 91.1,86.96 C33.2 ; v1(30.05,200.33) v1(30.05,201.09) J35.A77 ; C683.2 v1(83.14,183.93) ; C599.2 v1(143.26,58.44) ; C194.2 R203.2 ; C624.2 v1(151.97,186.86) ; C284.2 C285.2 89.83,124.95 v1(89.17,124.3) ; C612.2 60.28,181.51 v1(60.78,181.01) ; v1(124.05,201.03) J18.A74 ; C681.2 v1(104.28,187.84) ; R1328.2 v1(138.8,59.84) ; C665.2 105.87,184.19 105.47,183.8 v1(105.13,183.8) ; v1(150.83,186.86) C627.2 ; C657.2 v1(163.66,186.86) ; v1(61.85,181) 61.42,181.43 C609.2 ; C594.2 v1(197.33,187.3) C596.2 ; J35.A14 v1(93.05,201.09) ; C709.2 v1(70.56,187.05) ; v1(119.05,201.03) J18.A79 ; R1224.2 170.51,186.73 v1(170.52,186.73) ; v1(178.72,173.55) 178.85,173.68 C918.2 ; C670.2 v1(67.14,186.96) ; C723.2 v1(161.37,186.86) ; v1(127.23,187) 127.23,187.03 127.33,187.13 C721.2 ; C406.2 v1(48.79,151.93) ; C674.2 86.06,187.03 v1(86.15,186.94) ; C601.2 64.85,181.59 v1(65.38,181.06) ; v1(169.05,201.03) J18.A29 ; J35.A29 v1(78.05,201.09) ; C640.2 v1(78.57,186.91) ; C598.2 v1(150.39,54.89) ; R848.2 v1(63.71,186.86) ; v1(61.42,186.85) R850.2 ; v1(148.61,186.86) 148.54,186.92 C633.2 ; v1(181.61,156.77) 181.26,157.11 C457.2 ; R1137.1 147.61,45.92 v1(147.62,45.91) ; v1(155.4,186.91) C735.2 ; v1(64.85,186.86) R845.2 ; C592.2 v1(191.5,188.07) ; C628.2 v1(76.28,187.02) ; v1(51.43,142.53) 51.48,142.58 C229.2 ; v1(105.05,200.15) v1(105.05,200.91) J35.A4 ; C258.2 76.83,142.71 v5(76.97,142.86) ; C637.2 v1(79.71,186.95) ; v1(67.98,22.46) 68.32,22.13 R209.1 ; C662.2 v1(117.17,186.86) ; v1(159.05,201.03) J18.A39 ; v1(33.05,200.33) v1(33.05,201.09) J35.A74 ; C169.2 v1(85.08,26.95) ; v1(173.05,201.03) J18.A25 ; J35.A19 v1(88.05,201.09) ; C630.2 v1(149.69,186.86) ; R552.1 49.15,146.58 v1(48.87,146.3) ; C730.2 v1(122.89,184.08) ; v1(73.98,184.06) 73.98,184.8 C700.2 ; v1(47.89,151.81) 48.8,150.91 C426.2 ; R293.2 v1(86.04,148.88) ; v1(164.05,201.03) J18.A34 ; C689.2 v1(80.85,186.85) ; C603.2 63.71,181.47 63.25,181.02 v1(63.25,181.02) ; R1174.2 v1(176.64,181.25) ; C699.2 v1(118.32,186.93) ; J35.A1 108.05,202.71 107.78,202.44 v1(107.78,201.06) v1(107.78,200.3) ; C726.2 v1(158.83,183.93) ; C919.1 v1(181.7,171.86) ; C703.2 v1(72.85,186.98) ; C572.1 v1(160.6,168.61) ; v1(167.05,201.03) J18.A31 ; C615.2 v1(59.13,180.97) ; C450.2 v1(180.84,152.9) ; C720.2 v1(162.51,183.84)
  vias: v1(2.92,185.77) v1(23.3,110.17) v1(23.3,105.39) v1(23.57,109.33) v1(23.57,5.48) v1(23.6,104.77) v1(24.07,125.64) v1(24.08,110.17) v1(24.2,105.32) v1(24.64,124.92) v1(24.64,124.28) v1(24.64,122.17) v1(24.64,121.53) v1(24.64,109.28) v1(24.66,104.77) v1(24.82,127.97) v1(24.82,126.48) v1(25.08,110.16) v1(25.28,105.38) v1(25.58,128.63) v1(25.58,127.97) v1(25.58,126.48) v1(25.65,129.36) v1(25.97,4.31) v1(27.15,6.58) v1(27.53,130.84) v1(27.53,129.72) v1(27.57,118.19) v1(28.16,160.2) v1(28.11,157.93) v1(28.2,146.31) v1(28.27,142.29) v1(28.3,118.29) v1(28.66,130.84) v1(28.65,129.71) v1(28.77,143.87) v1(28.79,146.84) v1(28.81,146.02) v1(28.84,142.79) v1(28.99,118.46) v1(29.12,138.86) v1(29.75,147.96) v1(30.55,39.2) v1(30.62,155.24) v1(30.61,152.81) v1(31.89,54.52) v1(32.43,138.25) v1(32.43,137.42) v1(32.51,175.18) v1(32.57,27.14) v1(32.66,66.38) v1(32.76,136.24) v1(32.73,135.43) v1(32.88,18.6) v1(33.08,181.88) v1(33.23,125.6) v1(33.23,124.96) v1(33.23,124.33) v1(33.87,125.6) v1(33.87,124.96) v1(33.87,124.33) v1(34.06,127.51) v1(34.53,125.6) v1(34.53,124.96) v1(34.53,124.33) v1(36.88,16.89) v1(37.03,172.86) v1(37.03,107.16) v1(37.04,106.38) v1(37.06,30.82) v1(37.49,186.23) v1(37.84,113.34) v1(37.85,112.53) v1(37.85,110.76) v1(37.85,110.06) v1(37.85,108.9) v1(37.85,108.09) v1(39.78,164.84) v1(39.78,163.75) v1(39.82,157.84) v1(39.85,156.65) v1(39.88,155.42) v1(40.07,127.56) v1(40.08,126.92) v1(40.09,126.21) v1(40.58,18.26) v1(40.64,136.32) v1(40.63,135.37) v1(40.82,127.53) v1(40.81,126.89) v1(40.83,126.21) v1(40.97,137.45) v1(40.99,138.27) v1(41.04,106.15) v1(41.04,105.39) v1(41.43,181.93) v1(41.4,26.52) v1(42.01,115.59) v1(42,114.8) v1(42.19,119.89) v1(42.59,188.52) v1(42.6,187.68) v1(42.86,119.9) v1(42.79,116.86) v1(43.21,101.09) v1(43.33,105.14) v1(43.32,72.91) v1(43.41,188.48) v1(43.54,116.78) v1(43.84,101.09) v1(43.97,105.14) v1(44.18,65.07) v1(44.15,63.54) v1(44.48,101.09) v1(44.6,105.14) v1(44.95,72.93) v1(44.97,71.09) v1(45.13,68.37) v1(45.14,34.08) v1(45.14,33.12) v1(45.25,125.45) v1(46,125.45) v1(46.18,173.48) v1(46.47,33.13) v1(46.49,34.08) v1(47.43,131.23) v1(47.44,130.48) v1(49.05,160.08) v1(49.41,61.52) v1(49.56,159.4) v1(49.52,63.25) v1(49.5,10.92) v1(49.49,9.67) v1(50.27,97.23) v1(50.73,10.92) v1(50.75,9.68) v1(50.84,13.49) v1(52.31,72.53) v1(52.56,83.32) v1(53.09,102.43) v1(53.2,83.3) v1(53.18,82.39) v1(53.21,32.85) v1(53.72,3.31) v1(54.15,157.34) v1(54.15,155.74) v1(54.15,153.93) v1(54.15,152.49) v1(54.12,25.1) v1(54.36,3.31) v1(54.69,96.66) v1(55.03,142.84) v1(55.33,113.89) v1(55.54,166.54) v1(55.51,165.61) v1(55.55,3.16) v1(55.64,1.89) v1(55.71,26.7) v1(55.78,13.74) v1(55.78,13.11) v1(55.78,12.47) v1(55.86,157.36) v1(55.96,113.89) v1(56.08,152.51) v1(56.27,1.89) v1(56.36,97.38) v1(56.41,13.74) v1(56.41,13.11) v1(56.41,12.47) v1(56.56,98.95) v1(56.55,3.15) v1(57.04,24.8) v1(57.05,13.74) v1(57.05,13.11) v1(57.05,12.47) v1(57.3,110.57) v1(57.3,109.38) v1(57.41,157.34) v1(57.56,1.87) v1(57.63,152.51) v1(57.82,74.94) v1(57.88,59.26) v1(58.19,1.87) v1(58.46,107.7) v1(58.46,107.06) v1(58.48,110.57) v1(58.48,109.39) v1(58.81,24.18) v1(59.01,157.34) v1(59.03,155.69) v1(59.03,154.11) v1(59.01,152.54) v1(59.09,107.7) v1(59.09,107.06) v1(59.29,25.43) v1(59.99,59.13) v1(60.09,61.74) v1(60.1,1.87) v1(60.73,1.87) v1(60.82,112.99) v1(61.37,99.13) v1(61.44,178.94) v1(61.39,100.69) v1(61.82,31.8) v1(61.82,24.27) v1(62.84,114.64) v1(62.84,113.98) v1(62.96,100.69) v1(62.94,99.1) v1(63.45,168.56) v1(64.43,24.98) v1(64.61,153.03) v1(64.63,48) v1(64.62,46.86) v1(64.63,45.65) v1(64.65,44.5) v1(64.73,154.67) v1(65.04,127.22) v1(65.19,81.99) v1(65.63,64.95) v1(65.72,127.48) v1(65.85,156.9) v1(65.82,155.17) v1(65.89,59.53) v1(66.03,81.05) v1(66.03,77) v1(66.03,76.2) v1(66.03,74.6) v1(66.03,73.8) v1(66.03,71.4) v1(66.19,124.17) v1(66.39,118.38) v1(66.53,23.82) v1(66.66,82.71) v1(66.67,81.97) v1(66.84,64.22) v1(66.95,124.17) v1(66.92,69.63) v1(67.16,26.19) v1(67.18,83.11) v1(67.18,82.35) v1(67.44,66.98) v1(67.44,66.22) v1(67.62,150.65) v1(67.63,78.6) v1(67.73,153.62) v1(67.85,64.18) v1(68.32,143.1) v1(68.32,16.84) v1(68.43,79.4) v1(68.43,78.6) v1(68.43,77) v1(68.43,73.8) v1(68.42,5.39) v1(68.82,142.61) v1(69.13,65.22) v1(69.23,77) v1(69.23,76.2) v1(69.23,73) v1(69.23,71.4) v1(69.33,16.84) v1(69.43,5.39) v1(69.51,117.02) v1(70.35,16.84) v1(70.45,5.39) v1(70.83,73) v1(70.94,26.86) v1(71.37,16.84) v1(71.77,24.61) v1(72.07,23.86) v1(72.43,73.8) v1(72.43,72.2) v1(72.38,16.84) v1(72.87,25.63) v1(73.14,111.77) v1(73.22,69.78) v1(73.4,16.84) v1(73.5,5.39) v1(73.73,146.44) v1(73.94,26.18) v1(74.06,110.64) v1(74.06,109.98) v1(74.06,108.61) v1(74.06,107.95) v1(74.06,106.58) v1(74.06,105.92) v1(74.03,74.6) v1(74.04,70.61) v1(74.41,16.84) v1(74.51,5.39) v1(74.68,158.59) v1(74.68,157.93) v1(74.68,156.56) v1(74.68,155.9) v1(74.68,154.53) v1(74.68,153.87) v1(74.83,77) v1(74.99,26.88) v1(75.44,153.04) v1(75.43,16.84) v1(75.53,5.39) v1(75.63,75.4) v1(75.63,73.8) v1(76.45,74.62) v1(76.5,16.06) v1(76.63,75.88) v1(77.2,23.9) v1(77.32,71.02) v1(77.83,31.43) v1(78.81,73.21) v1(79.14,24.62) v1(79.19,71.22) v1(79.55,26.05) v1(79.56,10.36) v1(80.2,10.36) v1(80.56,16.04) v1(81.07,65.2) v1(81.54,7.04) v1(81.54,5.85) v1(81.6,16.04) v1(82.05,86.07) v1(82.27,75.14) v1(82.22,67.23) v1(82.39,22.43) v1(82.57,89.58) v1(82.61,16.04) v1(82.72,7.04) v1(82.72,5.86) v1(82.7,4.17) v1(82.7,3.53) v1(82.88,88.12) v1(82.9,26.64) v1(83.33,4.17) v1(83.33,3.53) v1(83.46,85.87) v1(83.67,16.04) v1(83.71,2.6) v1(83.87,89.58) v1(83.95,87.9) v1(84.25,120.1) v1(84.66,61.96) v1(84.74,22.52) v1(84.86,89.58) v1(84.86,24.31) v1(85.05,9.43) v1(85.74,89.53) v1(85.96,150.64) v1(85.96,149.98) v1(85.9,16.04) v1(86.03,118.57) v1(86.57,89.52) v1(86.76,87.27) v1(86.87,88.46) v1(86.91,25.55) v1(86.94,16.04) v1(87.06,11.18) v1(87.04,10.48) v1(87.09,24.69) v1(87.1,13.44) v1(87.12,12.78) v1(87.24,22.47) v1(87.95,16.04) v1(88.01,151.78) v1(88.26,63.75) v1(88.55,119.6) v1(88.66,178.27) v1(88.66,177.64) v1(88.83,24.18) v1(88.96,22.62) v1(89.01,16.04) v1(89.18,97.88) v1(89.66,157.65) v1(89.66,157.02) v1(89.81,121.19) v1(89.93,16.04) v1(90.26,155.33) v1(90.26,154.15) v1(90.29,157.65) v1(90.29,157.02) v1(90.55,81.77) v1(90.9,16.04) v1(91.13,63.56) v1(91.19,81.77) v1(91.33,22.56) v1(91.44,155.34) v1(91.45,154.15) v1(91.56,141.37) v1(91.55,140.65) v1(91.57,139.91) v1(91.62,144.96) v1(91.6,142.14) v1(91.76,143.76) v1(91.82,81.77) v1(91.95,16.04) v1(92,23.58) v1(92.15,65.7) v1(92.47,144.68) v1(92.46,81.77) v1(92.5,145.52) v1(92.94,16.04) v1(93.09,81.77) v1(93.73,81.77) v1(93.68,22.48) v1(94.07,23.96) v1(94,16.04) v1(94.11,141.95) v1(94.11,141.32) v1(94.11,140.68) v1(94.93,16.04) v1(95.33,25.67) v1(96.54,84.6) v1(97.08,94.64) v1(97.08,93.42) v1(97.46,25.21) v1(97.46,8.08) v1(97.77,141.89) v1(97.77,141.25) v1(97.77,140.62) v1(97.71,94.66) v1(97.71,93.41) v1(98.18,3.02) v1(98.18,2.36) v1(98.24,155.99) v1(98.24,155.33) v1(98.2,6.82) v1(98.2,6.15) v1(98.26,4.92) v1(98.26,4.26) v1(98.29,157.81) v1(98.29,157.15) v1(98.29,153.91) v1(98.29,153.27) v1(99.09,152.2) v1(99.6,25.84) v1(101.28,34.13) v1(101.39,26.77) v1(102.72,84.57) v1(102.74,83.62) v1(102.81,78.13) v1(103.25,84.12) v1(103.32,80.54) v1(104.06,25.06) v1(104.15,80.51) v1(104.83,138.71) v1(105.1,135.31) v1(105.1,134.68) v1(105.1,134.04) v1(105.68,138.72) v1(105.83,105.56) v1(106.68,24.98) v1(106.99,126.13) v1(107.04,24.13) v1(107.17,104.75) v1(107.57,109.32) v1(108.34,129.49) v1(108.34,26.14) v1(109.21,140.76) v1(109.22,135.34) v1(109.22,134.7) v1(109.22,134.07) v1(109.4,150.69) v1(109.4,150.03) v1(109.59,25.08) v1(109.69,140.3) v1(109.72,133.62) v1(109.83,132.53) v1(110.87,124.99) v1(110.8,24.89) v1(111.39,26.46) v1(111.51,151.87) v1(111.57,33.45) v1(111.6,65.6) v1(111.77,69.22) v1(112.64,72.12) v1(113.17,157.69) v1(113.17,157.05) v1(113.33,117.41) v1(113.33,116.35) v1(113.33,24.34) v1(113.39,115.4) v1(113.39,114.55) v1(113.45,65.34) v1(113.42,33.47) v1(113.6,63.43) v1(113.7,173.74) v1(113.78,155.36) v1(113.78,154.18) v1(113.81,157.69) v1(113.81,157.05) v1(113.87,74.46) v1(114.06,23.83) v1(114.37,112.99) v1(114.43,106.2) v1(114.96,155.37) v1(114.97,154.18) v1(115.16,112.97) v1(115.15,105.32) v1(115.14,104.49) v1(115.19,110.03) v1(115.19,107.89) v1(115.21,106.11) v1(115.29,111.93) v1(115.6,126.94) v1(115.6,126.18) v1(115.6,125.42) v1(115.6,124.66) v1(115.93,122.7) v1(115.93,23.39) v1(116.31,150.86) v1(116.36,126.94) v1(116.36,126.18) v1(116.36,125.42) v1(116.36,124.66) v1(116.75,122.65) v1(116.94,150.86) v1(117.12,126.94) v1(117.12,126.18) v1(117.12,125.42) v1(117.12,124.66) v1(117.65,176.09) v1(118.2,168.52) v1(119.09,40.78) v1(119.09,40.02) v1(119.29,63.67) v1(119.4,62.05) v1(119.56,136.34) v1(119.55,133.39) v1(120.97,134.78) v1(120.97,133.4) v1(122.08,40.83) v1(122.11,40.03) v1(122.24,163.86) v1(122.31,31.77) v1(122.31,31.06) v1(123.26,119.65) v1(124.18,31.05) v1(124.67,31.64) v1(124.91,169.15) v1(125.02,31.02) v1(125.34,22.9) v1(125.34,22.27) v1(125.34,21.63) v1(125.38,17.54) v1(125.8,67.38) v1(126.15,70.16) v1(126.56,122.8) v1(126.54,31.05) v1(126.49,17.53) v1(126.88,31.64) v1(127.01,39.91) v1(127.17,31.05) v1(127.29,74.27) v1(127.53,120.77) v1(127.68,41.35) v1(127.72,42.41) v1(127.83,45.39) v1(128.1,174.14) v1(128.3,173.23) v1(128.29,120.77) v1(128.53,169.3) v1(128.57,31.86) v1(128.57,31) v1(128.78,174.24) v1(129.01,173.2) v1(129.05,120.77) v1(129.15,104.51) v1(129.16,103.71) v1(129.26,114.26) v1(129.28,113.46) v1(129.37,173.84) v1(129.46,22.93) v1(129.46,22.29) v1(129.46,21.66) v1(129.66,173.23) v1(129.81,120.77) v1(129.81,114.76) v1(130.21,104.51) v1(130.23,103.71) v1(130.33,114.26) v1(130.34,113.46) v1(130.41,171.53) v1(130.57,120.77) v1(130.57,26.01) v1(130.56,23.17) v1(130.88,114.72) v1(130.96,101.98) v1(131.29,113.72) v1(131.29,104.51) v1(131.31,103.71) v1(131.8,111.05) v1(131.97,114.37) v1(132.21,111.75) v1(132.46,140.63) v1(132.45,104.51) v1(132.46,103.71) v1(132.5,143.15) v1(132.53,31.83) v1(133.47,31.81) v1(133.79,169.84) v1(133.84,118.77) v1(133.89,117.6) v1(133.97,106.57) v1(134.31,145.69) v1(134.3,140.52) v1(134.88,121.83) v1(134.89,120.27) v1(135.45,150) v1(135.66,143.19) v1(135.64,138.1) v1(135.65,108.25) v1(136.34,150.07) v1(137.8,97.98) v1(138.58,106.13) v1(138.75,55.16) v1(138.92,109.13) v1(139.71,106.03) v1(140.28,99.18) v1(140.49,125.95) v1(140.51,106.04) v1(141.72,106.11) v1(141.97,130.5) v1(141.96,126.05) v1(142.37,120.15) v1(142.37,118.37) v1(142.37,116.77) v1(142.37,114.97) v1(142.8,106.07) v1(143.51,107.43) v1(143.97,114.89) v1(143.98,126.15) v1(144.02,120.15) v1(144.68,130.48) v1(145.56,126.17) v1(145.55,120.15) v1(145.72,114.89) v1(146.63,106.55) v1(147.4,124.81) v1(147.42,115.12) v1(147.6,120.15) v1(147.6,118.12) v1(147.6,116.34) v1(149.04,124.74) v1(150.05,113.9) v1(151.19,131) v1(151.22,129.41) v1(152.46,160.44) v1(153.18,98.84) v1(154.52,129.58) v1(154.68,127.99) v1(155.46,66.06) v1(155.46,64.44) v1(155.46,62.66) v1(156.13,105.43) v1(157.28,129.39) v1(157.19,66.06) v1(157.21,62.66) v1(158.25,119.38) v1(158.22,117.8) v1(158.3,73.63) v1(158.3,72.64) v1(158.3,71.73) v1(158.86,66.06) v1(158.86,64.36) v1(158.86,62.66) v1(159.14,79.66) v1(159.25,129.26) v1(160.09,49.33) v1(160.3,81.59) v1(160.33,79.7) v1(160.77,78.46) v1(161.56,48.97) v1(161.65,139.4) v1(162.06,157.16) v1(162.11,154.46) v1(162.15,152.5) v1(162.12,151.68) v1(162.39,81.12) v1(162.45,78.48) v1(163.56,68.25) v1(163.61,63.45) v1(163.69,60.96) v1(164.6,68.27) v1(164.65,63.45) v1(164.65,60.91) v1(164.84,168.86) v1(165.59,68.27) v1(165.65,63.45) v1(165.62,60.96) v1(165.79,154.79) v1(165.83,152.68) v1(165.85,100.06) v1(165.89,98.51) v1(166.23,144) v1(166.53,68.27) v1(166.53,63.45) v1(166.67,102.48) v1(166.66,60.96) v1(166.76,140.93) v1(166.69,100.83) v1(167.29,180.3) v1(168.77,180.13) v1(169.83,181.3) v1(170.65,155.48) v1(170.62,153.91) v1(170.62,152.33) v1(170.65,150.68) v1(170.62,44.73) v1(170.77,48.21) v1(172.02,155.51) v1(172.25,150.68) v1(172.68,51.33) v1(172.68,48.97) v1(172.98,102.54) v1(172.98,104.4) v1(173.57,155.51) v1(173.8,150.66) v1(174.13,142.49) v1(174.16,141.58) v1(174.64,79.24) v1(174.71,74.78) v1(174.97,109.29) v1(174.9,75.46) v1(175.4,74.75) v1(175.5,155.53) v1(175.5,154.09) v1(175.5,152.28) v1(175.5,150.68) v1(175.64,79.24) v1(175.64,75.46) v1(176.48,103.73) v1(176.46,101.62) v1(176.46,99.89) v1(176.48,98.14) v1(177.15,109.29) v1(177.17,80.87) v1(177.48,82.28) v1(177.94,80.87) v1(178.23,98.12) v1(178.24,82.28) v1(178.36,103.75) v1(178.66,108.68) v1(179.32,58.36) v1(179.31,56.54) v1(179.36,38.36) v1(179.36,36.48) v1(179.41,42.07) v1(179.41,40.22) v1(179.87,54.6) v1(179.85,51.63) v1(179.96,98.12) v1(179.9,79.12) v1(179.97,62.51) v1(179.97,59.81) v1(180.17,103.73) v1(180.82,117.71) v1(180.83,49.53) v1(180.83,48.63) v1(181.04,54.59) v1(181.02,51.62) v1(181.14,108.68) v1(181.27,91.22) v1(181.43,118.91) v1(181.56,117.71) v1(181.53,47.78) v1(182.06,176.63) v1(182.07,103.75) v1(182.07,100.38) v1(182.04,54.61) v1(182.02,51.64) v1(182.14,118.88) v1(182.1,102.31) v1(182.1,98.12) v1(182.32,117.74) v1(182.28,47.78) v1(182.46,19.57) v1(182.57,169.2) v1(182.5,77.62) v1(182.51,76.85) v1(182.67,27.04) v1(182.88,183.07) v1(182.88,118.88) v1(184.81,114.66) v1(185.09,169.33) v1(185.55,114.64) v1(186.13,157.8) v1(186.46,104.99) v1(186.56,103.38) v1(186.87,157.81) v1(186.83,16.37) v1(186.91,186.76) v1(187.06,172.79) v1(187.17,30.59) v1(187.26,101.13) v1(187.26,99.6) v1(187.68,149.3) v1(187.68,148.28) v1(187.68,147.27) v1(187.68,146.25) v1(187.68,145.23) v1(187.68,144.22) v1(187.68,143.2) v1(187.68,142.19) v1(187.98,170.32) v1(188.71,150.06) v1(189.54,170.35) v1(190.74,170.95) v1(191.32,183.35) v1(191.45,19.17) v1(191.78,170.99) v1(191.85,113.96) v1(191.98,176.65) v1(191.9,27.02) v1(192.78,157.58) v1(192.94,114.88) v1(193.37,173.06) v1(193.55,115.54) v1(193.71,157.55) v1(194.44,193.81) v1(194.53,173.11) v1(194.93,157.6) v1(195.19,193.78) v1(196.48,28.58) v1(196.48,27.77) v1(196.48,26.75) v1(196.84,196.92) v1(197.7,196.93) v1(199.64,28.59) v1(199.64,27.78) v1(199.65,26.76) v1(202.41,167.23) v1(203.28,166.11) v1(205.73,27.06) v1(205.74,26.24) v1(206.83,145.51) v1(206.8,144.75) v1(206.83,144.08) v1(206.83,143.28) v1(206.81,142.57) v1(206.84,141.81) v1(207.83,149.1) v1(207.79,148.35) v1(207.83,146.24) v1(207.89,146.98) v2(77.81,133.72) v2(78.91,134.94) v5(62.76,140.12) v5(63.22,137.12) v5(64.89,139.97) v5(65.34,137.15) v5(66.55,131.19)
