# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND2: length 8.5
  BOTTOM w0.102: v1(185.13,197.46) 185.13,197.81 185.6,198.28 185.6,199.45 185.13,199.93 185.13,202.04 186.05,202.96 J18.A12
GND3: length 7.5
  BOTTOM w0.102: J18.A15 183.05,199.63 182.61,199.19 182.61,198.25 v1(182.85,198.01)
GND27: length 5.6
  BOTTOM w0.102: v1(36.72,199.76) 37.05,200.09 J35.A70
GND36: length 6.6
  TOP w0.102: J18.B13 185.05,203.22 184.59,202.76 184.59,199.45 v1(185.05,199)
GND37: length 5.4
  TOP w0.102: v1(182.16,199.83) 182.16,199.83 182.05,199.94 182.05,205.2 J18.B16
GND61: length 7.6
  TOP w0.102: v1(39.12,198.01) 39.12,198.64 38.54,199.22 38.54,200.14 39.05,200.65 J35.B68
GND62: length 5.6
  TOP w0.102: J35.B69 v1(38.05,199.63)
GNDA: length 5.1
  TOP w0.254: v1(148.17,28.66) 147.65,28.66 147.29,29.02 U43.86
  TOP w0.508: C482.2 v1(153.24,24.71) ; L37.2 v1(156.7,26.19) ; C485.2 v1(148.42,25.47) ; C483.2 v1(154.51,24.69)
  vias: v2(155.82,28.58)
P0V75_BMC_VTTREF_NODE1: length 21.1
  TOP w0.356: U15.M8 v5(57.27,131.76) ; v5(51.5,135.49) 51.63,135.36 52.06,135.36 U15.H1 ; U14.V13 v5(72.17,133.26)
  TOP w0.381: v1(50,135.31) 50.18,135.49 v5(51.5,135.49)
  IN3 w0.102: 69.91,133.41 70.15,133.66 71.54,133.66 71.61,133.58 71.78,133.58 ; 71.8,132.06 72.57,132.06 72.57,132.05 ; 71.8,132.06 71.78,132.08 71.78,132.74 71.66,132.86 70.1,132.86 ; 71.8,132.06 70.12,132.06 ; 72.46,132.94 72.57,132.82 72.57,132.05 ; 72.57,132.05 72.57,131.44 72.39,131.26 70.1,131.26
  BOTTOM w0.102: 70.12,132.86 71.65,132.86 ; 71.65,133.66 70.2,133.66 ; 71.78,133.82 71.78,134.58 ; 70.12,132.06 71.65,132.06 71.78,132.18 71.78,132.8
  BOTTOM w0.381: v5(57.27,131.76) 57.6,132.09 C223.2
  vias: v1(48.64,139.08) v1(49.35,139.11) v2(48.07,138.38) v2(48.12,136.69) v2(48.49,135.13) v2(49.21,141.07) v2(69.67,134.13) v5(51.21,133.98)
P1V0_ADJ: length 4.7
  TOP w0.254: PR9.1 C851.1 PR10.2 172.09,76.08 v1(172.48,76.47) 172.87,76.86 U130.4
P1V0_ADJ_S: length 2.7
  TOP w0.254: PR9.2 C851.2 v1(170.63,74.32) 169.61,74.32 J28.2
P1V0_NODE1: length 48.3
  TOP w0.178: U125.15 152.33,142.98 v1(152.1,143.21) ; v1(139.07,141.89) 138.95,141.78 U125.85 ; U125.106 142.97,136.67 143.19,136.9 v1(143.19,137.25) ; v1(152.12,137.24) 152.26,137.38 U125.1 ; U125.4 152.41,138.58 v1(152.07,138.23) ; U125.72 v1(139.14,146.98) ; U125.42 148.17,150.03 v1(148.12,149.98) ; v1(139.17,145.29) 139.09,145.38 U125.76 ; U125.37 v1(150.17,149.94) ; U125.29 152.28,148.58 v1(152.05,148.34) ; v1(146.74,149.94) 146.57,150.11 U125.46 ; U125.49 145.37,150 v1(145.29,149.92) ; C877.1 140.97,135.82 U125.101 ; U125.118 v1(147.77,134.51) ; U125.110 144.57,137.03 144.6,137.06 v1(144.6,137.24) ; U125.52 v1(144.17,149.95) ; U125.123 149.77,134.71 v1(149.58,134.52)
  TOP w0.203: U125.61 140.57,150.07 v1(140.49,149.99)
  TOP w0.254: J28.1 169.61,75.54 171.21,77.14 PC29.1
  TOP w0.457: v1(140.2,133.4) C877.1
  BOTTOM w0.406: v1(139.17,145.29) 138.4,145.29 C880.1 ; C862.1 138.92,147.2 v1(139.14,146.98)
  BOTTOM w0.457: v1(152.1,143.21) 152.29,143.41 C889.1 ; v1(143.19,137.25) 142.83,136.89 C876.1 ; C331.1 145.01,150.23 145.29,149.95 v1(145.29,149.92) ; C873.1 144.6,136.47 v1(144.6,137.24) ; C864.1 146.74,150.63 v1(146.74,149.94) ; v1(152.07,138.23) C890.1 C330.1 v1(152.12,137.24) ; v1(144.17,149.95) 144.02,150.09 C875.1 ; C199.1 139.75,141.89 v1(139.07,141.89) 139,141.96 C878.1 ; v1(148.12,149.98) 148.29,150.15 C891.1 ; C861.1 147.78,134.52 v1(147.77,134.51) ; v1(150.17,149.94) 150.27,150.04 C874.1 ; C863.1 152.1,148.4 v1(152.05,148.34) ; C879.1 v1(149.58,134.52)
  BOTTOM w0.508: C872.1 140.34,150.15 v1(140.49,149.99)
  vias: v1(141.35,85.85) v1(142.52,142.86) v1(142.69,86.57) v1(143.28,142.86) v1(144.24,85.67) v1(146,86.45) v1(146.04,85.65) v1(147.02,85.62) v1(147.11,86.46) v1(148.22,86.72) v1(148.22,85.5) v1(149.54,86.45) v1(149.98,84.8) v1(150.46,58.7) v1(150.89,59.2) v1(151.06,86.13) v1(151.57,58.46) v1(151.6,59.18) v1(152.27,59.03) v1(152.25,58.2) v1(152.67,86.57) v1(166.76,83.44) v1(168.62,83.19) v1(169.31,85.59) v1(170.25,82.61) v1(170.48,81.55) v1(170.83,85.59) v1(171.29,83.29) v1(171.58,80.67) v1(172.1,85.59) v1(172.52,81.65) v1(172.48,78.2) v1(172.59,79.48) v1(172.66,77.54) v1(172.93,82.98) v1(172.98,80.06) v1(173.01,78.85) v1(173.49,79.53) v1(173.82,78.98) v1(176.74,86.03) v1(178.84,86.01) v2(145.59,148) v2(148.53,143.48)
P1V0_PCI_SW_A: length 10
  TOP w0.178: U125.78 139.06,144.58 v1(139.12,144.63) ; U125.112 145.37,137.09 v1(145.47,137.19) ; U125.80 139.02,143.78 v1(139.12,143.87) 138.81,144.18 U125.79 ; U125.92 v1(136.66,138.98) ; U125.113 145.77,136.73 v1(146.18,137.14)
  BOTTOM w0.457: v1(139.12,143.87) 138.68,143.87 C896.1 138.73,144.63 v1(139.12,144.63)
  vias: v2(142.59,144.44) v2(145.34,139.38)
P1V0_SATA: length 6.8
  TOP w0.178: U30.21 v1(162.77,61.16) ; U30.71 v1(151.76,62.76) ; U30.51 155.96,69.87 v1(155.99,69.9) ; U30.13 v1(158.36,58.83) ; U30.5 v1(155.16,58.93) ; U30.64 v1(151.21,65.56)
  vias: v1(150.49,67.78) v1(154.59,58.46) v1(155.86,58.49) v1(156.3,56.48) v1(156.41,57.57) v1(157.33,56.49) v1(157.5,57.55) v2(152.92,58.62) v2(155.23,57.66)
P1V5_CLK_NODE1: length 6.2
  TOP w0.152: U1.25 149.26,118.91 149.66,119.31 v1(150.59,119.31)
  TOP w0.178: U1.48 v1(140.52,118.11)
  BOTTOM w0.508: C7.1 141.23,118.83 v1(140.52,118.11) ; v1(150.59,119.31) 150.42,119.49 C8.1
  vias: v1(152.89,119.3)
P1V05_CLK_NODE1: length 2.7
  TOP w0.178: v1(139.78,117.81) 139.96,117.63 140.77,117.63 140.85,117.71 U1.49 ; U1.34 145.59,121.92 v1(145.54,121.97)
P1V5_CLK_NODE1_R:
  vias: v1(154.87,123)
P1V05_CLK_NODE1_R:
  vias: v1(136.58,126.32)
P1V05_LAN1: length 12.6
  TOP w0.254: v1(58.09,149.23) 57.85,149.47 U35.11 ; U35.41 v1(56.35,160.52) ; v1(62.13,151.22) 61.67,151.67 U35.18 ; U35.4 v1(54.35,149.32) ; U35.37 v1(58.35,160.43) ; U35.27 61.98,156.17 v1(62.13,156.32) ; U35.60 v1(51,153.17)
  BOTTOM w0.508: C419.1 54.86,149.82 v1(54.35,149.32) ; v1(51,153.17) 51.53,153.7 C417.1 ; v1(62.13,156.32) 61.95,156.14 C423.1 ; C420.1 61.98,151.06 v1(62.13,151.22) ; v1(58.09,149.23) 58.6,149.74 C422.1
  vias: v2(60.16,149.33) v2(62.38,155.22)
P1V05_LAN2: length 14.5
  TOP w0.254: v1(171.54,158.98) 171.54,158.98 171.54,158.75 171.8,158.49 U37.11 ; U37.60 v1(178.65,154.85) ; v1(167.29,156.96) 167.44,156.81 167.55,156.81 168.01,156.35 U37.18 ; U37.41 v1(173.3,147.36) ; U37.37 v1(171.3,147.59) ; U37.27 167.67,151.85 v1(167.36,151.53) ; U37.4 v1(175.3,158.7)
  BOTTOM w0.508: C464.1 167.7,151.88 v1(167.36,151.53) ; C463.1 172.71,147.45 172.8,147.36 v1(173.3,147.36) ; v1(178.65,154.85) 178.12,154.32 C467.1 ; v1(171.3,147.59) 171.28,147.61 C461.1 ; v1(167.29,156.96) C466.1
  vias: v2(165.81,158.17)
P1V5_NODE1: length 143.9
  TOP w0.254: v1(67.65,79.4) 67.24,79 U2.AA28
  TOP w0.305: v1(66.83,74.6) U2.AJ28 ; v1(66.83,73) U2.AM28 ; U2.AT21 63.98,71.8 63.63,71.46 v1(63.63,71.4) ; U2.AF28 v1(67.63,77)
  TOP w0.356: v1(66.83,71.4) U2.AT28
  TOP w0.508: v1(47.58,74.63) 47.8,74.42 R150.1 ; R2.1 158.91,120.72 161.42,118.2 v1(161.42,116.74)
  IN3 w0.508: v1(66.83,71.4) 66.83,72.04 ; v1(161.42,116.74) 162.08,116.74 163.07,115.74 163.07,113.68 154.96,105.56 154.96,104.95 152.38,102.37 137.99,102.37 121.46,85.83 114.66,85.83 111.11,82.29 109.56,82.29 106.98,79.72 104.29,79.72 103.67,79.09 102.4,79.09 102.36,79.13 100.31,79.13 99.79,79.65 97.21,79.65 97.09,79.52 96.29,79.52 95.28,80.53 79.15,80.53 77.74,81.95 77.74,86.25 75.9,88.08 74.99,88.08 73.83,86.92 73.83,82.53 72.23,80.93 69.1,80.93 67.65,79.47 v1(67.65,79.4)
  BOTTOM w0.381: R148.1 62.71,83.49 v1(62.98,83.21) ; v1(63.63,71.4) 63.49,71.54 R149.1
  BOTTOM w0.457: v1(63.63,71.4) 63.48,71.25 R36.1
  vias: v1(49.52,114.37) v1(49.52,113.74) v1(49.52,113.1) v1(51.24,114.28)
P1V05_NODE1: length 319.2
  TOP w0.178: v1(174.02,99.58) 174.18,99.74 U32.12 ; U32.43 184.38,100.94 v1(184.53,101.09) ; U32.37 184.05,98.54 v1(184.23,98.35) ; U32.54 181.68,105.72 181.9,105.95 v1(181.9,105.95) ; U32.9 174.02,100.94 v1(173.99,100.9) ; U32.63 178.08,105.6 v1(178.06,106.07) ; v1(184.76,102.4) 184.49,102.14 U32.46 ; U32.28 180.08,96.3 v1(179.56,95.78) ; v1(179.24,106.09) 179.28,105.65 U32.60
  TOP w0.254: U2.AL29 U2.AJ31 ; v1(75.63,71.4) U2.AU44 75.93,70.3 U2.AW46 U2.AW47 76.73,70.97 U2.AU47 76.78,71.02 76.78,71.36 v1(76.61,71.53) 76.07,71 U2.AU46 ; U2.AF31 v1(68.43,76.2) U2.AG29 ; v1(65.23,71.4) U2.AU25 65.64,71 65.87,70.77 66.2,70.77 U2.AU26 66.43,70.97 66.63,70.77 67,70.77 U2.AU28 ; U2.AL25 v1(65.23,73.8) U2.AL23 ; U2.AL26 v1(66.83,73.8) U2.AL28 ; v1(63.63,73) 63.55,73 U2.AP20 62.78,72.24 U2.AR19 ; U2.AM38 v1(72.43,73) U2.AP38 ; v1(67.63,71.4) U2.AU29 ; U2.AL36 v1(70.83,74.6) U2.AJ34 v1(70.83,75.4) U2.AG36 v1(70.83,76.2) ; U2.AC31 v1(68.43,77.8) ; U2.AL21 63.96,74.2 63.84,74.32 63.39,74.32 U2.AL20 U2.AL18 62.04,74.41 v1(62.04,74.76) ; U2.AP46 v1(75.63,73) U2.AP44 U2.AP42 ; U2.AP25 v1(65.23,73) ; v1(67.63,77.8) U2.AD29 ; U2.AP23 v1(64.43,73) U2.AP21 ; PR30.1 23.33,131.59 21.55,129.8 21.55,117.92 23.41,116.06 26.52,116.06 27.26,115.32 27.26,115.32 27.3,115.28 27.3,112.53 27.7,112.13 PC63.1 ; U2.AP41 v1(73.23,73) U2.AP39 ; U2.AR48 77.28,72.79 v1(77.42,72.93) 78.04,72.31 U2.AR50
  TOP w0.305: U2.AL42 74.43,74.19 v1(74.04,73.79) 73.65,73.4 U2.AM41 ; U2.AG34 v1(70.83,75.4) ; v1(76.43,73.8) 76.53,73.8 76.96,74.23 U2.AL47 U2.AL49 ; v1(65.23,71.4) U2.AU23 U2.AW23 64.83,69.93 64.74,69.85 U2.AY23 U2.AY21 63.84,70.01 U2.AW21 ; v1(72.43,73) U2.AP39 ; v1(74.83,75.4) U2.AJ44 ; U2.AC31 v1(69.23,77.8) U2.AD32 ; U2.AM41 v1(73.23,73) ; U2.AM41 v1(74.03,73) ; U2.AM41 v1(73.23,73.8) U2.AL39 72.43,74.6 v1(72.42,74.6) 72.03,74.99 U2.AJ38 ; U2.AC34 70.43,78.14 70.69,77.88 70.91,77.88 U2.AC36 U2.AA38 v1(72.43,79.4) U2.W39 ; U2.AU36 v1(71.63,71.4) U2.AU38 72.44,71.41 v1(72.45,71.41) 72.83,71.02 U2.AU39 U2.AU41 v1(74.03,71.4) U2.AU42 U2.AU44 ; v1(65.23,73) U2.AP23 ; v1(75.63,71.4) U2.AU46 ; U2.AC20 U2.AC18 ; U2.AC20 63.85,78.02 U2.AC21 64.15,78.32 64.71,78.32 U2.AC23 64.83,78.19 65.62,78.19 U2.AC25 65.64,78.2 v1(66.04,77.8) 66.43,78.2 U2.AC26 ; U2.AC20 U2.AD20 U2.AD18 U2.AC18 ; U2.AC18 62.4,78.02 v1(62.02,78.39) 62.14,78.39 v1(62.55,78.8) ; U2.AA41 U2.W42 ; U2.AG32 U2.AJ31 68.83,74.98 v1(69.22,74.59) 69.62,74.2 U2.AL32 v1(69.23,73.8) U2.AM31 ; U2.AP28 U2.AP29 ; U2.AM34 70.43,73.42 v1(70.82,73.81) 71.21,74.2 U2.AL36 ; v1(63.63,73) U2.AP21 ; v1(66.03,73) U2.AP25 ; v1(74.03,73) U2.AP41 ; v1(74.03,73) U2.AP42 ; U2.AD29 v1(68.43,77.8) ; U2.AJ41 v1(74.03,75.4) ; v1(69.23,72.2) U2.AT31 ; U2.AL29 U2.AL28
  TOP w0.356: U2.AP36 v1(70.83,72.2) U2.AT34 U2.AU32 ; v1(66.03,73) U2.AP26 66.61,72.43 67.06,72.43 U2.AP28 ; U2.AD28 v1(67.63,77.8) ; U2.W32 v1(69.23,79.4) U2.AA31 ; U2.AM31 v1(68.43,73) U2.AP29 ; U2.AA34 v1(70.83,79.4) U2.W36 ; v1(73.23,78.6) U2.AA41 ; U2.AF36 v1(70.83,76.2) U2.AG34 ; U2.AP32 v1(69.23,72.2)
  TOP w0.457: PC97.2 115.11,140.49 v1(114.8,140.17) ; R137.2 v1(112.71,135.13) ; R1215.2 v1(104.75,84.45)
  TOP w0.508: R116.2 v1(181.86,134.04) ; PR50.1 PR45.1 112.53,130.25 v1(112.54,130.24) ; R1122.2 v1(181.91,135.25) ; R1043.2 190.63,136.28 v1(190.13,136.78) ; v1(128.06,65.85) 127.66,65.85 127.22,65.41 127.19,65.41 R221.1 ; R228.2 v1(127.25,62.27)
  IN1 w0.508: v1(137.07,122.64) 137.07,116.24 136.28,115.45 136.28,110.7 136.87,110.11 136.87,106.28 133.63,103.04 130.16,103.04 129.67,102.55 129.67,99.03 137.72,90.98 v1(137.72,80.2) ; v1(109,125.99) 109,125.12 108.5,124.62 108.5,119.19 108.23,118.93 108.23,118.4 108.52,118.11 108.52,110.71 108.91,110.32 108.91,104.26 108.6,103.95 108.6,103.42 112.55,99.47 112.55,94.2 117.5,89.25 122.35,89.25 131.82,79.78 v1(135.17,79.78)
  IN2 w0.508: v1(190.13,136.78) 188.6,135.25 v1(181.91,135.25) 181.91,134.09 v1(181.86,134.04)
  IN3 w0.508: v1(109,125.99) 112.15,129.13 112.15,129.86 v1(112.54,130.24) 112.54,130.69 113.78,131.93 113.78,134.06 v1(112.71,135.13) 112.71,135.36 113.89,136.55 113.89,139.26 v1(114.8,140.17)
  BOTTOM w0.381: R200.2 64.76,81.48 66.1,80.14 C49.1
  BOTTOM w0.457: v1(95.48,78.41) 95.48,78.47 96.02,79.01 R127.2 ; v1(59.76,78.43) 60.05,78.72 C56.1
  BOTTOM w0.508: v1(184.53,101.09) 184.43,100.99 C371.2 ; R224.2 123.85,67.43 v1(124.17,67.75) ; v1(181.86,134.04) 181.32,134.04 179.77,132.48 175.29,132.48 173.81,131 173.81,129.61 171.45,127.25 171.45,124.29 174.48,121.26 174.48,114.39 177.91,110.95 v1(177.91,108.58) ; v1(178.06,106.07) 178.06,105.3 C369.1 ; v1(174.02,99.58) 174.03,99.59 C376.2 ; v1(181.9,105.95) 181.9,105.8 181.59,105.48 C375.2 ; C368.1 183.86,98.35 v1(184.23,98.35) ; v1(184.76,102.4) 184.41,102.05 C373.2 ; C372.2 179.25,106.08 v1(179.24,106.09) ; v1(179.56,95.78) 179.56,96.55 C370.1 ; v1(173.99,100.9) 174.06,100.83 C374.2
  vias: v1(28.43,114.56) v1(29.19,114.56) v1(29.96,114.56) v1(32.33,113.08) v1(32.33,112.32) v1(32.33,111.56) v1(32.48,108.38) v1(32.48,107.62) v1(32.48,106.86) v1(33.02,114.62) v1(33.78,114.62) v1(33.89,113.39) v1(33.89,112.63) v1(33.89,111.12) v1(33.89,110.36) v1(33.89,108.89) v1(33.89,107.98) v1(34.54,114.62) v1(34.9,107.11) v1(34.95,106.33) v1(56.72,76.69) v1(57.48,76.69) v1(58.24,76.69) v1(58.58,74.94) v1(59.89,70.84) v1(59.99,76.71) v1(60.56,74.78) v1(60.79,76.7) v1(96.99,76.1) v1(101.92,79.78) v1(102.67,79.73) v1(104.54,75.39) v1(104.99,76) v1(106.94,76.47) v1(107.04,77.46) v1(137.76,122.68) v2(55.97,77.65) v2(57.86,77.44)
P1V5_NODE1_AA21: length 8
  TOP w0.305: v1(63.64,79.39) 64.03,79 U2.AA21
  IN2 w0.508: v1(60.43,82.73) 60.43,82.44 61.61,81.26 62.2,81.26 62.87,80.58 62.87,79.9 63.37,79.4 63.63,79.4 v1(63.64,79.39)
  BOTTOM w0.381: v1(60.43,82.73) 60.43,83.13 61.38,84.08 R148.2
P1V5_NODE1_AJ21: length 18.3
  TOP w0.381: U2.AJ21 63.76,75 63.42,75.34 63.42,75.98 v1(63.47,76.04)
  TOP w0.508: R150.2 v1(50.06,74.42)
  IN1 w0.381: v1(50.06,74.42) 50.93,75.29 54.21,75.29 55.41,74.09 56.43,74.09 56.71,73.81 57.3,73.81
  IN1 w0.508: 57.3,73.81 59.23,73.81 59.44,74.02 62.24,74.02 62.81,74.59 62.81,75.69 63.16,76.04 v1(63.47,76.04)
P1V5_NODE1_AM21: length 3.4
  TOP w0.305: U2.AM21 v1(63.63,73.8)
  BOTTOM w0.381: v2(62.19,73.46) 62.53,73.8 v1(63.63,73.8)
  BOTTOM w0.508: R149.2 62.49,72.34 62.49,73.16 v2(62.19,73.46)
P1V05_NODE1_COMP: length 2.4
  TOP w0.254: PC69.2 26.09,131.84 v1(26,131.75) 25.86,131.61 25.86,131.27 26.11,131.02 PU6.5
P1V5_NODE1_DDR3_VREF0_D: length 8.4
  TOP w0.254: R217.1 C143.1 47.73,19.73 49.17,21.17 v1(50.54,21.17) 51.62,22.24 51.62,22.25 51.84,22.47 52.16,22.47 52.16,22.47 52.38,22.24 J2.1
P1V5_NODE1_DDR3_VREF_A_A: length 3
  TOP w0.254: v1(80.36,30.9) 80.3,30.96 v1(79.34,30.96) 79.34,30.71 79.68,30.36 J2.84
P1V05_NODE1_EN: length 5.3
  TOP w0.203: PU6.14 30.44,130.02 30.75,130.33 PC62.1
  TOP w0.254: PC62.1 31.36,130.25 32.28,129.33 PR23.2 33.39,129.33 PJ6.2 33.39,129.81 v1(33.71,130.12)
P1V05_NODE1_MODE: length 2.1
  TOP w0.254: PU6.15 30.23,130.52 v1(30.59,130.88) 31.05,131.34 PR26.1
P1V05_NODE1_TRIP: length 1.8
  TOP w0.254: PR28.1 25.48,130.52 v1(25.69,130.31) 25.9,130.52 PU6.6
P1V05_NODE1_VREF: length 4.1
  TOP w0.254: PC65.2 29.14,133.92 v1(29.99,133.92) 29.99,132.67 29.63,132.31 29.03,132.31 28.84,132.13 PU6.1
P1V05_NODE1_VREFIN: length 3
  TOP w0.254: v1(29.14,132.84) 28.75,132.84 28.34,132.44 PU6.2
  BOTTOM w0.254: PR25.2 28.68,133.3 v1(29.14,132.84)
P1V05_NODE1_VSNS: length 4.8
  TOP w0.102: PR29.2 25.07,134.26 v1(24.89,134.44)
  TOP w0.254: PR29.2 26.09,133.62 PC69.1 27.09,133.62 PC70.1 27.09,132.62 27.34,132.37 PU6.4
P1V5_SFRPLL_NODE1: length 10.1
  TOP w0.305: U2.BB34 70.53,68.5 70.99,68.96 v1(70.99,68.98) 70.9,68.89 70.9,68.87 U2.BA34
  BOTTOM w0.102: L8.2 67.17,70.72 66.97,70.92 65.6,70.92 65.08,70.4 65.08,69.53 v2(64.89,69.34)
  BOTTOM w0.381: L8.2 67.17,70.31 67.97,69.51 C93.1 68.33,68.85 69.41,68.85 C94.1 69.83,68.98 v1(70.99,68.98)
P1V05_STB_NODE1_XDP_A: length 3.3
  BOTTOM w0.508: R224.1 122.72,65.54 C182.2 120.98,65.46 v1(120.7,65.74)
P1V05_STB_NODE1_XDP_B: length 1.8
  TOP w0.254: J3.44 v1(124.25,65.91)
P1V5_SUS_NODE1: length 1.7
  BOTTOM w0.381: v1(66.17,69.64) 66.12,69.69 L8.1
  BOTTOM w0.457: C95.1 66.2,69.61 v1(66.17,69.64)
  vias: v1(46.34,102.89) v1(46.37,102.14) v1(47.06,102.45) v1(47.2,112) v1(47.2,111.36) v1(47.2,110.73) v1(48.05,102.74) v1(48.06,102.06) v1(48.94,102.71) v1(48.93,101.98) v2(44.19,101.96) v2(45.65,101.92) v2(45.79,100.29) v2(47.38,101.8)
P1V05_SUS_NODE1: length 3
  TOP w0.254: v1(107.66,137.31) 107.37,137.02 U119.3
  TOP w0.305: U2.P48 77.51,82.33 v1(77.13,81.95) ; v1(77.13,81.95) 76.83,81.66 U2.T47 ; v1(77.13,81.95) U2.T48
  vias: v1(98.23,83.61) v1(98.29,84.35) v1(101.91,77.77) v1(105.67,114.17) v1(105.83,76.43) v1(105.89,113.25) v1(106.13,77.7) v1(106.29,113.86) v1(106.29,77.09) v1(106.51,109.35) v1(106.6,111.64) v1(106.7,113.21) v1(107.83,137.96) v1(109.15,137.27) v1(109.21,136.49)
P1V5_SUS_NODE1_ADJ: length 2.8
  TOP w0.102: v1(48.16,107.28) 47.98,107.09 R1088.1
P1V05_SUS_NODE1_ADJ: length 1.1
  TOP w0.203: U119.4 106.87,137.12 106.75,137.24
  vias: v1(106.09,139.78)
P1V05_SUS_NODE1_ADJ_S:
  vias: v1(108.48,139.55)
P1V05_VCCACLK_DDR3_NODE1: length 6.6
  TOP w0.305: U2.AW32 69.65,70.03 v1(69.02,69.4) 69.15,69.27 U2.BA32
  BOTTOM w0.102: v2(67.71,73.24) 67.85,73.1 67.85,71.88 68.37,71.35 L7.2
  BOTTOM w0.305: L7.2 68.43,71.06 68.15,70.79 C80.1 68.15,70.22 68.97,69.4 v1(69.02,69.4)
P1V05_VCCPLL_DDR3_NODE1: length 4.3
  TOP w0.305: U2.AY38 U2.BA38 72.49,68.88 v1(72.88,68.49)
  BOTTOM w0.381: L5.2 C62.1 72.46,69.18 72.13,68.86 v2(72.13,68.63) 72.27,68.49 v1(72.88,68.49)
P1V05_VCCPLLCPU0SIO_NODE1: length 23.3
  TOP w0.305: U2.AC49 77.68,78.26 78.07,78.64 v1(78.08,78.64)
  IN2 w0.508: v1(98.59,78.01) 96.46,78.01 96.04,77.59 90.87,77.59 90.51,77.95 88.57,77.95 87.09,79.43 86.6,79.43 84.84,77.68 83.49,77.68 83.25,77.92 78.56,77.92 78.08,78.4 v1(78.08,78.64)
P1V05_VCCPLLCPU1SIO_NODE1: length 24.2
  TOP w0.305: U2.AD47 76.93,77.56 76.55,77.93 v1(76.55,77.93)
  IN2 w0.508: v1(76.55,77.93) 76.55,78.97 77.44,79.86 86.08,79.86 86.51,80.29 94.92,80.29 95.7,79.5 97.08,79.5 97.7,80.13 v1(97.7,80.43)
P1V8_NODE1: length 24.5
  TOP w0.254: 69.19,83.49 69.56,83.86 U2.L32 ; 69.19,83.49 69.2,83.49 69.56,83.13 U2.N32 69.25,82.78 v1(69.11,82.78) 69.56,82.33 ; 69.19,83.49 v1(69.17,83.49)
  TOP w0.305: v1(69.23,80.2) U2.V32 69.56,80.67 U2.T32 69.55,81.57 v1(69.08,82.04) 69.22,82.04 69.51,82.33 U2.P32 ; v1(67.63,76.2) U2.AG28
  TOP w0.508: L9.1 v1(47.08,75.37) ; v1(70.13,97.85) R47.2
  IN1 w0.508: v1(67.63,76.2) 67.63,76.01 68.1,75.54 69.61,75.54 69.84,75.78 69.84,79.65 69.3,80.2 v1(69.23,80.2)
  IN2 w0.508: v1(64.3,98.3) 65.61,96.99 66.63,96.99 67.06,97.41 v1(67.06,97.79) 67.69,97.15 69.43,97.15 v1(70.13,97.85)
  BOTTOM w0.508: R53.2 67.06,97.11 v1(67.06,97.79) ; R51.2 65.04,97.59 64.33,98.3 v1(64.3,98.3)
  vias: v1(41.37,123.37) v1(41.76,124.03) v1(42.34,124.39) v1(43.01,124.07) v1(64.45,102.16) v1(65.6,102.2) v1(66.31,102.17) v1(80.88,112.53) v1(81.56,112.53) v1(81.95,113.22) v1(82.3,112.5) v1(82.93,113.02) v1(83.15,112.29) v1(83.66,113.02) v1(83.97,112.34) v1(84.73,113.01) v1(84.7,112.34) v1(85.18,113.46) v1(85.37,112.29) v1(85.6,112.99) v1(86.16,112.5) v1(86.24,113.28) v1(94.88,113.95) v1(95.37,144.15) v1(95.29,113.24) v1(95.63,114.1) v1(95.95,143.71) v1(96.2,113.62) v1(96.46,144.2) v1(100.47,129.93) v1(100.42,121.7) v1(101.25,126.94) v1(101.48,127.54) v1(101.51,122.69) v1(101.67,121.83) v1(101.72,129.54) v1(101.8,128.84) v1(101.81,128.15) v1(110.06,122.55) v1(110.18,121.3) v1(110.35,123.55) v1(110.81,122.03) v1(111.01,121.22) v1(123.37,102.46) v1(123.58,101.84) v1(124.62,102.1) v1(125.29,102.48) v1(125.53,101.74) v1(126.07,102.58) v1(126.83,102.22) v1(141.84,78.92) v1(143.42,80.26) v1(143.75,78.77) v1(144.02,81.38) v1(144.73,80.13) v1(145.11,81.7) v1(145.7,78.98) v1(146.32,80.61) v1(148.12,63.52) v1(158.31,75.08) v1(158.31,74.43) v1(167.73,68.35) v1(168.95,60.67) v1(170.14,66.45) v1(177.73,77.88) v1(178.16,76.82) v1(178.39,78.16) v1(178.73,76.04) v1(179.51,75.9) v2(52.59,118.18) v2(85.08,122.44) v2(87.78,121.63)
P1V8_SATA_AVDD_NODE1: length 2.2
  TOP w0.178: U30.42 159.56,69.63 v1(159.73,69.8) 159.96,69.56 U30.41
  vias: v2(160.84,71.63)
P1V8_SATA_VAA1_NODE1: length 1.4
  TOP w0.178: v1(162.88,66.65) 162.59,66.65 162.3,66.36 U30.34
  vias: v2(168.85,66.72)
P1V8_SATA_VAA2_0_NODE1: length 1.4
  TOP w0.178: U30.31 162.91,65.16 v1(162.95,65.2)
  vias: v2(168.82,65.43)
P1V8_SATA_VAA2_1_NODE1: length 1
  TOP w0.178: U30.25 v1(162.62,62.76)
  vias: v2(168.87,62.61)
P1V8_STB_NODE1: length 27.9
  TOP w0.254: PU4.16 115.12,152.95 115.36,152.72 PC42.2 PR15.2 117.58,148.83 115.94,147.2 103.19,147.2 100.99,149.39 100.99,151.86 PC39.1
  vias: v1(40.86,103.55) v1(40.84,102.83) v1(41.43,103.08) v1(74.34,103.13) v1(74.97,103.13) v1(75.61,103.13) v1(76.24,103.13) v1(80.52,107.92) v1(81.05,107.34) v1(81.67,107.94) v1(82.24,107.27) v1(82.66,107.89) v1(83.16,107.26) v1(83.45,107.94) v1(101.43,152.23) v1(102.2,158.39) v1(102.2,157.63) v1(102.2,156.11) v1(102.2,155.34) v1(102.2,153.82) v1(102.2,153.06) v1(103.64,153.07) v1(103.85,157.63) v1(106.91,132.13) v1(107.67,132.12) v2(41.12,101.92) v2(42.55,101.88)
P1V8_STB_NODE1_FB: length 4.3
  TOP w0.254: PU4.1 116.21,154.02 116.44,153.8 v1(116.88,153.8) PR16.1 117.71,153.55 118.38,152.89 PC42.1 PR15.1
P1V8_STB_NODE1_SS: length 2.4
  TOP w0.254: PC41.2 117.29,156.22 v1(116.96,155.89) 116.96,155.63 116.35,155.02 PU4.3
P1V8_STB_NODE1_VREG5: length 6.9
  TOP w0.254: PU4.2 116.57,154.52 116.87,154.82 PC40.1 117.71,155.49 118.16,155.94 118.16,157.47 v1(117.81,157.82) 116.95,158.68 PR13.1
P1V8_SUS_NODE1: length 2.4
  TOP w0.305: U2.L41 73.39,83.86 v1(73.09,83.56) 73.54,83.11 U2.N41 73.54,83.09 v1(73.12,82.68) 73.47,82.33 U2.P41
  vias: v1(74.15,97.87) v1(74.79,97.89) v2(75.84,83.73)
P1V8_VCCASFRHPLL_NODE1: length 14.1
  TOP w0.254: U2.AD23 v1(64.43,77.8)
  IN2 w0.508: v1(51.3,78.43) 51.87,77.86 54.99,77.86 55.22,77.63 62.51,77.63 62.68,77.8 v1(64.43,77.8)
  vias: v1(49.88,77.09)
P1V9_LAN1: length 11.2
  TOP w0.254: v1(50.98,152.38) 51.27,152.67 U35.61 ; U35.47 v1(53.35,160.5) ; U35.22 v1(62.05,153.67) ; U35.51 v1(51.14,157.67) ; v1(62.08,152.03) 61.93,152.17 U35.19 ; U35.56 v1(51.08,155.17) ; U35.63 v1(51.03,151.67) ; U35.44 54.85,160.13 54.59,160.4 v1(54.59,160.51)
  BOTTOM w0.508: C410.1 61.33,154.39 v1(62.05,153.67) 61.75,153.37 C412.1 ; v1(62.08,152.03) 61.98,152.13 C405.1
  vias: v1(35.51,134.89) v1(35.93,157.22) v1(35.93,155.92) v1(36.24,164.46) v1(36.25,163.6) v1(36.33,134.97) v1(36.47,156.55) v1(36.76,137.9) v1(36.74,136.41) v1(36.87,155.9) v1(37.03,164.82) v1(37.05,164.14) v1(37.02,157.29) v1(37.13,135.03) v2(50.75,159.48)
P1V9_LAN2: length 19.9
  TOP w0.254: U37.47 v1(176.3,147.52) ; U37.63 v1(178.62,156.35) ; U37.22 v1(167.61,154.35) ; U37.44 174.8,147.77 v1(175.07,147.51) ; U37.19 167.72,155.85 v1(167.57,155.99) ; U37.56 v1(178.58,152.85) ; U37.61 178.38,155.35 v1(178.67,155.64) ; U37.51 v1(178.52,150.35)
  BOTTOM w0.508: 176.98,148.43 175.94,148.43 C459.1 175.92,147.9 v1(176.3,147.52) ; v1(167.57,155.99) 167.68,155.89 C469.1 ; C453.1 178.57,152.84 v1(178.58,152.85) 178.63,152.9 C450.1 ; C454.1 174.81,148.45 C452.1 174.84,147.74 v1(175.07,147.51) ; C451.1 C449.1 178.57,150.4 v1(178.52,150.35) 178.47,150.3 C455.1 177.63,150.32 C456.1 ; v1(167.61,154.35) 167.91,154.65 C470.1
  vias: v1(185.7,160.46) v1(186.19,161.08) v1(186.7,160.48) v1(193.07,160.46) v1(193.32,161.13) v1(193.91,160.46) v1(194.24,161.16) v1(194.68,160.45) v1(201,147.02) v1(201.03,146.07) v1(201.02,145.25) v1(201.01,143.8) v1(201.89,148.73) v1(201.89,147.91) v1(202.97,148.09) v2(177.97,148.76) v2(200.1,156.57)
P1V26_BMC_NODE1: length 9.6
  TOP w0.305: U14.L6 v5(78.57,139.66) 78.97,139.26 U14.K6 v5(79.37,139.66) ; v5(79.37,130.06) 78.97,130.46 U14.K17 ; v5(75.37,130.06) 75.77,130.46 U14.P17 ; U14.U12 73.37,134.46 v5(72.97,134.06) 73.37,133.66 U14.U13 v5(72.97,133.26) ; U14.L17 78.17,130.46 v5(78.57,130.06) ; U14.P6 75.77,139.26 v5(75.37,139.66) U14.R6 ; U14.F15 v5(82.57,132.46) U14.F14 ; U14.R17 74.97,130.46 v5(74.57,130.06)
  TOP w0.381: U14.Y18 v5(70.57,129.26)
  BOTTOM w0.356: v5(70.57,129.26) 70.57,129.4 70.47,129.51 70.35,129.51 70.02,129.83 70.02,129.85 C288.1
  vias: v1(62.95,123.76) v1(92.98,137.41) v1(93.78,137.59) v1(94.56,138.69) v1(94.73,137.53) v1(95.43,138.53) v1(95.49,137.45) v2(62.23,124.42)
P1V26_BMC_NODE1_ADJ: length 3.8
  BOTTOM w0.254: v1(96.46,138.2) 96.46,137.36 95.87,136.76 94.01,136.76 R1098.1
P1V26_STB_NODE1_ADJ_S: length 2.7
  TOP w0.254: J23.1 95.46,135.71 v1(95.69,135.48) 96.21,135.48 96.38,135.66 R1097.1
P1V538_BMC_NODE1: length 57.8
  TOP w0.178: v1(139.07,143.01) 139.03,142.98 U125.82 ; U125.115 146.57,134.69 v1(146.76,134.5) ; v1(139.14,146.03) 138.86,146.03 138.61,145.78 U125.75 ; v1(143.84,137.27) 143.84,137.04 144.17,136.71 U125.109
  TOP w0.356: U15.E9 58.93,137.3 59.33,137.3 v5(60.02,136.61) ; U15.C9 58.57,139.47 59.84,139.47 v5(60.4,138.9) ; v5(59.75,135.67) 59.75,135.41 59.41,135.07 58.75,135.07 U15.H9 ; U15.H2 v5(52.47,135.76) ; U15.K8 57.27,134.16 v5(57.27,134.16) ; v5(56.03,136.29) 56.15,136.16 U15.G7 ; U15.D9 58.47,138.56 v5(58.87,138.16) ; U15.B2 v5(52.47,140.56) ; U15.F1 51.39,136.96 v5(51.39,136.97) ; v5(51.38,139.37) 51.38,139.36 U15.C1 v5(52.47,138.96) U15.D2 ; v5(60.04,130.77) 59.68,131.13 58.7,131.13 U15.N9 ; U15.K2 v5(53.27,134.16) ; U15.A8 57.93,141.23 57.93,141.39 v5(58.13,141.59) ; v5(59.64,129.22) 59.64,129.51 59.38,129.76 U15.R9
  TOP w0.381: v5(72.97,136.46) 73.37,136.06 U14.U10 ; v5(72.97,131.66) 73.37,132.06 U14.U15 ; U15.R1 51.29,129.76 v5(51.16,129.89) ; v5(72.97,135.66) 73.37,135.26 U14.U11 ; U15.A1 v5(52.07,141.6) ; v5(51.14,131.37) 51.14,131.36 U15.N1 ; U14.U14 v5(72.97,132.46) ; R259.2 v1(53.53,123.07)
  IN2 w0.102: 69.92,131.26 72.75,131.26 ; 69.92,133.66 73.27,133.66 ; 69.92,137.66 73.27,137.66 ; 69.92,132.06 72.75,132.06 ; 69.92,132.86 72.75,132.86 ; 69.92,136.06 72.75,136.06 ; 69.92,136.86 72.75,136.86
  BOTTOM w0.102: v5(72.97,136.46) 72.86,136.46 72.46,136.86 70.12,136.86 70.12,136.86 ; 70.18,136.06 72.64,136.06
  BOTTOM w0.406: C882.1 138.97,146.21 v1(139.14,146.03)
  BOTTOM w0.457: C894.1 v1(139.07,143.01) ; C893.1 143.82,137.06 143.84,137.09 v1(143.84,137.27) ; C892.1 146.79,134.52 v1(146.76,134.5)
  vias: v1(42.93,129.39) v1(43.69,129.39) v1(44.57,130.52) v1(45.27,130.84) v1(45.23,130.19) v1(45.2,129.55) v1(45.85,129.57) v1(50.78,125.48) v1(52.27,127) v1(58.38,143.97) v1(105.97,149.58) v1(105.99,150.43) v1(106.91,150.47) v1(106.89,149.62) v1(124.1,149.18) v1(125.41,148) v1(125.78,149.54) v1(126.53,148.11) v2(54.19,126.4) v2(56.97,127.29) v2(60.99,126.47) v2(61.49,141.57) v2(69.2,135.73) v5(51.25,141.73)
P1V538_BMC_NODE1_ADJ: length 4.6
  TOP w0.203: v1(42.04,129.75) 42.17,129.61 U121.4
  TOP w0.254: C833.1 42.18,131.84 R1095.1 42.19,130.54 PR17.2 42.22,129.93 v1(42.04,129.75)
P1V538_STB_NODE1_ADJ_S: length 2.6
  TOP w0.254: R1095.2 42.98,131.84 C833.2 42.99,132.84 43.42,132.84 v1(43.6,133.02) 43.8,132.82 J22.1
P3V0_BAT_NODE1_R: length 2.1
  TOP w0.102: R147.2 135.41,69.7 v1(135.01,69.31) U3.2
P3V3_CLK_NODE1: length 13.6
  TOP w0.178: v1(147.86,113.16) 147.59,113.43 U1.14 ; v1(150.04,116.67) 149.76,116.67 149.51,116.91 U1.20 ; U1.7 144.79,113.29 145.09,112.99 v1(145.09,112.45) ; U1.3 v1(143.19,112.65) ; U1.15 149.02,114.91 149.46,114.48 v1(149.66,114.48)
  TOP w0.508: R21.2 v1(153.04,113.27) ; v1(137.89,113.66) 137.89,113.88 138.25,114.24 R8.2 ; R19.2 149.43,107.44 v1(149.61,107.26) ; v1(153.51,111.5) 152.72,111.5 R20.2 ; R14.2 148.16,107.31 v1(148.29,107.18) ; R11.2 v1(145.75,107.3) ; R12.2 v1(155.81,117.08) ; R13.2 v1(155.79,115.86) ; v1(150.34,107.34) 150.7,107.7 R22.2
  vias: v1(145.97,106.01) v1(149.37,106.39) v1(151.62,109.88)
P3V3_CLK_NODE1_R:
  vias: v2(147.65,102.15)
P3V3_NODE1: length 712
  TOP w0.178: U125.20 152.29,144.98 v1(152.05,145.22) ; v1(156.78,58.88) 156.76,58.89 U30.9 ; v1(146.05,149.94) 145.77,150.22 U125.48 ; U125.39 v1(149.37,149.9) ; v1(176.75,105.97) 176.88,105.85 U32.66 ; U125.35 v1(150.97,149.9) ; U32.15 174.2,98.54 v1(173.83,98.16) ; v1(140.04,134.47) 140.17,134.6 U125.99 ; U32.49 184.08,103.34 184.26,103.51 184.39,103.51 v1(184.46,103.58) ; v1(180.28,95.77) 180.48,95.96 U32.29 ; U125.55 142.97,150.12 v1(142.95,150.1) ; U125.124 150.17,136.76 v1(150.5,137.09) ; U30.73 v1(151.74,61.96) ; v1(180.61,106.17) 180.48,106.04 U32.57 ; U30.57 v1(153.56,69.81) ; U32.40 v1(184.49,99.74) ; v1(152.07,139.98) 152.27,140.18 U125.8 ; U125.5 v1(152.03,138.98)
  TOP w0.203: 94.71,121.14 U115.6 ; U115.36 105.03,123.64 105.03,123.64 105.24,123.64 105.56,123.96 105.88,123.96 105.89,123.96 ; U115.30 105.28,120.64 105.67,121.04 106.01,121.04 ; 94.3,117.8 94.58,117.8 94.92,118.14 U115.12
  TOP w0.254: U37.10 v1(172.3,158.71) ; U129.31 v1(140.65,174.61) ; v1(62.1,159.04) 61.74,158.67 U35.32 ; U37.32 167.91,149.35 v1(167.55,148.98) ; U128.80 99.78,168.12 100.53,168.12 100.68,167.98 101.89,167.98 C581.1 ; U129.59 147.56,162.37 147.75,162.18 147.75,161.86 147.81,161.79 ; U129.13 149.56,179.63 149.84,179.91 149.84,180.38 v1(150,180.54) ; PU5.16 81.38,8.27 81.14,8.5 PC53.2 PR20.2 78.92,12.89 80.85,14.81 92.12,14.81 95.82,11.12 PC50.1 ; C909.1 102.23,175.42 v1(101.76,174.94) 101.68,175.02 100.83,175.02 100.73,175.12 U128.94 ; U128.9 94.03,180.77 v1(93.77,181.02) 94.06,181.31 ; U128.31 83.25,175.62 83.2,175.58 82.24,175.58 C583.1 ; 159.1,167.2 159.08,167.2 159.08,167.22 158.97,167.11 U129.80 ; v1(151.11,180.73) 151.11,180.08 151.56,179.63 U129.9 ; C580.1 90.03,162.63 U128.59 ; U37.1 v1(176.8,158.69) ; C904.1 159.15,174.25 159.01,174.11 159.01,174.11 U129.94 ; U128.13 92.03,180.65 92.16,180.79 92.16,181.08 ; v1(92.03,163.09) U128.63 ; U128.45 v1(83.1,168.62) ; U129.63 v1(149.56,164.49) ; U35.10 v1(57.35,149.31) ; U35.1 v1(52.85,149.33)
  TOP w0.305: U2.V36 U2.T36 71.23,81.34 v1(70.85,81.72) 71.08,81.95 U2.R37 U2.P37 71.53,82.71 v1(71.16,83.08) 71.55,83.47 U2.M37 ; U2.AF23 v1(64.43,77)
  TOP w0.356: U70.3 v1(108.32,167.07) ; v1(163.25,30.53) U51.26 ; v1(108.5,172.58) 108.75,172.83 U69.3 ; v1(134.51,164.15) 134.35,164.31 U61.12
  TOP w0.381: U14.J6 v5(80.17,139.66) ; U14.H6 v5(80.97,139.66) ; v5(76.97,130.06) 77.37,130.46 U14.M17 ; C550.1 22.21,156.23 21.79,156.66 U55.26 ; 113.78,17.68 C140.1 ; 113.78,17.68 113.78,19.05 114.18,19.45 J2.199 ; 113.78,17.68 v1(113.07,17.68) ; U14.N6 76.57,139.26 v5(76.17,139.66) ; v5(76.97,139.66) 77.37,139.26 U14.M6 ; U57.26 170.13,172.9 169.83,172.6 C913.1 ; U56.26 22.42,140.17 22.69,139.9 C555.1 ; U14.W18 v5(71.37,129.26) ; C580.1 89.98,162.5 89.22,161.73 89.22,161.31 88.96,161.06 v1(88.96,161.03) ; U9.16 63.15,96.56 v1(62.31,95.72) ; v1(101.39,179.53) 101.48,179.61 R1252.2 ; U14.N17 76.57,130.46 v5(76.17,130.06) ; U14.F13 v5(82.57,134.06) U14.F12 ; v1(16.06,155.19) 16.26,155.39 R1310.1 ; U14.F9 v5(82.57,137.26) ; v5(80.17,130.06) 79.77,130.46 U14.J17 ; v5(72.97,138.06) 73.37,137.66 U14.U8 ; PR54.2 v1(112.63,137.19) ; v5(72.97,137.26) 73.37,136.86 U14.U9 ; C225.2 55.89,122.25 U16.5 ; U14.F10 v5(82.57,136.46) ; 28.03,17.71 27.17,18.57 U52.26 ; R583.2 v1(179.05,166.39) ; U14.F11 v5(82.57,135.66) ; PR52.2 v1(112.6,136.18) ; U14.H17 80.57,130.46 v5(80.97,130.06) ; v1(116.17,129.14) 116.58,129.55 PR79.1 ; U14.F8 v5(82.57,138.06)
  TOP w0.406: U131.5 113.47,181.31 C776.1 ; R534.1 169.13,103.59 v1(169.26,103.72)
  TOP w0.457: v1(93.63,120.06) 93.34,120.35 C1120.2 93.97,120.81 94.31,121.14 94.71,121.14 ; v1(119.63,163.93) 119.42,163.72 118.68,163.72 118.62,163.77 R769.1 ; R1075.1 89.24,182.66 v1(89.56,182.98) 89.45,183.09 88.73,183.09 88.66,183.15 R1076.1 ; PR24.1 v1(32.77,132.36) ; v1(107.08,124.72) C1119.2 105.89,123.96 ; v1(93.66,116) 93.34,116.32 C1121.1 94.3,117.8 ; R309.2 160.49,140.51 v1(160.25,140.27) ; v1(151.11,180.73) 151.49,181.11 C901.1 ; U135.5 142.45,57.07 C539.1 142.99,57.05 v1(143.4,57.46) ; 106.01,121.04 C1122.1 v1(107.08,121.75) ; v1(142.12,55.14) C538.1 141.46,54.51 141.39,54.58 U136.5 ; R1217.2 136.82,58.88 v1(136.83,58.88) ; R283.1 138.58,154.18 v1(139.06,154.66) ; C618.1 64.29,171.4 64.73,171.84 U85.5 ; v1(145.53,153.03) 145.53,153.61 145.8,153.88 R299.1 ; C907.1 159.2,167.09 159.1,167.2 v1(159.1,167.2) ; R527.1 171.44,97.32 v1(171.3,97.46) 171.32,97.49 171.32,97.86 171.64,98.18 R533.1 ; R310.2 v1(160.47,143.05)
  TOP w0.508: U89.5 68.13,171.72 68.52,171.33 C620.1 v1(69.24,170.63) ; v1(82.67,149.67) R304.1 ; R663.1 R664.1 122.76,171.61 122.76,171.61 v1(122.78,171.63) ; v1(62.31,95.72) 62.54,95.49 C136.1 ; R759.2 120.13,163.93 v1(119.63,163.93) ; C578.1 92,163.06 v1(92.03,163.09) ; R669.1 142.04,162.25 v1(142.06,162.24) ; R1302.1 v1(20.7,137.25) ; v1(57.69,144.51) 57.57,144.63 R544.1 ; R674.1 v1(136.76,170.59) ; U134.8 37.67,96.26 37.42,96.01 C537.1 38,95.06 v1(38.23,94.83) ; R667.1 v1(122.89,169.58) ; v1(140.65,174.61) 140.59,174.67 C900.1 ; v1(41.76,99.05) 41.25,98.55 R180.1 ; v1(122.77,166.52) R673.2 R677.1 ; v1(105.38,175.32) R739.2 R738.2 105.71,176.34 v1(105.41,176.04) ; R649.1 v1(160.25,32.57) ; R48.1 v1(93.26,87.98) 93.94,87.98 94.68,87.24 97.66,87.24 98.36,86.54 102.97,86.54 107.6,91.17 107.6,97.75 107.98,98.13 v1(108.26,98.13) ; v1(98.44,135.07) 98.39,135.03 v1(97.38,135.03) 97.42,134.98 D34.A D33.A D32.A 94.37,133.96 D31.A ; v1(98.44,135.07) 98.95,134.57 D35.A ; v1(98.44,135.07) 99.95,135.07 99.97,135.09 ; U36.8 69,160.23 68.2,161.02 C390.1 v1(67.48,161.53) ; v1(82.92,169.8) 82.85,169.87 C885.1 ; R1213.1 v1(178.64,13.63) ; v1(130.29,162.92) 130.28,162.91 130.28,161.67 131.14,160.8 R668.1 ; R300.1 81.58,149.21 81.5,149.29 v1(81.5,149.66) ; C776.1 114.52,180.75 v1(114.28,180.5) ; R555.2 v1(76.34,151.48) ; v1(83.1,168.62) 83.03,168.7 C582.1 ; R1311.1 19.68,138.23 R1301.1 19.69,137.08 19.74,137.03 19.74,137.03 20.38,136.39 v1(20.73,136.39) ; 92.16,181.08 92.16,181.49 92.03,181.62 C585.1 91.54,182.01 v1(91.28,182.27) ; 99.97,135.09 100.47,134.58 D36.A ; 99.97,135.09 v1(101.21,135.09) ; v1(56.58,144.68) 56.58,145.4 R546.1 ; R652.1 v1(23.97,14.91) ; v1(149.06,160.65) C906.1 148.19,161.41 147.81,161.79 ; v1(166.37,164.38) 166.18,164.57 R585.2 ; R525.1 170.77,106.78 v1(169.87,106.78) ; v1(86.12,95.29) 85.47,94.65 R151.2 ; R343.1 v1(70.01,117.77) ; R327.1 v1(75.86,120.03) R326.1 ; v1(103.01,134.93) 103.52,134.42 D38.A D37.A 101.99,134.31 v1(101.21,135.09) ; R186.1 v1(30.84,98.96) ; v1(158.87,147.87) 159.49,147.87 159.96,148.33 R301.2 ; v1(163.52,149.82) 163.84,150.14 R597.1 ; R553.2 v1(69.23,163.22) ; 28.03,17.71 C543.1 v1(27.35,16.66) ; R632.1 v1(38.01,42.66) ; R1261.2 161.84,172.95 v1(161.65,172.76) ; R298.1 83.74,149.28 84.08,149.62 v1(84.08,149.62) ; v1(185.65,200.43) v1(185.65,201.19) 185.65,202.38 186.05,202.78 J18.B12 ; v1(159.35,173.52) 159.71,173.88 C904.1 ; R111.2 84.35,97.19 83.63,97.91 v1(83.63,98.09) ; v1(117.33,179.7) 117.33,179.69 117.33,179.68 117.5,179.52 117.5,179.49 117.8,179.18 117.89,179.18 118.06,179.01 C573.2 117.09,178.98 116.71,179.36 U67.8 ; v1(32.65,127.91) 32.45,128.12 PR23.1 ; U38.8 176.39,167.66 176.49,167.76 C434.1 v1(177.44,169.24) ; R666.1 v1(122.66,170.59) ; v1(77.19,97.76) 77.19,97.16 R68.1 ; R653.1 v1(145.3,59.63) ; R735.2 v1(119.49,176.97) ; R538.1 v1(63.06,165.14) ; C550.1 22.21,153.75 22.03,153.57 v1(22.03,153.57) ; R671.1 v1(149.7,157.54) ; v1(34.49,61.99) 33.87,62.6 R631.1 ; R198.1 v1(56.83,102.8) ; v1(34,63.31) 33.64,63.67 R633.1 ; R1248.1 136.76,162.46 v1(136.84,162.38) ; v1(101.21,135.09) 101.21,137.23 107.29,143.31 109.44,143.31 v1(109.93,143.79) ; R303.2 v1(158.95,148.77) ; R537.1 v1(60.78,165.11) ; v1(167.11,177.28) 166.89,177.28 166.2,176.59 R1305.1 ; R626.1 v1(162.72,45.71) ; R596.1 v1(66.8,157.98) ; R536.1 v1(59.63,165.03) ; v1(138.88,61.69) C335.1 137.84,61.69 137.84,62.44 137.5,62.78 U31.8 ; R1139.1 v1(152.1,24.68) ; C903.1 149.56,180.99 v1(150,180.54) ; R1299.1 20.23,153.19 v1(20.45,152.97) ; U68.5 119.91,168.62 120.26,168.98 v1(120.26,169.64) ; v1(166.73,140.23) 167.12,140.23 167.72,140.84 R568.1 ; C581.1 101.42,167.42 v1(101.37,167.47) ; C574.1 120.26,173.98 120.72,173.52 v1(120.72,172.65) ; U84.5 78.45,171.63 78.85,171.23 C617.1 v1(79.57,170.63) ; R540.1 v1(61.92,165.14) ; v1(85.36,97.86) 85.37,97.85 R109.2 R105.2 ; R196.1 R197.1 69.24,98.88 68.96,98.59 v1(68.96,98.56) ; C913.1 168.65,172.6 168.27,172.23 167.47,172.23 v1(167.15,172.55) ; v1(102.27,106.85) 101.99,107.12 R177.1 ; R514.1 v1(160.29,56.07) ; R517.1 v1(162.33,56.16) ; R529.1 v1(176.84,88.85) ; v1(54.4,144.54) 54.4,145.37 R548.1 ; R580.1 v1(176.3,162.41) ; v1(76.16,170.63) C619.1 75.44,171.27 75.02,171.68 U88.5 ; R297.1 141.51,154.7 v1(141.38,154.56) ; R569.1 163.53,141.72 v1(163.43,141.62) ; R737.2 105.65,179.39 v1(105.37,179.11) 105.37,179.8 v1(106.31,180.74) ; R572.1 v1(168.62,161.6) ; R771.1 v1(119.22,165.79) ; R1262.1 17.52,152.35 16.94,151.77 16.94,151.77 16.74,151.57 16.74,150.99 v1(16.36,150.61) ; R1298.1 v1(19.21,152.96) ; R528.1 v1(165.53,85.92) ; R344.1 v1(68.92,117.74) ; R571.1 168.86,141.67 169.55,140.98 v1(169.98,140.98) ; v1(82.73,174.58) 82.19,175.12 C583.1 ; v1(166.54,91.43) 166.25,91.73 R531.2 ; v1(62.3,170.49) 61.97,170.82 C621.1 61.39,171.49 61.17,171.7 U87.5 ; R281.1 134.93,136.73 v1(135.35,136.31) ; R665.1 137.73,161.64 138.01,161.91 138.01,163 v1(137.99,163.02) ; v1(109.3,180.7) 109.3,181.07 109.7,181.46 R146.2 ; R680.2 136.23,164.49 136.96,165.23 v1(137.08,165.23) ; U33.8 175.3,90.12 C367.1 v1(175.32,90.93) ; R672.1 v1(136.76,169.57) ; v1(63.47,171.01) 63.85,170.63 C618.1 ; U13.8 159.35,156.95 160.02,157.62 C191.1 160.27,158.19 v1(160.75,157.72) ; v1(108.32,167.07) 108.23,167.16 C577.1 ; v1(72.78,170.6) C616.1 72.02,171.08 71.59,171.51 U86.5 ; R566.1 v1(165.56,141.72) ; C584.1 v1(107.7,166.16) ; R516.2 v1(143.01,59.58) ; R576.1 v1(173.1,162.4) ; R509.1 v1(148.42,61.72) ; R302.1 v1(80.51,149.52) ; R511.1 v1(148.3,60.7) ; C575.1 108.19,172.27 v1(108.5,172.58) ; R650.1 v1(160.33,33.59) ; R542.1 v1(65.27,147.55) ; R187.1 v1(30.79,101.07) ; v1(161.52,141.58) 161.5,141.61 R570.1 ; R651.1 v1(24.98,14.9) ; R1214.1 v1(175.6,13.64) ; R336.1 v1(74.54,120.01) ; v1(54.8,121.36) C225.2 ; R314.2 71.23,150.35 71.56,150.68 v1(71.56,150.68) ; v1(138.76,133.05) 139.03,132.78 R280.1 ; R305.2 v1(156.18,135.19) ; v1(169.01,177.8) 169.01,177.05 168.44,176.48 R1304.1 ; R275.1 v1(159.87,145.1) ; R502.1 v1(161.31,56.06) ; v1(163.25,30.53) 163.24,30.55 163.03,30.55 162.63,30.95 C530.1 ; R567.1 v1(170,141.8) ; v1(100.14,107.91) C42.1 99.07,106.86 100.19,105.75 U4.8 U5.8 ; R1150.1 v1(137.24,25.26) ; R550.1 53.38,145.37 v1(53.38,144.42) ; R760.2 R762.1 118.6,171.95 118.96,171.6 118.99,171.6 119.09,171.51 v1(119.28,171.51) ; v1(134.51,164.15) 135.19,163.48 C567.2 ; R501.2 v1(152.07,69.66) ; R1290.2 v1(196.84,127.03) ; R617.1 v1(135.85,50.44) ; v1(22.69,138) C555.1 ; R541.1 v1(59.63,167.57) ; R767.2 v1(119.23,166.85) ; R578.1 v1(175.29,162.41) ; R574.1 v1(172.09,162.39) ; R532.2 v1(178.13,92.68) ; C586.1 94.06,181.31 ; R539.1 v1(64.21,165.11) ; R616.1 v1(138.84,52.15)
  IN1 w0.508: 78.87,171.34 76.62,171.34 76.16,170.88 v1(76.16,170.63) 75.37,171.43 73.46,171.43 72.78,170.74 v1(72.78,170.6) 72.34,170.6 71.57,171.38 69.99,171.38 v1(69.24,170.63) ; 78.87,171.34 78.35,171.86 78.35,176.32 76.07,178.6 v1(75.73,178.6) ; 78.87,171.34 v1(79.57,170.63) ; v1(30.79,101.07) 27.05,104.81 v1(26.76,104.81) ; v1(82.73,174.58) 82.73,173.9 84.87,171.76 85.79,171.76 87.26,170.29 89,170.29 v1(89.83,169.46) ; v1(89.56,182.98) 90.57,182.98 v1(91.28,182.27) 92.16,181.38 92.16,180.83 92.56,180.43 93.18,180.43 v1(93.77,181.02) 95.27,179.53 v1(101.39,179.53) 102.22,179.53 102.79,180.1 104.17,180.1 v1(105.34,181.27) 105.78,181.27 v1(106.31,180.74) 107.02,180.02 107.85,180.02 108.53,180.7 v1(109.3,180.7)
  IN2 w0.508: v1(64.43,77) 64.49,77 65.33,77.84 65.33,78.32 68.18,81.17 70.3,81.17 v1(70.85,81.72) ; v1(109.93,143.79) 109.93,143.66 110.73,142.86 110.73,128.96 113.07,126.62 113.07,121.08 v1(111.62,119.63) ; v1(89.83,169.46) 91.29,169.46 95.12,173.29 97.35,173.29 97.71,173.65 100.46,173.65 v1(101.76,174.94)
  IN3 w0.508: v1(99.26,98.03) 99.43,98.19 104.26,98.19 104.36,98.29 108.1,98.29 v1(108.26,98.13) ; v1(108.5,172.58) 109.3,173.39 v1(109.3,180.7)
  BOTTOM w0.254: v1(101.92,169.45) 101.84,169.53 100.87,169.53 100.59,169.82 99.77,169.82 U62.24 ; C569.2 63.17,179.87 v1(63.19,179.89) ; U66.24 162.45,169.95 162.04,169.53 C572.2
  BOTTOM w0.305: 179.13,172.9 U59.26
  BOTTOM w0.33: U146.5 141.59,57.18 142.11,57.64 C599.1 ; C598.1 148.76,54.95 U145.5 ; v1(116.74,173.53) 116.21,172.99 U65.24
  BOTTOM w0.356: v1(133.8,173.31) 133.48,173.63 U64.24 ; v1(95.23,165.97) 95.19,165.97 94.87,165.65 U73.12 ; U63.24 v1(63.19,179.89)
  BOTTOM w0.381: U133.5 112.18,170.1 111.86,169.78 C766.1 ; 81.29,97.46 81.29,97.61 81.41,97.73 ; v1(72.8,99.9) 73.08,100.18 74.61,100.18 R70.1
  BOTTOM w0.406: R799.1 114.19,172.57 v1(113.74,173.02)
  BOTTOM w0.457: v1(132.67,167.48) 133.03,167.12 R1211.2 ; v1(135.92,40.95) 135.08,40.95 133.35,39.23 R1204.2 R1203.2 R1202.2 R1201.2 ; v1(150.5,137.09) 150.57,137.01 C870.1 ; C871.1 v1(142.95,150.1) ; C865.1 140.04,135.13 v1(140.04,134.47) ; v1(152.07,139.98) C867.1 ; R701.1 106.08,171.93 106.5,171.52 107.32,171.52 v1(107.84,170.99) ; v1(152.05,145.22) 152.1,145.16 C866.1 ; v1(150.97,149.9) 151.26,150.19 C868.1 ; C888.1 152.28,139.22 v1(152.03,138.98) ; C869.1 146,149.99 v1(146.05,149.94) ; v1(149.37,149.9) 149.28,149.99 C881.1
  BOTTOM w0.508: R702.1 v1(121.47,172.51) ; v1(111.63,171.76) 112.32,171.76 R778.1 ; R326.1 v1(75.86,120.03) R327.1 ; R1291.2 131.3,35.54 v1(131.79,35.05) ; v1(130.29,162.92) 130.29,162.92 130.48,163.11 131.71,163.11 132.44,163.84 134.19,163.84 v1(134.51,164.15) ; R1056.2 154.85,37.92 v1(155.09,38.16) ; C379.2 183.68,99.74 v1(184.49,99.74) ; R145.2 106.9,181.36 106.31,180.77 v1(106.31,180.74) ; R1330.2 141.57,60.33 141.19,60.71 v1(140.81,60.71) ; C382.2 174.04,98.37 v1(173.83,98.16) ; R332.1 v1(71.8,117.95) ; 137,173.39 v1(137.08,173.32) ; 137,173.39 136.74,173.65 R706.1 137,173.39 ; v1(180.61,106.17) 180.61,105.86 180.49,105.75 C378.2 ; R1065.2 v1(148.76,40.49) ; C570.2 134.98,172.38 v1(134.73,172.63) ; v1(81.5,119.8) R339.1 ; v1(178.99,183.79) 178.71,184.07 R1307.1 ; R329.1 80.41,119.95 v1(80.39,119.98) R330.1 ; C443.1 176.89,158.61 v1(176.8,158.69) 176.31,158.2 C441.1 ; v1(25.78,134.39) 26.06,134.11 PR25.1 ; C395.1 53.35,149.82 v1(52.85,149.33) 52.77,149.41 C397.1 ; v1(143.4,57.46) 143.22,57.64 C599.1 ; R708.1 106.08,175.18 105.52,175.18 v1(105.38,175.32) ; 81.29,97.46 R90.1 ; v1(111.58,170.77) 111.58,170.43 111.09,169.94 C766.1 ; R743.1 v1(153.09,169.97) ; v1(184.46,103.58) 183.87,103.58 C377.1 ; R793.2 87.55,163.12 v1(87.51,163.08) ; v1(139.59,39.8) 139.32,40.07 R620.1 ; R776.1 144.48,30.61 v1(145.53,31.65) ; v1(74.54,120.01) 74.54,120.01 R316.1 ; v1(182.45,155.47) 181.79,154.8 R581.1 ; R686.1 v1(75.73,178.6) ; R331.1 v1(76.93,119.95) R338.1 ; C905.1 149.6,164.44 v1(149.56,164.49) ; v1(92.03,163.09) 91.45,162.51 C579.2 ; v1(77.19,97.76) 77.19,97.16 77.18,97.15 R86.1 ; C354.1 v1(156.78,58.88) ; R345.1 v1(78.23,120) R346.1 ; v1(147.15,165.22) 146.77,165.22 146.03,164.48 R1309.1 ; v1(151.74,61.96) 151.88,61.82 C353.1 152.38,61.81 C352.1 ; C396.1 56.81,149.85 v1(57.35,149.31) ; v1(30.79,101.07) 30.2,100.48 30.2,99.61 v1(30.84,98.96) 31.9,97.91 35.17,97.91 37.12,95.96 37.12,95.95 38.23,94.83 v1(38.23,94.83) 41.76,98.35 v1(41.76,99.05) ; v1(89.47,166.56) 89.57,166.56 89.59,166.57 90.3,166.57 R791.2 R782.2 ; v1(117.33,179.7) 116.83,180.2 116.83,180.89 116.33,181.39 115.09,181.39 114.28,180.58 v1(114.28,180.5) ; R790.2 v1(89.83,167.43) ; R152.2 78.25,97.59 v1(78.49,97.84) ; R124.1 v1(59,97.5) ; C571.2 117.81,173.53 v1(116.74,173.53) ; C598.1 v1(148.82,54.21) ; v1(153.56,69.81) 153.55,69.8 C351.1 ; v1(176.75,105.97) 176.75,105.34 C381.2 ; v1(81.5,97.82) 81.41,97.73 ; R324.1 v1(79.32,120.03) R335.1 ; C398.1 61.32,158.25 v1(62.1,159.04) 61.85,159.29 C394.1 ; U71.5 114.87,165.25 114.95,165.17 C576.1 115.86,165.17 116.09,164.94 v1(116.41,164.94) ; 179.13,172.9 179.15,172.88 C918.1 v1(180.96,172.88) ; R685.1 v1(89.83,169.46) ; R812.2 104.72,181.89 v1(105.34,181.27) 105.74,181.67 R1196.2 ; R779.2 v1(89.83,168.44) ; R734.1 v1(153.09,168.95) ; R1138.1 v1(139.28,41.21) ; C444.1 167.8,148.73 v1(167.55,148.98) 167.55,149.29 168.03,149.77 C442.1 ; v1(110.12,168.93) 110.12,168.2 109.97,167.95 R766.2 ; v1(101.92,169.45) 102.43,168.94 C568.2 ; R1289.2 v1(128.62,50.93) ; C440.1 172.84,158.17 v1(172.3,158.71) ; R323.1 v1(73.48,120.03) 73.5,120.01 R319.1 ; v1(119.47,175.35) 119.22,175.1 R704.1 ; L14.2 75.56,147.07 76.05,147.56 v1(76.05,147.86) ; R1288.2 v1(133.44,53.98) ; R140.2 69.47,97.46 69.47,98.06 68.97,98.56 v1(68.96,98.56) ; C380.2 180.67,96.16 v1(180.28,95.77) ; R1329.2 v1(143.79,43.31) ; R551.1 v1(48.42,145.57) ; R1308.1 v1(178.55,185.08) ; v1(162.69,168.61) C572.2
  vias: v1(32.74,146.79) v1(32.86,141.44) v1(32.9,142.43) v1(33.12,147.99) v1(33.66,148.64) v1(33.62,143.07) v1(34.44,144.3) v1(50.59,97.93) v1(54.02,98.03) v1(55.7,98.14) v1(57.41,98.66) v1(66.09,121.68) v1(66.75,121.73) v1(67.74,124.3) v1(68.47,124.3) v1(71.29,120.03) v1(72.39,120) v1(74.84,83.23) v1(82,122.74) v1(84.34,98.24) v1(86.04,97.91) v1(89.04,95.05) v1(91.78,85.3) v1(92.64,7.35) v1(92.64,2.78) v1(93.98,2.48) v1(94.16,3.14) v1(94.3,7.32) v1(94.3,6.56) v1(94.3,5.03) v1(94.3,4.27) v1(95.12,8.09) v1(103.87,165.8) v1(103.87,163.87) v1(103.89,167.27) v1(110.9,5.22) v1(111.75,5.22) v1(127.18,47.16) v1(127.54,46.61) v1(128.23,46.61) v1(138.53,171.53) v1(138.75,169.75) v1(139.97,167.56) v1(140.26,166.9) v1(145.79,170.76) v1(148.97,170.21) v1(151.67,103.44) v1(152.55,103.44) v1(152.68,104.25) v1(155.81,159.39) v1(159.24,36.4) v1(159.4,37.82) v1(159.48,35.14) v1(160.36,36.73) v1(161.62,25.14) v1(161.72,26.41) v1(162.5,25.56) v1(162.87,26.35) v1(163.24,25.11) v1(163.96,25.91) v1(164.78,23.89) v1(165.23,23.25) v1(165.59,24.1) v1(168.9,92.08) v1(169.57,92.55) v1(170.43,24.67) v1(170.46,22.97) v1(170.46,22.13) v1(170.48,23.79) v1(170.53,21.14) v1(170.75,90.88) v1(171.08,25.22) v1(171.08,23.35) v1(171.12,24.41) v1(171.13,22.48) v1(171.13,21.62) v1(172.93,108.51) v1(173.22,107.94) v1(185.9,199.81) v1(195.03,141.98) v1(195.77,141.96) v1(196.48,141.99) v1(197.11,141.97) v1(197.77,141.98) v2(73.11,139.49) v2(83.6,134.96)
P3V3_NODE1_FB: length 4.3
  TOP w0.254: PU5.1 80.29,7.2 80.06,7.42 v1(79.62,7.42) PR21.1 78.79,7.67 78.12,8.33 PC53.1 PR20.1
P3V3_NODE1_SS: length 2.4
  TOP w0.254: PC52.2 79.21,5 v1(79.54,5.33) 79.54,5.59 80.15,6.2 PU5.3
P3V3_NODE1_VREG5: length 7
  TOP w0.254: PR18.1 79.51,2.54 79.07,2.98 79.06,2.98 v1(78.82,3.22) 78.21,3.83 78.21,5.15 78.9,5.84 PC51.1 78.99,6.42 79.66,6.42 79.93,6.7 PU5.2
P3V3_RTC_NODE1: length 195
  TOP w0.508: R175.2 173.8,116.3 v1(173.35,115.86) ; v1(93.6,90.86) 93.44,91.03 92.4,91.03 R163.2 ; v1(99.59,82.74) 100.84,82.74 101.02,82.55 104.1,82.55 104.34,82.31 104.39,82.31 104.46,82.24 104.59,82.24 105.77,81.06 v1(105.77,80.45) 108.37,80.45 108.44,80.38 114.11,80.38 114.95,81.22 122.07,81.22 125.83,77.45 125.83,72.51 v1(125.29,71.96) 125.71,71.54 127.06,71.54 v1(127.07,71.54) 127.07,71.54 U3.3 ; v1(125.45,37.32) 125.56,37.32 133.54,29.34 D6.1
  IN1 w0.508: v1(125.29,71.96) 124.98,71.65 124.98,68.43 124.95,68.41 124.95,67.29 125.43,66.81 125.43,60.43 125.13,60.14 125.13,57.5 v1(124.43,56.8)
  IN2 w0.508: v1(98.88,82.74) v1(99.59,82.74) 99.59,82.34 98.46,81.21 96.24,81.21 96.04,81.02 86.02,81.02 85.54,80.54 77.16,80.54 76.39,81.3 75.68,81.3 74.97,82.02 v1(74.97,82.02)
  IN3 w0.508: v1(173.35,115.86) 171.7,115.86 169.23,113.39 169.23,112.21 153.75,96.73 145.65,96.73 144.97,96.05 141.78,96.05 127.98,82.26 127.98,75.74 127.14,74.91 127.03,74.91 126.66,74.54 126.66,72.89 127.04,72.52 127.04,71.57 v1(127.07,71.54) ; v1(125.45,37.32) 124.34,37.32 123.75,37.9 123.75,47.9 124.43,48.58 v1(124.43,56.8)
  BOTTOM w0.508: R143.2 90.29,85.32 v1(90.57,85.59) 91.14,86.16 C33.1
P3V3_STB_NODE1: length 382.5
  TOP w0.254: PC18.1 71.68,111.76 71.68,113.29 71.29,113.68 65.35,113.68 62.65,116.39 61.29,116.39 60.6,117.07 55.55,117.07 54.27,115.8 54.27,113.77 54.69,113.36 PR7.2 PC21.2 56.91,112.03 57.14,111.8 PU2.16
  TOP w0.406: R1218.1 v1(174.62,72.4)
  TOP w0.457: U102.G4 v5(190.54,121.87) ; R1034.1 200.76,122.84 200.79,122.81 v1(200.79,122.81) ; v1(102.92,135.78) 102.74,135.96 102.74,137.79 102.93,137.98 R1084.1 ; R1035.1 v1(200.85,121.66)
  TOP w0.508: R1046.2 v1(193.09,131.99) ; R1131.2 189.14,133.02 v1(189.44,133.32) ; R1100.2 95.09,108.1 v1(95.42,107.77) ; v1(100.34,163.14) 100.89,163.14 101.37,163.62 R801.2 ; v1(83.34,100.04) 83.34,100.04 83.12,100.26 82.59,100.26 ; v1(115.34,183.74) 114.15,182.55 109.47,182.55 v1(107.58,180.66) ; U102.G6 v5(187.54,122.87) ; R1091.2 82.59,100.26 ; 82.59,100.26 R1092.2 ; R1121.2 v1(194.74,131) ; R800.2 104.89,159.43 v1(104.37,159.95) ; U102.F4 v5(190.54,121.87) ; R1116.2 v1(44.13,118.55) 44.13,119.42 v1(44.1,119.45) 44.22,119.57 R1117.2 44.98,120.52 46.67,122.21 46.67,122.43 v1(46.7,122.43) ; v1(170.22,138.88) C565.1 169.5,138.88 169.5,138.38 169.24,138.12 U58.5 ; v1(128.87,62.47) 128.96,62.56 R223.2 ; v1(145.37,25.24) R1147.1 ; R1053.2 v1(184.3,136.34) ; R1108.2 v1(71.36,165.74) ; R1113.2 v1(76.75,106.1) ; v1(96.98,108.88) 96.66,109.2 R1101.2 ; R1149.1 v1(147.4,25.55) ; v1(146.39,25.34) R1148.1 ; R1087.1 v1(44.81,108.1) ; C799.1 v1(191.93,139.65) ; U102.D6 v5(187.54,118.87) ; R1140.1 v1(139.28,25.44) ; R1032.1 v1(175.06,131.25) ; R1059.2 v1(132.25,155.75) ; R1041.2 v1(191.8,129.58) ; U102.F7 v5(186.54,121.87) ; R1109.2 v1(73.42,165.75) ; R1036.1 v1(186.44,131.88) ; U102.E4 v5(190.54,119.87) ; R802.2 v1(123.8,154.57) ; R1112.2 v1(77.77,106.07) ; U102.D4 v5(190.54,118.87) ; R1142.1 v1(140.29,25.36) ; R1144.1 v1(142.32,25.51) ; U3.1 v1(131.87,68.06) ; R1094.1 v1(39.97,131.96) ; R1031.1 v1(177.49,123.77) ; R1096.2 v1(98.65,136.61) ; R1062.2 v1(163.56,136.17) ; R1145.1 v1(143.34,25.48) ; U102.E7 v5(186.54,119.87) ; R1141.1 v1(141.31,25.39) ; R1146.1 v1(144.36,25.51) ; R1143.1 v1(138.26,25.39) ; U106.5 v1(186.58,137.05)
  IN1 w0.508: v1(47.42,121.44) 47.42,118.63 42.33,113.55 42.33,108.6 42.83,108.1 v1(44.81,108.1)
  IN3 w0.508: 73.42,165.75 73.42,165.9 72.69,165.17 71.95,165.17 71.38,165.74 v1(71.36,165.74) ; 73.42,165.75 73.56,165.9 77.75,165.9 79.5,164.15 82.82,164.15 86.91,160.05 92.21,160.05 92.43,159.83 102.79,159.83 102.97,160.01 104.31,160.01 104.37,159.95 ; 73.42,165.75 v1(73.42,165.75) ; v1(123.6,160.27) 116.3,160.27 115.45,161.13 114.92,161.13 114.45,160.65 109.7,160.65 109.06,160.01 104.43,160.01 104.37,159.95 ; v1(115.15,65.15) 115.65,65.65 115.65,68.59 v1(114.97,69.27) ; 104.37,159.95 v1(104.37,159.95) ; v1(117.39,177.03) 117.61,177.03 118.29,176.35 118.29,175.46 119.74,174.01 120.44,174.01 121.24,173.21 124.49,173.21 126.25,174.97 134.76,174.97 135.36,175.56 137.49,175.56 v1(137.59,175.67) ; v1(107.58,180.66) 108.5,181.58 109.82,181.58 110.15,181.25 110.15,175.24 110.91,174.48 v1(111.26,174.48)
  BOTTOM w0.508: v1(50.28,5.33) 50.12,5.17 v1(49.21,5.17) ; R226.1 v1(114.97,69.27) ; R1060.2 114.29,182.58 115.34,183.63 v1(115.34,183.74) ; v1(111.26,174.48) 111.72,174.02 111.72,172.79 110.9,171.97 110.9,171.25 109.41,169.76 109.41,169.19 108.71,168.49 108.47,168.49 106.85,166.87 106.85,163.72 107,163.57 107,162.59 v1(104.37,159.95) 104.22,159.8 101.19,159.8 99.17,161.82 99.17,162.34 99.93,163.09 100.29,163.09 v1(100.34,163.14) ; v1(117.39,177.03) 117.53,177.17 R803.2 ; R220.1 v1(115.15,65.15) ; v1(104.12,91.81) 103.49,92.44 103.49,93.43 102.58,94.33 100.6,94.33 v1(99.92,95.02) ; v1(49.21,5.17) 49.21,5.3 48.84,5.68 46.02,5.68 43.67,8.03 43.67,15.29 46.35,17.96 54.79,17.96 55.28,18.46 76.78,18.46 78.41,16.82 102.63,16.82 103.1,16.36 103.1,15.02 104.1,14.02 115.76,14.02 122.24,20.5 124.32,20.5 124.59,20.77 127.55,20.77 v1(128.52,19.8) ; v1(49.21,5.17) 49.21,5.01 47.11,2.91 39.41,2.91 38.06,1.56 19.61,1.56 18.13,3.04 v1(18.13,3.3)
  vias: v1(67.53,112.41) v1(68.27,110.89) v1(68.38,112.34) v1(69.11,106.17) v1(69.19,112.39) v1(69.9,112.44) v1(70.17,110.89) v1(70.17,110.12) v1(70.17,108.6) v1(70.17,107.84) v1(70.13,106.56) v1(70.13,105.8) v1(70.93,112.33) v1(70.93,111.64) v1(92.97,101.51) v1(93.6,101.51) v1(94.24,101.51) v1(94.91,101.53) v1(129.26,19.88) v1(185.93,136.12) v1(187.3,136.09) v1(188.35,136.18)
