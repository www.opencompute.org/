# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
HEADER1X2AXC
  rect 1.549x1.549 hole 1.041: 1(0,0)
  round 1.549 hole 1.041: 2(0,-2.54)
HEADER1X2RXC
  rect 1.524x1.524 hole 1.016: 1(1.27,0)
  round 1.524 hole 1.016: 2(-1.27,0)
HEADER1X2XG
  rect 1.727x1.727 hole 1.219: 1(-1.27,0)
  round 1.727 hole 1.219: 2(1.27,0)
HEADER1X4BHXA
  round 1.194 hole 1.194 unplated: (-3,0.9)
  rect 1.321x1.321 hole 0.914: 1(3,-0.9)
  round 1.321 hole 0.914: 2(1,-0.9) 3(-1,-0.9) 4(-3,-0.9)
HEADER2X5XB
  rect 1.676x1.676 hole 1.168: 1(-5.08,-1.27)
  round 1.676 hole 1.168: 2(-5.08,1.27) 3(-2.54,-1.27) 4(-2.54,1.27) 5(0,-1.27) 6(0,1.27) 7(2.54,-1.27) 8(2.54,1.27) 9(5.08,-1.27) 10(5.08,1.27)
HEADER2X7SBHR
  round 1.067 hole 1.067 unplated: (0,5) (0,-5)
  rect 2.769x1.016 smd: 1(-2.125,6) 2(2.125,6) 3(-2.125,4) 4(2.125,4) 5(-2.125,2) 6(2.125,2) 7(-2.125,0) 8(2.125,0) 9(-2.125,-2) 10(2.125,-2) 11(-2.125,-4) 12(2.125,-4) 13(-2.125,-6) 14(2.125,-6)
HOLE_C7-77D5-41_BM_T94
  round 7.772 hole 5.41: 1(0,0)
HOLE_C12D3-6_7B12_OB5XC6N
  round 3.607 hole 3.607 unplated: (0,0)
HOLE_C12D3-8_7B12_OB5XC6N
  round 3.81 hole 3.81 unplated: (0,0)
HOLE_D3N
  round 2.997 hole 2.997 unplated: (0,0)
L0402
  rect 0.457x0.508 smd: 1(0.4,0) 2(-0.4,0)
L0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
L0805
  rect 1.118x1.372 smd: 1(0.95,0) 2(-0.95,0)
L0805XA
  rect 1.016x0.813 smd: 1(0,0.9) 2(0,-0.9)
L_MMD-06CZ_4P
  rect 3.429x1.829 smd: 1A(0,0) 2A(0,-5.54)
  rect 0.508x0.254 smd: 1B(0,-0.788) 2B(0,-4.753)
L_PCMC063T
  rect 3.302x2.154 smd: 1(0,2.925) 2(0,-2.925)
L_WCM3216F2S
  rect 0.61x0.914 smd: 1(-0.5,1.4) 2(-0.5,-1.4) 3(0.5,-1.4) 4(0.5,1.4)
LED_1921
  rect 0.813x0.813 smd: A(-0.75,0) C(0.75,0)
LED_1921XA
  rect 0.813x0.813 smd: A(-0.75,0) C(0.75,0)
LED_L150A9VS
  rect 1.524x1.524 hole 1.016: 1(-1.27,-2.54)
  round 1.524 hole 1.016: 2(0,0) 3(1.27,-2.54)
LQFP128XB
  rect 0.178x1.524 smd: 1(-6.2,-7.75) 2(-5.8,-7.75) 3(-5.4,-7.75) 4(-5,-7.75) 5(-4.6,-7.75) 6(-4.2,-7.75) 7(-3.8,-7.75) 8(-3.4,-7.75) 9(-3,-7.75) 10(-2.6,-7.75) 11(-2.2,-7.75) 12(-1.8,-7.75) 13(-1.4,-7.75) 14(-1,-7.75) 15(-0.6,-7.75) 16(-0.2,-7.75) 17(0.2,-7.75) 18(0.6,-7.75) 19(1,-7.75) 20(1.4,-7.75) 21(1.8,-7.75) 22(2.2,-7.75) 23(2.6,-7.75) 24(3,-7.75) 25(3.4,-7.75) 26(3.8,-7.75) 27(4.2,-7.75) 28(4.6,-7.75) 29(5,-7.75) 30(5.4,-7.75) 31(5.8,-7.75) 32(6.2,-7.75) 65(6.2,7.75) 66(5.8,7.75) 67(5.4,7.75) 68(5,7.75) 69(4.6,7.75) 70(4.2,7.75) 71(3.8,7.75) 72(3.4,7.75) 73(3,7.75) 74(2.6,7.75) 75(2.2,7.75) 76(1.8,7.75) 77(1.4,7.75) 78(1,7.75) 79(0.6,7.75) 80(0.2,7.75) 81(-0.2,7.75) 82(-0.6,7.75) 83(-1,7.75) 84(-1.4,7.75) 85(-1.8,7.75) 86(-2.2,7.75) 87(-2.6,7.75) 88(-3,7.75) 89(-3.4,7.75) 90(-3.8,7.75) 91(-4.2,7.75) 92(-4.6,7.75) 93(-5,7.75) 94(-5.4,7.75) 95(-5.8,7.75) 96(-6.2,7.75)
  rect 1.524x0.178 smd: 33(7.75,-6.2) 34(7.75,-5.8) 35(7.75,-5.4) 36(7.75,-5) 37(7.75,-4.6) 38(7.75,-4.2) 39(7.75,-3.8) 40(7.75,-3.4) 41(7.75,-3) 42(7.75,-2.6) 43(7.75,-2.2) 44(7.75,-1.8) 45(7.75,-1.4) 46(7.75,-1) 47(7.75,-0.6) 48(7.75,-0.2) 49(7.75,0.2) 50(7.75,0.6) 51(7.75,1) 52(7.75,1.4) 53(7.75,1.8) 54(7.75,2.2) 55(7.75,2.6) 56(7.75,3) 57(7.75,3.4) 58(7.75,3.8) 59(7.75,4.2) 60(7.75,4.6) 61(7.75,5) 62(7.75,5.4) 63(7.75,5.8) 64(7.75,6.2) 97(-7.75,6.2) 98(-7.75,5.8) 99(-7.75,5.4) 100(-7.75,5) 101(-7.75,4.6) 102(-7.75,4.2) 103(-7.75,3.8) 104(-7.75,3.4) 105(-7.75,3) 106(-7.75,2.6) 107(-7.75,2.2) 108(-7.75,1.8) 109(-7.75,1.4) 110(-7.75,1) 111(-7.75,0.6) 112(-7.75,0.2) 113(-7.75,-0.2) 114(-7.75,-0.6) 115(-7.75,-1) 116(-7.75,-1.4) 117(-7.75,-1.8) 118(-7.75,-2.2) 119(-7.75,-2.6) 120(-7.75,-3) 121(-7.75,-3.4) 122(-7.75,-3.8) 123(-7.75,-4.2) 124(-7.75,-4.6) 125(-7.75,-5) 126(-7.75,-5.4) 127(-7.75,-5.8) 128(-7.75,-6.2)
MPL8_TH
  rect 0.559x0.432 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 8(4.182,0)
  custom 0.144x0.144 smd: 5-6-7(4.182,-1.3)
  rect 0.838x2.515 smd: D1_EP(0.902,-0.975)
  rect 2.032x2.515 smd: S1/D2_EP(2.675,-0.975)
MSOP10
  rect 0.279x1.448 smd: 1(-1,-2.225) 2(-0.5,-2.225) 3(0,-2.225) 4(0.5,-2.225) 5(1,-2.225) 6(1,2.225) 7(0.5,2.225) 8(0,2.225) 9(-0.5,2.225) 10(-1,2.225)
OSC4_7W
  rect 1.422x1.118 smd: 1(-2.54,-1.85) 2(2.54,-1.85) 3(2.54,1.85) 4(-2.54,1.85)
OSC4_SCO3225C
  rect 0.965x1.219 smd: 1(0,0) 2(0,-2.2) 3(1.75,-2.2) 4(1.75,0)
PICOPROBE_B
  round 0.254 hole 1.27 unplated: (0,4.572) (0,0) (4.064,4.572) (4.064,0)
  custom 0.267x0.267 hole 0.254: 1(1.397,2.286)
  rect 0.305x0.203 smd: 2(2.032,2.061) 3(2.032,2.511)
POWER56XA
  rect 0.762x1.041 smd: 1(-1.905,-3.01) 2(-0.635,-3.01) 3(0.635,-3.01) 4(1.905,-3.01) 5(1.905,3.01) 6(0.635,3.01) 7(-0.635,3.01) 8(-1.905,3.01)
  rect 4.216x0.813 smd: D1_EP(0,-1.7)
  rect 4.216x2.921 smd: S1/D2_EP(0,0.65)
QFN16_THXG
  rect 0.914x0.279 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 9(3.1,-1.5) 10(3.1,-1) 11(3.1,-0.5) 12(3.1,0)
  rect 0.279x0.914 smd: 5(0.8,-2.3) 6(1.3,-2.3) 7(1.8,-2.3) 8(2.3,-2.3) 13(2.3,0.8) 14(1.8,0.8) 15(1.3,0.8) 16(0.8,0.8)
  rect 1.651x1.651 smd: TH(1.55,-0.75)
QFN16_THXI
  rect 0.838x0.254 smd: 1(-1.475,0.75) 2(-1.475,0.25) 3(-1.475,-0.25) 4(-1.475,-0.75) 9(1.475,-0.75) 10(1.475,-0.25) 11(1.475,0.25) 12(1.475,0.75)
  rect 0.254x0.838 smd: 5(-0.75,-1.475) 6(-0.25,-1.475) 7(0.25,-1.475) 8(0.75,-1.475) 13(0.75,1.475) 14(0.25,1.475) 15(-0.25,1.475) 16(-0.75,1.475)
  rect 1.702x1.702 smd: TH(0,0)
QFN16_THXJ
  oval 0.711x0.381 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 9(3.52,-1.95) 10(3.52,-1.3) 11(3.52,-0.65) 12(3.52,0)
  oval 0.381x0.711 smd: 5(0.785,-2.735) 6(1.435,-2.735) 7(2.085,-2.735) 8(2.735,-2.735) 13(2.735,0.785) 14(2.085,0.785) 15(1.435,0.785) 16(0.785,0.785)
  rect 2.108x2.108 smd: TH(1.76,-0.975)
QFN20_THXH
  rect 0.914x0.178 smd: 1(0.317,-0.292) 2(0.317,-0.692) 3(0.317,-1.092) 4(0.317,-1.492) 5(0.317,-1.892) 11(3.442,-1.892) 12(3.442,-1.492) 13(3.442,-1.092) 14(3.442,-0.692) 15(3.442,-0.292)
  rect 0.178x0.914 smd: 6(1.079,-2.655) 7(1.48,-2.655) 8(1.88,-2.655) 9(2.28,-2.655) 10(2.68,-2.655) 16(2.68,0.471) 17(2.28,0.471) 18(1.88,0.471) 19(1.48,0.471) 20(1.079,0.471)
  rect 1.803x1.803 smd: TH(1.88,-1.092)
QFN40_THXJ
  rect 0.914x0.178 smd: 1(-2.543,1.8) 10(-2.543,-1.8) 21(2.543,-1.8) 30(2.543,1.8)
  rect 0.965x0.178 smd: 2(-2.525,1.4) 3(-2.525,1) 4(-2.525,0.6) 5(-2.525,0.2) 6(-2.525,-0.2) 7(-2.525,-0.6) 8(-2.525,-1) 9(-2.525,-1.4) 22(2.525,-1.4) 23(2.525,-1) 24(2.525,-0.6) 25(2.525,-0.2) 26(2.525,0.2) 27(2.525,0.6) 28(2.525,1) 29(2.525,1.4)
  rect 0.178x0.914 smd: 11(-1.8,-2.543) 20(1.8,-2.543) 31(1.8,2.543) 40(-1.8,2.543)
  rect 0.178x0.965 smd: 12(-1.4,-2.525) 13(-1,-2.525) 14(-0.6,-2.525) 15(-0.2,-2.525) 16(0.2,-2.525) 17(0.6,-2.525) 18(1,-2.525) 19(1.4,-2.525) 32(1.4,2.525) 33(1,2.525) 34(0.6,2.525) 35(0.2,2.525) 36(-0.2,2.525) 37(-0.6,2.525) 38(-1,2.525) 39(-1.4,2.525)
  rect 3.404x3.404 smd: TH(0,0)
QFN56_THXL
  rect 0.889x0.178 smd: 1(-3.55,2.6) 2(-3.55,2.2) 3(-3.55,1.8) 4(-3.55,1.4) 5(-3.55,1) 6(-3.55,0.6) 7(-3.55,0.2) 8(-3.55,-0.2) 9(-3.55,-0.6) 10(-3.55,-1) 11(-3.55,-1.4) 12(-3.55,-1.8) 13(-3.55,-2.2) 14(-3.55,-2.6) 29(3.55,-2.6) 30(3.55,-2.2) 31(3.55,-1.8) 32(3.55,-1.4) 33(3.55,-1) 34(3.55,-0.6) 35(3.55,-0.2) 36(3.55,0.2) 37(3.55,0.6) 38(3.55,1) 39(3.55,1.4) 40(3.55,1.8) 41(3.55,2.2) 42(3.55,2.6)
  rect 0.178x0.889 smd: 15(-2.6,-3.55) 16(-2.2,-3.55) 17(-1.8,-3.55) 18(-1.4,-3.55) 19(-1,-3.55) 20(-0.6,-3.55) 21(-0.2,-3.55) 22(0.2,-3.55) 23(0.6,-3.55) 24(1,-3.55) 25(1.4,-3.55) 26(1.8,-3.55) 27(2.2,-3.55) 28(2.6,-3.55) 43(2.6,3.55) 44(2.2,3.55) 45(1.8,3.55) 46(1.4,3.55) 47(1,3.55) 48(0.6,3.55) 49(0.2,3.55) 50(-0.2,3.55) 51(-0.6,3.55) 52(-1,3.55) 53(-1.4,3.55) 54(-1.8,3.55) 55(-2.2,3.55) 56(-2.6,3.55)
  rect 5.791x5.791 smd: TH(0,0)
QFN64_THXD
  rect 0.914x0.254 smd: 1(-4.55,3.75) 2(-4.55,3.25) 3(-4.55,2.75) 4(-4.55,2.25) 5(-4.55,1.75) 6(-4.55,1.25) 7(-4.55,0.75) 8(-4.55,0.25) 9(-4.55,-0.25) 10(-4.55,-0.75) 11(-4.55,-1.25) 12(-4.55,-1.75) 13(-4.55,-2.25) 14(-4.55,-2.75) 15(-4.55,-3.25) 16(-4.55,-3.75) 33(4.55,-3.75) 34(4.55,-3.25) 35(4.55,-2.75) 36(4.55,-2.25) 37(4.55,-1.75) 38(4.55,-1.25) 39(4.55,-0.75) 40(4.55,-0.25) 41(4.55,0.25) 42(4.55,0.75) 43(4.55,1.25) 44(4.55,1.75) 45(4.55,2.25) 46(4.55,2.75) 47(4.55,3.25) 48(4.55,3.75)
  rect 0.254x0.914 smd: 17(-3.75,-4.55) 18(-3.25,-4.55) 19(-2.75,-4.55) 20(-2.25,-4.55) 21(-1.75,-4.55) 22(-1.25,-4.55) 23(-0.75,-4.55) 24(-0.25,-4.55) 25(0.25,-4.55) 26(0.75,-4.55) 27(1.25,-4.55) 28(1.75,-4.55) 29(2.25,-4.55) 30(2.75,-4.55) 31(3.25,-4.55) 32(3.75,-4.55) 49(3.75,4.55) 50(3.25,4.55) 51(2.75,4.55) 52(2.25,4.55) 53(1.75,4.55) 54(1.25,4.55) 55(0.75,4.55) 56(0.25,4.55) 57(-0.25,4.55) 58(-0.75,4.55) 59(-1.25,4.55) 60(-1.75,4.55) 61(-2.25,4.55) 62(-2.75,4.55) 63(-3.25,4.55) 64(-3.75,4.55)
  rect 5.41x5.41 smd: TH(0,0)
QFN68_THXB
  rect 1.016x0.178 smd: 1(-3.992,3.2) 17(-3.992,-3.2) 35(3.992,-3.2) 51(3.992,3.2)
  rect 1.194x0.178 smd: 2(-3.903,2.8) 3(-3.903,2.4) 4(-3.903,2) 5(-3.903,1.6) 6(-3.903,1.2) 7(-3.903,0.8) 8(-3.903,0.4) 9(-3.903,0) 10(-3.903,-0.4) 11(-3.903,-0.8) 12(-3.903,-1.2) 13(-3.903,-1.6) 14(-3.903,-2) 15(-3.903,-2.4) 16(-3.903,-2.8) 36(3.903,-2.8) 37(3.903,-2.4) 38(3.903,-2) 39(3.903,-1.6) 40(3.903,-1.2) 41(3.903,-0.8) 42(3.903,-0.4) 43(3.903,0) 44(3.903,0.4) 45(3.903,0.8) 46(3.903,1.2) 47(3.903,1.6) 48(3.903,2) 49(3.903,2.4) 50(3.903,2.8)
  rect 0.178x1.016 smd: 18(-3.2,-3.992) 34(3.2,-3.992) 52(3.2,3.992) 68(-3.2,3.992)
  rect 0.178x1.194 smd: 19(-2.8,-3.903) 20(-2.4,-3.903) 21(-2,-3.903) 22(-1.6,-3.903) 23(-1.2,-3.903) 24(-0.8,-3.903) 25(-0.4,-3.903) 26(0,-3.903) 27(0.4,-3.903) 28(0.8,-3.903) 29(1.2,-3.903) 30(1.6,-3.903) 31(2,-3.903) 32(2.4,-3.903) 33(2.8,-3.903) 53(2.8,3.903) 54(2.4,3.903) 55(2,3.903) 56(1.6,3.903) 57(1.2,3.903) 58(0.8,3.903) 59(0.4,3.903) 60(0,3.903) 61(-0.4,3.903) 62(-0.8,3.903) 63(-1.2,3.903) 64(-1.6,3.903) 65(-2,3.903) 66(-2.4,3.903) 67(-2.8,3.903)
  rect 6.198x6.198 smd: TH(0,0)
QFN76_THXA
  rect 1.118x0.178 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 39(8.882,-7.2) 40(8.882,-6.8) 41(8.882,-6.4) 42(8.882,-6) 43(8.882,-5.6) 44(8.882,-5.2) 45(8.882,-4.8) 46(8.882,-4.4) 47(8.882,-4) 48(8.882,-3.6) 49(8.882,-3.2) 50(8.882,-2.8) 51(8.882,-2.4) 52(8.882,-2) 53(8.882,-1.6) 54(8.882,-1.2) 55(8.882,-0.8) 56(8.882,-0.4) 57(8.882,0)
  rect 0.178x1.118 smd: 20(0.841,-8.041) 21(1.241,-8.041) 22(1.641,-8.041) 23(2.041,-8.041) 24(2.441,-8.041) 25(2.841,-8.041) 26(3.241,-8.041) 27(3.641,-8.041) 28(4.041,-8.041) 29(4.441,-8.041) 30(4.841,-8.041) 31(5.241,-8.041) 32(5.641,-8.041) 33(6.041,-8.041) 34(6.441,-8.041) 35(6.841,-8.041) 36(7.241,-8.041) 37(7.641,-8.041) 38(8.041,-8.041) 58(8.041,0.841) 59(7.641,0.841) 60(7.241,0.841) 61(6.841,0.841) 62(6.441,0.841) 63(6.041,0.841) 64(5.641,0.841) 65(5.241,0.841) 66(4.841,0.841) 67(4.441,0.841) 68(4.041,0.841) 69(3.641,0.841) 70(3.241,0.841) 71(2.841,0.841) 72(2.441,0.841) 73(2.041,0.841) 74(1.641,0.841) 75(1.241,0.841) 76(0.841,0.841)
  rect 3.962x3.962 smd: TH(4.441,-3.6)
QFP128
  rect 1.803x0.279 smd: 1(-8.56,9.25) 2(-8.56,8.75) 3(-8.56,8.25) 4(-8.56,7.75) 5(-8.56,7.25) 6(-8.56,6.75) 7(-8.56,6.25) 8(-8.56,5.75) 9(-8.56,5.25) 10(-8.56,4.75) 11(-8.56,4.25) 12(-8.56,3.75) 13(-8.56,3.25) 14(-8.56,2.75) 15(-8.56,2.25) 16(-8.56,1.75) 17(-8.56,1.25) 18(-8.56,0.75) 19(-8.56,0.25) 20(-8.56,-0.25) 21(-8.56,-0.75) 22(-8.56,-1.25) 23(-8.56,-1.75) 24(-8.56,-2.25) 25(-8.56,-2.75) 26(-8.56,-3.25) 27(-8.56,-3.75) 28(-8.56,-4.25) 29(-8.56,-4.75) 30(-8.56,-5.25) 31(-8.56,-5.75) 32(-8.56,-6.25) 33(-8.56,-6.75) 34(-8.56,-7.25) 35(-8.56,-7.75) 36(-8.56,-8.25) 37(-8.56,-8.75) 38(-8.56,-9.25) 65(8.56,-9.25) 66(8.56,-8.75) 67(8.56,-8.25) 68(8.56,-7.75) 69(8.56,-7.25) 70(8.56,-6.75) 71(8.56,-6.25) 72(8.56,-5.75) 73(8.56,-5.25) 74(8.56,-4.75) 75(8.56,-4.25) 76(8.56,-3.75) 77(8.56,-3.25) 78(8.56,-2.75) 79(8.56,-2.25) 80(8.56,-1.75) 81(8.56,-1.25) 82(8.56,-0.75) 83(8.56,-0.25) 84(8.56,0.25) 85(8.56,0.75) 86(8.56,1.25) 87(8.56,1.75) 88(8.56,2.25) 89(8.56,2.75) 90(8.56,3.25) 91(8.56,3.75) 92(8.56,4.25) 93(8.56,4.75) 94(8.56,5.25) 95(8.56,5.75) 96(8.56,6.25) 97(8.56,6.75) 98(8.56,7.25) 99(8.56,7.75) 100(8.56,8.25) 101(8.56,8.75) 102(8.56,9.25)
  rect 0.279x1.803 smd: 39(-6.25,-11.56) 40(-5.75,-11.56) 41(-5.25,-11.56) 42(-4.75,-11.56) 43(-4.25,-11.56) 44(-3.75,-11.56) 45(-3.25,-11.56) 46(-2.75,-11.56) 47(-2.25,-11.56) 48(-1.75,-11.56) 49(-1.25,-11.56) 50(-0.75,-11.56) 51(-0.25,-11.56) 52(0.25,-11.56) 53(0.75,-11.56) 54(1.25,-11.56) 55(1.75,-11.56) 56(2.25,-11.56) 57(2.75,-11.56) 58(3.25,-11.56) 59(3.75,-11.56) 60(4.25,-11.56) 61(4.75,-11.56) 62(5.25,-11.56) 63(5.75,-11.56) 64(6.25,-11.56) 103(6.25,11.56) 104(5.75,11.56) 105(5.25,11.56) 106(4.75,11.56) 107(4.25,11.56) 108(3.75,11.56) 109(3.25,11.56) 110(2.75,11.56) 111(2.25,11.56) 112(1.75,11.56) 113(1.25,11.56) 114(0.75,11.56) 115(0.25,11.56) 116(-0.25,11.56) 117(-0.75,11.56) 118(-1.25,11.56) 119(-1.75,11.56) 120(-2.25,11.56) 121(-2.75,11.56) 122(-3.25,11.56) 123(-3.75,11.56) 124(-4.25,11.56) 125(-4.75,11.56) 126(-5.25,11.56) 127(-5.75,11.56) 128(-6.25,11.56)
QSOP16
  rect 0.356x1.549 smd: 1(-2.223,-2.743) 2(-1.587,-2.743) 3(-0.953,-2.743) 4(-0.318,-2.743) 5(0.318,-2.743) 6(0.953,-2.743) 7(1.587,-2.743) 8(2.223,-2.743) 9(2.223,2.743) 10(1.587,2.743) 11(0.953,2.743) 12(0.318,2.743) 13(-0.318,2.743) 14(-0.953,2.743) 15(-1.587,2.743) 16(-2.223,2.743)
R0402
  rect 0.457x0.508 smd: 1(0.4,0) 2(-0.4,0)
R0402XA
  rect 0.61x0.61 smd: 1(0,0) 2(0,-1.1)
R0603
  rect 0.813x0.711 smd: 1(0.737,0) 2(-0.737,0)
R0805
  rect 1.118x1.372 smd: 1(0.95,0) 2(-0.95,0)
R1206
  rect 1.168x1.575 smd: 1(1.473,0) 2(-1.473,0)
R2010
  rect 1.422x2.413 smd: 1(-2.35,0) 2(2.35,0)
SATA7XD
  rect 1.067x1.067 hole 0.66: 1(0,0)
  round 1.067 hole 0.66: 2(-1.5,-1.055) 3(-1.5,-2.755) 4(0,-3.81) 5(-1.5,-4.865) 6(-1.5,-6.565) 7(0,-7.62)
  round 1.93 hole 1.422: 8(0,2.46) 9(-1,-10.37)
SC70-5
  rect 0.33x1.168 smd: 1(-0.65,-0.962) 2(0,-0.962) 3(0.65,-0.962) 4(0.65,0.962) 5(-0.65,0.962)
SC70-6
  rect 0.356x1.118 smd: 1(-0.65,-1) 2(0,-1) 3(0.65,-1) 4(0.65,1) 5(0,1) 6(-0.65,1)
SC74AXA
  rect 0.457x1.321 smd: 1(-0.95,-1.225) 2(0,-1.225) 3(0.95,-1.225) 4(0.95,1.225) 5(-0.95,1.225)
SCONN60_C21100001_Q
  round 0.254 hole 1.194 unplated: (-10.06,2.666) (10.066,2.666)
  rect 0.279x2.286 smd: 1(-7.25,-2.864) 2(-7.25,2.864) 3(-6.75,-2.864) 4(-6.75,2.864) 5(-6.25,-2.864) 6(-6.25,2.864) 7(-5.75,-2.864) 8(-5.75,2.864) 9(-5.25,-2.864) 10(-5.25,2.864) 11(-4.75,-2.864) 12(-4.75,2.864) 13(-4.25,-2.864) 14(-4.25,2.864) 15(-3.75,-2.864) 16(-3.75,2.864) 17(-3.25,-2.864) 18(-3.25,2.864) 19(-2.75,-2.864) 20(-2.75,2.864) 21(-2.25,-2.864) 22(-2.25,2.864) 23(-1.75,-2.864) 24(-1.75,2.864) 25(-1.25,-2.864) 26(-1.25,2.864) 27(-0.75,-2.864) 28(-0.75,2.864) 29(-0.25,-2.864) 30(-0.25,2.864) 31(0.25,-2.864) 32(0.25,2.864) 33(0.75,-2.864) 34(0.75,2.864) 35(1.25,-2.864) 36(1.25,2.864) 37(1.75,-2.864) 38(1.75,2.864) 39(2.25,-2.864) 40(2.25,2.864) 41(2.75,-2.864) 42(2.75,2.864) 43(3.25,-2.864) 44(3.25,2.864) 45(3.75,-2.864) 46(3.75,2.864) 47(4.25,-2.864) 48(4.25,2.864) 49(4.75,-2.864) 50(4.75,2.864) 51(5.25,-2.864) 52(5.25,2.864) 53(5.75,-2.864) 54(5.75,2.864) 55(6.25,-2.864) 56(6.25,2.864) 57(6.75,-2.864) 58(6.75,2.864) 59(7.25,-2.864) 60(7.25,2.864)
SHORT_R0402
  custom 0.127x0.127 smd: 1(0,0)
  rect 0.508x0.457 smd: 2(0,-0.8)
SHORT_R0603
  custom 0.178x0.178 smd: 1(0,0)
  rect 0.711x0.813 smd: 2(0,-1.499)
SLP1006P2T
  rect 0.61x0.559 smd: A(0,0) C(0,0.85)
SOCKET8S
  rect 0.66x1.93 smd: 1(1.905,3.38) 2(0.635,3.38) 3(-0.635,3.38) 4(-1.905,3.38) 5(-1.905,-3.38) 6(-0.635,-3.38) 7(0.635,-3.38) 8(1.905,-3.38)
SOD106
  rect 1.524x2.032 smd: 1(-2.25,0) 2(2.25,0)
SOD323
  rect 0.813x0.864 smd: 1(-1.092,0) 2(1.092,0)
SOD323XF
  rect 0.914x0.813 smd: 1(0,1.07) 2(0,-1.07)
SOIC8
  rect 0.559x1.727 smd: 1(-1.905,-2.642) 2(-0.635,-2.642) 3(0.635,-2.642) 4(1.905,-2.642) 5(1.905,2.642) 6(0.635,2.642) 7(-0.635,2.642) 8(-1.905,2.642)
SOIC8_5-3XA
  rect 0.559x1.727 smd: 1(-1.905,-3.637) 2(-0.635,-3.637) 3(0.635,-3.637) 4(1.905,-3.637) 5(1.905,3.637) 6(0.635,3.637) 7(-0.635,3.637) 8(-1.905,3.637)
SOT23-5
  rect 0.559x1.346 smd: 1(-0.95,-1.225) 2(0,-1.225) 3(0.95,-1.225) 4(0.95,1.225) 5(-0.95,1.225)
SOT23-5XA
  rect 0.559x1.346 smd: 1(-0.95,-1.225) 2(0,-1.225) 3(0.95,-1.225) 4(0.95,1.225) 5(-0.95,1.225)
SOT23_123
  rect 1.016x1.27 smd: 1(-1.016,-1.118) 2(1.016,-1.118) 3(0,1.118)
SOT23_123XB
  rect 0.813x0.914 smd: 1(-0.95,-1) 2(0.95,-1) 3(0,1)
SOT23_123XE
  rect 0.711x0.61 smd: 1(-1,0.95) 2(-1,-0.95) 3(1,0)
SOT23_BECXA
  rect 0.914x0.813 smd: B(0,0) C(2,-0.95) E(0,-1.9)
SOT23_GDS
  rect 1.016x1.27 smd: D(0,1.118) G(-1.016,-1.118) S(1.016,-1.118)
SOT23_GDSXC
  rect 0.914x0.813 smd: D(1,0) G(-1,0.95) S(-1,-0.95)
SOT223
  rect 1.499x2.007 smd: 1(-2.286,-2.832) 2(0,-2.832) 3(2.286,-2.832)
  rect 3.81x2.007 smd: 4(0,2.832)
SOT363
  rect 0.406x0.508 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(0,0.95) 6(-0.65,0.95)
SOT457
  rect 0.406x1.321 smd: 1(-0.95,-1.225) 2(0,-1.225) 3(0.95,-1.225) 4(0.95,1.225) 5(0,1.225) 6(-0.95,1.225)
SOT1023
  rect 1.168x0.711 smd: 1(0,0) 2(0,-1.27) 3(0,-2.54) 4(0,-3.81)
  custom 1.15x1.15 smd: 5(3.925,-1.905)
SW_STS-02
  rect 3.2x1.016 smd: 1(-3.4,2) 2(3.4,2) 3(-3.4,-2) 4(3.4,-2)
TAJ_SX
  rect 2.819x2.413 smd: 1(0,3.2) 2(0,-3.2)
TP26D10
  round 0.508 hole 0.254: 1(0,0)
TP30
  round 0.762 smd: 1(0,0)
TQFP48
  rect 0.229x1.397 smd: 1(-2.75,-4.3) 2(-2.25,-4.3) 3(-1.75,-4.3) 4(-1.25,-4.3) 5(-0.75,-4.3) 6(-0.25,-4.3) 7(0.25,-4.3) 8(0.75,-4.3) 9(1.25,-4.3) 10(1.75,-4.3) 11(2.25,-4.3) 12(2.75,-4.3) 25(2.75,4.3) 26(2.25,4.3) 27(1.75,4.3) 28(1.25,4.3) 29(0.75,4.3) 30(0.25,4.3) 31(-0.25,4.3) 32(-0.75,4.3) 33(-1.25,4.3) 34(-1.75,4.3) 35(-2.25,4.3) 36(-2.75,4.3)
  rect 1.397x0.229 smd: 13(4.3,-2.75) 14(4.3,-2.25) 15(4.3,-1.75) 16(4.3,-1.25) 17(4.3,-0.75) 18(4.3,-0.25) 19(4.3,0.25) 20(4.3,0.75) 21(4.3,1.25) 22(4.3,1.75) 23(4.3,2.25) 24(4.3,2.75) 37(-4.3,2.75) 38(-4.3,2.25) 39(-4.3,1.75) 40(-4.3,1.25) 41(-4.3,0.75) 42(-4.3,0.25) 43(-4.3,-0.25) 44(-4.3,-0.75) 45(-4.3,-1.25) 46(-4.3,-1.75) 47(-4.3,-2.25) 48(-4.3,-2.75)
TQFP100_H56
  rect 1.499x0.279 smd: 1(-7.75,6) 2(-7.75,5.5) 3(-7.75,5) 4(-7.75,4.5) 5(-7.75,4) 6(-7.75,3.5) 7(-7.75,3) 8(-7.75,2.5) 9(-7.75,2) 10(-7.75,1.5) 11(-7.75,1) 12(-7.75,0.5) 13(-7.75,0) 14(-7.75,-0.5) 15(-7.75,-1) 16(-7.75,-1.5) 17(-7.75,-2) 18(-7.75,-2.5) 19(-7.75,-3) 20(-7.75,-3.5) 21(-7.75,-4) 22(-7.75,-4.5) 23(-7.75,-5) 24(-7.75,-5.5) 25(-7.75,-6) 51(7.75,-6) 52(7.75,-5.5) 53(7.75,-5) 54(7.75,-4.5) 55(7.75,-4) 56(7.75,-3.5) 57(7.75,-3) 58(7.75,-2.5) 59(7.75,-2) 60(7.75,-1.5) 61(7.75,-1) 62(7.75,-0.5) 63(7.75,0) 64(7.75,0.5) 65(7.75,1) 66(7.75,1.5) 67(7.75,2) 68(7.75,2.5) 69(7.75,3) 70(7.75,3.5) 71(7.75,4) 72(7.75,4.5) 73(7.75,5) 74(7.75,5.5) 75(7.75,6)
  rect 0.279x1.499 smd: 26(-6,-7.75) 27(-5.5,-7.75) 28(-5,-7.75) 29(-4.5,-7.75) 30(-4,-7.75) 31(-3.5,-7.75) 32(-3,-7.75) 33(-2.5,-7.75) 34(-2,-7.75) 35(-1.5,-7.75) 36(-1,-7.75) 37(-0.5,-7.75) 38(0,-7.75) 39(0.5,-7.75) 40(1,-7.75) 41(1.5,-7.75) 42(2,-7.75) 43(2.5,-7.75) 44(3,-7.75) 45(3.5,-7.75) 46(4,-7.75) 47(4.5,-7.75) 48(5,-7.75) 49(5.5,-7.75) 50(6,-7.75) 76(6,7.75) 77(5.5,7.75) 78(5,7.75) 79(4.5,7.75) 80(4,7.75) 81(3.5,7.75) 82(3,7.75) 83(2.5,7.75) 84(2,7.75) 85(1.5,7.75) 86(1,7.75) 87(0.5,7.75) 88(0,7.75) 89(-0.5,7.75) 90(-1,7.75) 91(-1.5,7.75) 92(-2,7.75) 93(-2.5,7.75) 94(-3,7.75) 95(-3.5,7.75) 96(-4,7.75) 97(-4.5,7.75) 98(-5,7.75) 99(-5.5,7.75) 100(-6,7.75)
TRF24_NA0069RLF
  rect 1.549x0.813 smd: 1(-4.475,6.985) 2(-4.475,5.715) 3(-4.475,4.445) 4(-4.475,3.175) 5(-4.475,1.905) 6(-4.475,0.635) 7(-4.475,-0.635) 8(-4.475,-1.905) 9(-4.475,-3.175) 10(-4.475,-4.445) 11(-4.475,-5.715) 12(-4.475,-6.985) 13(4.475,-6.985) 14(4.475,-5.715) 15(4.475,-4.445) 16(4.475,-3.175) 17(4.475,-1.905) 18(4.475,-0.635) 19(4.475,0.635) 20(4.475,1.905) 21(4.475,3.175) 22(4.475,4.445) 23(4.475,5.715) 24(4.475,6.985)
TSSOP8_3XA
  rect 1.321x0.432 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(3.7,-1.95) 6(3.7,-1.3) 7(3.7,-0.65) 8(3.7,0)
TSSOP16
  rect 0.356x1.499 smd: 1(-2.275,-2.921) 2(-1.625,-2.921) 3(-0.975,-2.921) 4(-0.325,-2.921) 5(0.325,-2.921) 6(0.975,-2.921) 7(1.625,-2.921) 8(2.275,-2.921) 9(2.275,2.921) 10(1.625,2.921) 11(0.975,2.921) 12(0.325,2.921) 13(-0.325,2.921) 14(-0.975,2.921) 15(-1.625,2.921) 16(-2.275,2.921)
TSSOP24
  rect 0.356x1.499 smd: 1(-3.575,-2.921) 2(-2.925,-2.921) 3(-2.275,-2.921) 4(-1.625,-2.921) 5(-0.975,-2.921) 6(-0.325,-2.921) 7(0.325,-2.921) 8(0.975,-2.921) 9(1.625,-2.921) 10(2.275,-2.921) 11(2.925,-2.921) 12(3.575,-2.921) 13(3.575,2.921) 14(2.925,2.921) 15(2.275,2.921) 16(1.625,2.921) 17(0.975,2.921) 18(0.325,2.921) 19(-0.325,2.921) 20(-0.975,2.921) 21(-1.625,2.921) 22(-2.275,2.921) 23(-2.925,2.921) 24(-3.575,2.921)
TSSOP28
  rect 0.356x1.499 smd: 1(-4.225,-2.921) 2(-3.575,-2.921) 3(-2.925,-2.921) 4(-2.275,-2.921) 5(-1.625,-2.921) 6(-0.975,-2.921) 7(-0.325,-2.921) 8(0.325,-2.921) 9(0.975,-2.921) 10(1.625,-2.921) 11(2.275,-2.921) 12(2.925,-2.921) 13(3.575,-2.921) 14(4.225,-2.921) 15(4.225,2.921) 16(3.575,2.921) 17(2.925,2.921) 18(2.275,2.921) 19(1.625,2.921) 20(0.975,2.921) 21(0.325,2.921) 22(-0.325,2.921) 23(-0.975,2.921) 24(-1.625,2.921) 25(-2.275,2.921) 26(-2.925,2.921) 27(-3.575,2.921) 28(-4.225,2.921)
unnamed#2
  round 0.991 smd: 1(0,0)
USB
  rect 1.473x1.473 hole 1.016: 1(-3.505,0)
  round 1.473 hole 1.016: 2(-1.016,0) 3(1.016,0) 4(3.505,0) 5(-3.505,2.616) 6(-1.016,2.616) 7(1.016,2.616) 8(3.505,2.616)
  round 3.556 hole 2.286: 9(-6.579,-2.718) 10(6.579,-2.718) 11(-6.579,2.972) 12(6.579,2.972)
X_2S_FC145
  rect 1.803x1.016 smd: 1(0,1.25) 2(0,-1.25)
X_7A
  rect 2.21x2.21 smd: 1(-2.1,0) 2(2.1,0)
X_7MXA
  rect 1.422x1.219 smd: 1(-1.1,-0.85) 2(1.1,-0.85) 3(1.1,0.85) 4(-1.1,0.85)
X_E5FA
  rect 2.413x1.803 smd: 1(0,0) 2(0,-3.8)

## Nets
AGND_HSC_NODE1: C778.2 C780.2 R1022.2 R1025.1 U100.4(GND) U100.8(ADR)
AGND_PVCCP_NODE1: PC87.2 PC95.2 PC97.1 PC101.1 PC108.2 PC110.1 PC111.1 PC115.2 PC122.2 PJ17.2 PR60.1 PR62.1 PR65.1 PR74.2 PR77.1 PR78.1 PU8.8(GFXPS2)
GND: BT1.2 C1.2 C2.2 C3.2 C4.2 C5.2 C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C23.2 C24.2 C25.2 C26.1 C27.1 C28.1 C29.1 C30.1 C31.1 C32.2 C33.2 C34.2 C35.1 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.2 C43.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C134.1 C135.1 C136.2 C140.2 C141.2 C142.2 C143.2 C144.2 C145.2 C146.2 C147.2 C148.2 C149.2 C150.2 C151.2 C152.2 C153.2 C154.2 C155.2 C156.2 C157.2 C158.2 C159.2 C160.2 C161.2 C162.2 C163.2 C164.2 C165.2 C166.2 C167.2 C168.2 C169.2 C170.2 C171.2 C172.2 C173.2 C174.2 C175.2 C176.2 C177.2 C178.2 C179.2 C180.2 C181.2 C182.1 C183.2 C184.1 C191.2 C194.2 C196.2 C197.1 C198.2 C199.2 C200.2 C204.2 C205.1 C223.1 C224.2 C225.1 C227.1 C228.2 C229.2 C230.2 C231.2 C232.2 C233.2 C234.2 C235.2 C236.2 C242.2 C243.2 C244.2 C246.2 C247.1 C248.2 C249.2 C250.2 C251.2 C252.2 C253.2 C254.2 C255.2 C256.2 C257.2 C258.2 C262.2 C263.2 C264.2 C265.2 C266.2 C267.2 C268.2 C269.2 C270.2 C271.2 C272.2 C273.1 C274.2 C275.1 C276.2 C277.2 C278.2 C279.2 C280.2 C281.2 C282.2 C283.2 C284.2 C285.2 C286.2 C287.2 C288.2 C289.2 C290.2 C291.2 C292.2 C293.2 C294.2 C295.2 C296.2 C297.2 C329.2 C330.2 C331.2 C334.2 C335.2 C336.2 C337.2 C338.2 C339.2 C340.2 C341.2 C342.2 C343.2 C344.2 C345.1 C346.2 C347.2 C348.2 C349.1 C350.2 C351.2 C352.2 C353.2 C354.2 C355.2 C356.2 C357.1 C358.2 C359.2 C360.2 C361.1 C362.2 C365.2 C366.2 C367.2 C368.2 C369.2 C370.2 C371.1 C372.1 C373.1 C374.1 C375.1 C376.1 C377.2 C378.1 C379.1 C380.1 C381.1 C382.1 C383.2 C384.1 C385.2 C386.1 C390.2 C393.2 C394.2 C395.2 C396.2 C397.2 C398.2 C399.2 C400.2 C401.2 C402.2 C403.2 C404.2 C405.2 C406.2 C407.2 C408.2 C409.2 C410.2 C411.2 C412.2 C413.2 C414.2 C415.2 C416.2 C417.2 C418.2 C419.2 C420.2 C421.2 C422.2 C423.2 C424.2 C425.2 C426.2 C427.2 C428.2 C430.2 C431.2 C432.2 C433.2 C434.2 C437.2 C438.2 C439.2 C440.2 C441.2 C442.2 C443.2 C444.2 C445.2 C446.2 C447.2 C448.2 C449.2 C450.2 C451.2 C452.2 C453.2 C454.2 C455.2 C456.2 C457.2 C458.2 C459.2 C460.2 C461.2 C462.2 C463.2 C464.2 C465.2 C466.2 C467.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C481.2 C484.2 C486.2 C487.2 C488.2 C491.2 C493.2 C495.2 C496.2 C497.2 C498.2 C499.2 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C506.2 C507.2 C508.2 C509.1 C510.2 C511.2 C512.2 C513.2 C514.2 C517.2 C518.2 C519.2 C520.2 C521.2 C522.2 C523.2 C524.2 C527.2 C528.2 C529.2 C530.2 C531.1 C532.1 C535.2 C536.2 C537.2 C538.2 C539.2 C540.2 C541.2 C543.2 C544.1 C545.1 C548.1 C550.2 C551.1 C553.1 C555.2 C556.2 C557.2 C558.2 C559.2 C560.2 C561.2 C562.1 C564.1 C565.2 C566.1 C567.1 C568.1 C569.1 C570.1 C571.1 C572.1 C573.1 C574.2 C575.2 C576.2 C577.2 C578.2 C579.1 C580.2 C581.2 C582.2 C583.2 C584.2 C585.2 C586.2 C587.2 C588.2 C589.2 C590.1 C591.2 C592.2 C593.2 C594.2 C595.2 C596.2 C597.2 C598.2 C599.2 C600.2 C601.2 C602.2 C603.2 C604.2 C605.2 C606.2 C607.2 C608.2 C609.2 C610.2 C611.2 C612.2 C613.2 C614.2 C615.2 C616.2 C617.2 C618.2 C619.2 C620.2 C621.2 C622.2 C623.2 C624.2 C625.2 C626.2 C627.2 C628.2 C629.2 C630.2 C631.2 C632.2 C633.2 C634.2 C635.2 C636.2 C637.2 C638.2 C639.2 C640.2 C641.2 C642.2 C643.2 C644.2 C645.2 C646.2 C647.2 C648.2 C649.2 C650.2 C651.2 C652.2 C653.2 C654.2 C655.2 C656.2 C657.2 C658.2 C659.2 C660.2 C661.2 C662.2 C663.2 C664.2 C665.2 C666.2 C667.2 C668.2 C669.2 C670.2 C671.2 C672.2 C673.2 C674.2 C675.2 C676.2 C677.2 C678.2 C679.2 C680.2 C681.2 C682.2 C683.2 C684.2 C685.2 C686.2 C687.2 C688.2 C689.2 C690.2 C691.2 C692.2 C693.2 C694.2 C695.2 C696.2 C697.2 C698.2 C699.2 C700.2 C701.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.2 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C730.2 C731.2 C732.2 C733.2 C734.2 C735.2 C736.2 C737.2 C738.2 C739.2 C740.2 C741.2 C742.2 C743.2 C744.2 C745.2 C746.2 C747.2 C748.2 C749.2 C750.2 C751.2 C752.2 C753.2 C754.2 C755.2 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C763.2 C764.2 C765.2 C766.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C779.2 C781.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C791.2 C792.2 C793.2 C794.2 C795.2 C797.1 C798.2 C799.2 C801.1 C802.2 C809.2 C810.2 C811.2 C812.2 C813.2 C814.2 C816.1 C817.2 C818.2 C819.2 C820.2 C821.2 C822.2 C824.1 C826.2 C827.2 C828.2 C829.2 C830.2 C831.2 C832.2 C834.1 C835.2 C836.2 C837.2 C838.2 C839.2 C840.2 C842.2 C846.2 C848.2 C850.2 C852.2 C853.1 C854.2 C855.2 C856.2 C857.2 C858.2 C859.2 C860.2 C861.2 C862.2 C863.2 C864.2 C865.2 C866.2 C867.2 C868.2 C869.2 C870.2 C871.2 C872.2 C873.2 C874.2 C875.2 C876.2 C877.2 C878.2 C879.2 C880.2 C881.2 C882.2 C883.2 C884.1 C885.2 C886.1 C887.1 C888.2 C889.2 C890.2 C891.2 C892.2 C893.2 C894.2 C895.2 C896.2 C897.2 C900.2 C901.2 C902.2 C903.2 C904.2 C905.2 C906.2 C907.2 C908.2 C909.2 C913.2 C914.1 C917.1 C918.2 C919.1 C930.2 C931.2 C932.2 C933.2 C934.1 C1119.1 C1120.1 C1121.2 C1122.2 CE2.2 CE3.2 D9.A D10.A D18.3(G) D20.1(ANODE) D25.C H5.2(GND2) H5.3(GND3) H5.4(GND4) H5.5(GND5) H5.6(GND6) H5.7(GND7) H5.8(GND8) H5.9(GND9) H10.1(GND) J1.12 J1.14 J2.2(GND45) J2.3(GND44) J2.8(GND43) J2.9(GND42) J2.14(GND41) J2.17(GND40) J2.20(GND39) J2.23(GND38) J2.26(GND37) J2.29(GND36) J2.32(GND35) J2.35(GND34) J2.38(GND33) J2.41(GND32) J2.46(GND31) J2.47(GND30) J2.52(GND29) J2.53(GND28) J2.58(GND27) J2.61(GND26) J2.64(GND25) J2.67(GND24) J2.70(GND23) J2.73(GND22) J2.78(GND21) J2.79(GND20) J2.137(GND19) J2.138(GND18) J2.143(GND17) J2.146(GND16) J2.149(GND15) J2.152(GND14) J2.155(GND13) J2.158(GND12) J2.163(GND11) J2.164(GND10) J2.169(GND9) J2.170(GND8) J2.175(GND7) J2.178(GND6) J2.181(GND5) J2.184(GND4) J2.187(GND3) J2.190(GND2) J2.195(GND1) J2.196(GND0) J2.197(SA0) J2.201(SA1) J2.G1 J2.G2 J3.1 J3.2 J3.7 J3.8 J3.13 J3.14 J3.19 J3.20 J3.25 J3.26 J3.31 J3.32 J3.37 J3.38 J3.49 J3.50 J3.59 J4.1(GND) J5.4 J6.4 J7.1 J7.4 J7.8(G1) J7.9(G2) J8.1 J9.5(GND4) J9.6(GND3) J9.7(GND2) J9.8(GND1) J9.10(GND5) J9.G1(GND6) J9.G2(GND7) J14.4(GND1) J14.8(GND2) J14.9(EMI_1) J14.10(EMI_2) J14.11(EMI_3) J14.12(EMI_4) J15.4(GND1) J15.8(GND2) J15.9(EMI_1) J15.10(EMI_2) J15.11(EMI_3) J15.12(EMI_4) J18.A1(PRSNT1_N) J18.A2(12V_1) J18.A5(JTAG2) J18.A8(JTAG5) J18.A17(HSIP0-) J18.A25(HSIP2+) J18.A29(HSIP3+) J18.A31(GND10) J18.A34(GND11) J18.A39(HSIP5+) J18.A44(HSIP6-) J18.A49(GND18) J18.A54(GND20) J18.A59(GND23) J18.A64(HSIP11+) J18.A69(HSIP12-) J18.A74(GND29) J18.A79(GND32) J18.B1(12V_3) J18.B4(GND34) J18.B7(GND35) J18.B8(3.3V_3) J18.B9(JTAG1) J18.B18(GND38) J18.B26(GND42) J18.B30(RSVD3) J18.B35(GND45) J18.B40(GND48) J18.B45(HSOP7+) J18.B50(HSOP8+) J18.B55(HSOP9-) J18.B60(GND57) J18.B65(GND60) J18.B70(HSOP13+) J18.B75(HSOP14-) J18.B80(GND67) J19.1(GND#1) J19.2(GND#2) J20.2 J20.10 J25.1(GND) J26.2 J26.10 J27.2 J27.10 J29.1(GND) J30.1(GND) J32.2 J34.2 J35.A1(PRSNT1_N) J35.A4(GND1) J35.A7(JTAG4) J35.A14(REFCLK-) J35.A19(RSVD5) J35.A24(GND7) J35.A29(HSIP3+) J35.A34(GND11) J35.A39(HSIP5+) J35.A44(HSIP6-) J35.A51(GND19) J35.A59(GND23) J35.A66(GND26) J35.A71(GND28) J35.A74(GND29) J35.A77(HSIP14-) J35.B1(12V_3) J35.B4(GND34) J35.B9(JTAG1) J35.B16(GND37) J35.B21(GND39) J35.B26(GND42) J35.B31(PRSNT2_N-2) J35.B36(GND46) J35.B41(HSOP6+) J35.B44(GND50) J35.B51(HSOP8-) J35.B59(HSOP10-) J35.B66(HSOP12+) J35.B71(HSOP13-) J35.B74(HSOP14+) J35.B77(GND66) J36.1 L37.1 OSC3.2(GND) OSC4.2(GND) OSC5.2(GND) OSC6.2(GND) PC1.2 PC2.2 PC3.2 PC5.2 PC6.2 PC7.2 PC8.2 PC9.1 PC11.2 PC12.2 PC13.2 PC14.2 PC16.2 PC17.2 PC18.2 PC19.2 PC20.1 PC22.2 PC25.2 PC26.2 PC27.2 PC28.2 PC29.2 PC30.2 PC31.2 PC32.2 PC33.2 PC34.2 PC35.2 PC37.2 PC38.2 PC39.2 PC40.2 PC41.1 PC43.2 PC44.2 PC45.2 PC46.2 PC48.2 PC49.2 PC50.2 PC51.2 PC52.1 PC54.2 PC55.2 PC56.2 PC57.2 PC58.2 PC59.1 PC61.2 PC62.2 PC63.2 PC64.2 PC66.2 PC67.2 PC68.2 PC70.2 PC71.2 PC72.2 PC73.2 PC74.2 PC75.2 PC76.1 PC78.2 PC79.2 PC80.2 PC81.2 PC82.2 PC83.2 PC84.2 PC85.1 PC86.1 PC88.2 PC89.2 PC90.2 PC91.2 PC92.2 PC93.2 PC94.2 PC99.2 PC100.2 PC105.1 PC106.1 PC107.1 PC112.1 PC113.1 PC114.1 PC116.1 PC117.1 PC118.1 PC119.1 PC120.1 PC121.1 PC123.1 PC124.1 PC125.1 PC126.1 PC130.2 PC131.2 PC132.2 PC133.2 PJ7.1 PJ11.2 PJ17.1 PQ1.5-6-7(S2-5) PQ2.5-6-7(S2-5) PR2.2 PR4.2 PR6.2 PR8.2 PR10.1 PR14.2 PR16.2 PR17.1 PR19.2 PR21.2 PR26.2 PR27.1 PR28.2 PR33.2 PR34.2 PR36.1 PR37.2 PR53.2 PR71.2 PR103.2 PU1.4(GND) PU1.7(PGND_1) PU1.8(PGND_2) PU1.TH(GND-EP) PU2.4(GND) PU2.7(PGND_1) PU2.8(PGND_2) PU2.TH(GND-EP) PU4.4(GND) PU4.7(PGND_1) PU4.8(PGND_2) PU4.TH(GND-EP) PU5.4(GND) PU5.7(PGND_1) PU5.8(PGND_2) PU5.TH(GND-EP) PU6.7(GND) PU6.8(PGND) PU6.TH(GND_TP) PU7.17(GND) PU7.TH(GND_TP) PU8.10(SETINIA) PU8.22(VRA_READY) PU8.26(RGNDA) PU8.31(TONSETA) PU8.TH(GND) Q24.E(2) Q26.E(2) Q27.E(2) Q28.E(2) Q43.2(S) R15.1 R16.1 R17.1 R18.1 R23.1 R24.1 R25.1 R26.1 R28.1 R29.2 R30.2 R31.2 R37.2 R38.2 R39.2 R40.2 R41.2 R42.2 R43.2 R44.2 R45.2 R46.2 R50.2 R52.2 R54.2 R55.2 R56.2 R78.2 R79.1 R80.1 R81.1 R82.1 R83.1 R84.1 R88.1 R92.1 R96.1 R97.2 R98.2 R99.2 R100.2 R101.2 R102.2 R104.1 R107.2 R108.2 R120.2 R134.1 R141.1 R142.1 R154.2 R155.1 R156.1 R160.2 R161.1 R162.1 R166.2 R167.1 R168.1 R170.2 R173.1 R174.1 R176.2 R203.2 R204.1 R205.1 R206.1 R207.1 R208.1 R209.1 R210.1 R211.1 R212.1 R213.2 R218.2 R225.2 R227.2 R229.1 R253.1 R256.2 R257.1 R258.1 R260.2 R262.2 R276.1 R277.1 R278.1 R279.1 R284.1 R285.1 R286.1 R287.1 R288.1 R289.1 R290.2 R291.2 R292.2 R293.2 R294.2 R295.1 R296.1 R306.1 R307.1 R308.1 R313.1 R315.1 R497.1 R503.1 R504.2 R505.1 R510.1 R512.1 R515.1 R518.1 R526.2 R552.1 R554.1 R556.1 R557.1 R558.1 R559.1 R582.1 R584.1 R586.1 R587.1 R588.1 R589.1 R624.2 R630.1 R640.2 R641.2 R642.2 R654.1 R656.1 R658.1 R682.1 R687.2 R688.2 R718.2 R719.2 R750.2 R751.2 R752.2 R753.2 R754.2 R763.2 R772.2 R783.1 R792.1 R794.2 R796.2 R797.2 R798.2 R805.2 R806.2 R807.2 R808.2 R809.2 R810.2 R811.2 R813.2 R845.2 R848.2 R849.2 R850.2 R851.2 R852.2 R853.2 R854.2 R855.2 R856.2 R857.2 R858.2 R1003.1 R1004.1 R1008.1 R1010.1 R1013.1 R1014.1 R1016.1 R1018.1 R1024.1 R1025.2 R1028.2 R1029.2 R1033.1 R1037.1 R1038.1 R1048.2 R1058.2 R1074.1 R1083.2 R1086.1 R1089.1 R1093.1 R1098.2 R1102.1 R1103.1 R1104.1 R1105.1 R1106.1 R1110.1 R1114.1 R1118.1 R1120.2 R1125.2 R1133.1 R1135.1 R1137.1 R1151.2 R1152.1 R1153.1 R1154.1 R1156.2 R1158.2 R1160.2 R1162.2 R1165.2 R1166.2 R1168.2 R1171.2 R1172.2 R1174.2 R1177.2 R1178.2 R1180.2 R1182.2 R1184.2 R1186.2 R1188.2 R1191.2 R1192.2 R1206.2 R1209.2 R1210.2 R1212.1 R1219.2 R1220.2 R1221.2 R1222.2 R1223.2 R1224.2 R1225.2 R1226.1 R1227.2 R1228.2 R1229.2 R1230.1 R1231.1 R1232.1 R1233.1 R1234.1 R1235.1 R1236.1 R1237.1 R1238.1 R1239.2 R1240.1 R1241.1 R1242.1 R1243.1 R1244.1 R1245.1 R1251.2 R1266.2 R1269.2 R1270.2 R1297.1 R1300.1 R1303.1 R1306.1 R1326.2 R1328.2 S1.3 S1.4 S3.3 S3.4 U1.11(GNDPCI) U1.12(GND14M) U1.18(GND48) U1.22(GND27) U1.28(GNDLCD) U1.29(GNDSATA) U1.40(GNDSRC) U1.52(GNDCPU) U1.56(GND25) U1.TH(E_PAD) U2.A5(VSS_NCTF_2) U2.A6(VSS_NCTF_4) U2.A8(VSS_NCTF_9) U2.A9(VSS_NCTF_10) U2.A12(VSS_NCTF_1) U2.A15(VSS_1) U2.A18(VSS_2) U2.A21(VSS_3) U2.A24(VSS_4) U2.A27(VSS_5) U2.A30(VSS_6) U2.A33(VSS_7) U2.A36(VSS_8) U2.A39(VSS_9) U2.A42(VSS_10) U2.A45(VSS_11) U2.A54(VSS_12) U2.A57(VSS_13) U2.A59(VSS_NCTF_3) U2.A61(VSS_NCTF_5) U2.A62(VSS_NCTF_6) U2.A64(VSS_NCTF_7) U2.A66(VSS_NCTF_8) U2.AA3(VSS_207) U2.AA5(VSS_208) U2.AA25(VSS_209) U2.AA26(VSS_210) U2.AA29(VSS_211) U2.AA32(VSS_212) U2.AA36(VSS_213) U2.AA39(VSS_214) U2.AA42(VSS_215) U2.AA47(VSS_216) U2.AB1(VSS_217) U2.AB20(VSS_218) U2.AB65(VSS_219) U2.AC8(VSS_220) U2.AC12(VSS_221) U2.AC17(VSS_222) U2.AC28(VSS_223) U2.AC29(VSS_224) U2.AC32(VSS_225) U2.AC39(VSS_226) U2.AC46(VSS_227) U2.AC50(VSS_228) U2.AC55(VSS_229) U2.AC59(VSS_230) U2.AD8(VSS_231) U2.AD12(VSS_232) U2.AD17(VSS_233) U2.AD21(VSS_234) U2.AD26(VSS_235) U2.AD31(VSS_236) U2.AD34(VSS_237) U2.AD36(VSS_238) U2.AD38(VSS_239) U2.AD42(VSS_240) U2.AD44(VSS_241) U2.AD46(VSS_242) U2.AD50(VSS_243) U2.AD55(VSS_244) U2.AD59(VSS_245) U2.AD65(VSS_246) U2.AD66(VSS_247) U2.AE1(VSS_248) U2.AE3(VSS_249) U2.AE5(VSS_250) U2.AE47(VSS_251) U2.AF20(VSS_252) U2.AF21(VSS_253) U2.AF25(VSS_254) U2.AF26(VSS_255) U2.AF29(VSS_256) U2.AF32(VSS_257) U2.AF34(VSS_258) U2.AF39(VSS_259) U2.AF42(VSS_260) U2.AF44(VSS_261) U2.AF46(VSS_262) U2.AF62(VSS_263) U2.AF65(VSS_264) U2.AG7(VSS_265) U2.AG11(VSS_266) U2.AG16(VSS_267) U2.AG17(VSS_268) U2.AG19(VSS_269) U2.AG21(VSS_270) U2.AG25(VSS_271) U2.AG26(VSS_272) U2.AG31(VSS_273) U2.AG38(VSS_274) U2.AG44(VSS_275) U2.AG46(VSS_276) U2.AG51(VSS_277) U2.AG56(VSS_278) U2.AH7(VSS_280) U2.AH11(VSS_281) U2.AH16(VSS_282) U2.AH17(VSS_283) U2.AH19(VSS_284) U2.AH51(VSS_285) U2.AH56(VSS_286) U2.AH60(VSS_287) U2.AJ2(VSS_288) U2.AJ4(VSS_289) U2.AJ5(VSS_290) U2.AJ25(VSS_291) U2.AJ26(VSS_292) U2.AJ29(VSS_293) U2.AJ32(VSS_294) U2.AJ36(VSS_295) U2.AJ39(VSS_296) U2.AJ42(VSS_297) U2.AJ46(VSS_298) U2.AJ47(VSS_299) U2.AK3(VSS_301) U2.AK5(VSS_302) U2.AK20(VSS_300) U2.AK62(VSS_303) U2.AK64(VSS_304) U2.AK66(VSS_305) U2.AL1(VSS_306) U2.AL8(VSS_307) U2.AL12(VSS_308) U2.AL17(VSS_309) U2.AL31(VSS_310) U2.AL34(VSS_311) U2.AL38(VSS_312) U2.AL41(VSS_313) U2.AL44(VSS_314) U2.AL46(VSS_315) U2.AL50(VSS_316) U2.AL55(VSS_317) U2.AL59(VSS_318) U2.AM8(VSS_319) U2.AM12(VSS_320) U2.AM17(VSS_321) U2.AM18(VSS_322) U2.AM20(VSS_323) U2.AM25(VSS_324) U2.AM26(VSS_325) U2.AM29(VSS_326) U2.AM32(VSS_327) U2.AM36(VSS_328) U2.AM39(VSS_329) U2.AM42(VSS_330) U2.AM44(VSS_331) U2.AM46(VSS_332) U2.AM47(VSS_406) U2.AM49(VSS_279) U2.AM50(VSS_333) U2.AM55(VSS_334) U2.AM59(VSS_335) U2.AN47(VSS_405) U2.AN62(VSS_336) U2.AN66(VSS_337) U2.AP1(VSS_338) U2.AP3(VSS_339) U2.AP5(VSS_340) U2.AP31(VSS_341) U2.AP34(VSS_342) U2.AP62(VSS_343) U2.AR7(VSS_344) U2.AR11(VSS_345) U2.AR13(VSS_346) U2.AR17(VSS_347) U2.AR51(VSS_369) U2.AR56(VSS_370) U2.AR62(VSS_350) U2.AT7(VSS_351) U2.AT11(VSS_352) U2.AT16(VSS_353) U2.AT17(VSS_354) U2.AT19(VSS_355) U2.AT25(VSS_356) U2.AT26(VSS_357) U2.AT29(VSS_358) U2.AT32(VSS_359) U2.AT36(VSS_360) U2.AT38(VSS_361) U2.AT39(VSS_362) U2.AT41(VSS_363) U2.AT42(VSS_364) U2.AT44(VSS_365) U2.AT46(VSS_366) U2.AT48(VSS_367) U2.AT50(VSS_368) U2.AT51(VSS_348) U2.AT56(VSS_349) U2.AT66(VSS_371) U2.AU4(VSS_372) U2.AU21(VSS_373) U2.AU31(VSS_374) U2.AU34(VSS_375) U2.AU62(VSS_376) U2.AV4(VSS_377) U2.AV5(VSS_378) U2.AV63(VSS_379) U2.AV65(VSS_380) U2.AW3(VSS_381) U2.AW5(VSS_382) U2.AW8(VSS_383) U2.AW12(VSS_384) U2.AW17(VSS_385) U2.AW19(VSS_386) U2.AW20(VSS_387) U2.AW25(VSS_388) U2.AW26(VSS_389) U2.AW28(VSS_390) U2.AW30(VSS_391) U2.AW31(VSS_392) U2.AW34(VSS_393) U2.AW36(VSS_394) U2.AW38(VSS_395) U2.AW39(VSS_396) U2.AW41(VSS_397) U2.AW42(VSS_398) U2.AW44(VSS_399) U2.AW49(VSS_400) U2.AW50(VSS_401) U2.AW52(VSS_402) U2.AW53(VSS_403) U2.AW55(VSS_404) U2.AW59(VSS_407) U2.AW66(VSS_408) U2.AY1(VSS_409) U2.AY8(VSS_410) U2.AY12(VSS_411) U2.AY14(VSS_412) U2.AY15(VSS_413) U2.AY19(VSS_414) U2.AY29(VSS_415) U2.AY30(VSS_416) U2.AY37(VSS_417) U2.AY45(VSS_418) U2.AY46(VSS_419) U2.AY52(VSS_420) U2.AY53(VSS_421) U2.AY55(VSS_422) U2.AY56(VSS_423) U2.AY58(VSS_424) U2.AY59(VSS_425) U2.AY62(VSS_426) U2.B14(VSS_14) U2.B23(VSS_15) U2.B32(VSS_16) U2.B37(VSS_17) U2.B46(VSS_18) U2.B50(VSS_19) U2.BA17(VSS_427) U2.BA21(VSS_428) U2.BA23(VSS_429) U2.BA26(VSS_430) U2.BA30(VSS_431) U2.BA37(VSS_432) U2.BA42(VSS_433) U2.BA45(VSS_434) U2.BA46(VSS_435) U2.BA49(VSS_436) U2.BB32(VSS_437) U2.BB42(VSS_438) U2.BB50(VSS_439) U2.BB53(VSS_440) U2.BB54(VSS_441) U2.BB56(VSS_442) U2.BB62(VSS_443) U2.BB66(VSS_444) U2.BC1(VSS_445) U2.BC3(VSS_446) U2.BC5(VSS_447) U2.BC7(VSS_448) U2.BC11(VSS_449) U2.BC13(VSS_450) U2.BC15(VSS_451) U2.BC21(VSS_452) U2.BC23(VSS_453) U2.BC29(VSS_454) U2.BC30(VSS_455) U2.BC37(VSS_456) U2.BC45(VSS_457) U2.BC46(VSS_458) U2.BC62(VSS_459) U2.BD7(VSS_460) U2.BD15(VSS_461) U2.BD21(VSS_462) U2.BD23(VSS_463) U2.BD25(VSS_464) U2.BD29(VSS_465) U2.BD30(VSS_466) U2.BD32(VSS_467) U2.BD34(VSS_468) U2.BD46(VSS_469) U2.BD53(VSS_470) U2.BD54(VSS_471) U2.BD59(VSS_472) U2.BD62(VSS_473) U2.BE17(VSS_474) U2.BE19(VSS_475) U2.BE25(VSS_476) U2.BE50(VSS_477) U2.BE63(VSS_478) U2.BE66(VSS_479) U2.BF15(VSS_480) U2.BF23(VSS_481) U2.BF29(VSS_482) U2.BF30(VSS_483) U2.BF46(VSS_484) U2.BF53(VSS_485) U2.BF54(VSS_486) U2.BG1(VSS_NCTF_26) U2.BG4(VSS_487) U2.BG5(VSS_488) U2.BG11(VSS_489) U2.BG23(VSS_490) U2.BG26(VSS_491) U2.BG30(VSS_492) U2.BG46(VSS_493) U2.BG53(VSS_494) U2.BG54(VSS_495) U2.BG57(VSS_496) U2.BG63(VSS_497) U2.BG66(VSS_NCTF_27) U2.BH5(VSS_498) U2.BH11(VSS_499) U2.BH50(VSS_500) U2.BH60(VSS_501) U2.BH64(VSS_502) U2.BJ1(VSS_NCTF_28) U2.BJ62(VSS_503) U2.BJ63(VSS_504) U2.BJ66(VSS_NCTF_29) U2.BK1(VSS_NCTF_30) U2.BK3(VSS_NCTF_31) U2.BK5(VSS_NCTF_32) U2.BK6(VSS_505) U2.BK8(VSS_506) U2.BK10(VSS_507) U2.BK12(VSS_508) U2.BK13(VSS_509) U2.BK15(VSS_510) U2.BK17(VSS_511) U2.BK18(VSS_512) U2.BK19(VSS_513) U2.BK21(VSS_514) U2.BK22(VSS_515) U2.BK24(VSS_516) U2.BK26(VSS_517) U2.BK27(VSS_518) U2.BK28(VSS_519) U2.BK30(VSS_520) U2.BK31(VSS_521) U2.BK36(VSS_522) U2.BK42(VSS_523) U2.BK48(VSS_524) U2.BK53(VSS_525) U2.BK54(VSS_526) U2.BK56(VSS_527) U2.BK57(VSS_528) U2.BK58(VSS_529) U2.BK60(VSS_530) U2.BK62(VSS_NCTF_33) U2.BK64(VSS_NCTF_34) U2.BK66(VSS_NCTF_35) U2.BL8(VSS_531) U2.BL10(VSS_532) U2.BL12(VSS_533) U2.BL16(VSS_534) U2.BL21(VSS_535) U2.BL25(VSS_536) U2.BL30(VSS_537) U2.BL50(VSS_538) U2.BL52(VSS_539) U2.BL61(VSS_540) U2.BM1(VSS_NCTF_36) U2.BM61(VSS_541) U2.BM62(VSS_NCTF_37) U2.BM64(VSS_NCTF_38) U2.BM66(VSS_NCTF_39) U2.BN12(VSS_542) U2.BN21(VSS_543) U2.BN30(VSS_544) U2.BN50(VSS_545) U2.BP1(VSS_NCTF_40) U2.BP3(VSS_NCTF_41) U2.BP5(VSS_NCTF_42) U2.BP6(VSS_NCTF_44) U2.BP8(VSS_NCTF_45) U2.BP10(VSS_546) U2.BP16(VSS_547) U2.BP19(VSS_548) U2.BP25(VSS_549) U2.BP28(VSS_550) U2.BP52(VSS_551) U2.BP55(VSS_552) U2.BP58(VSS_553) U2.BP59(VSS_NCTF_43) U2.BP61(VSS_NCTF_46) U2.BP62(VSS_NCTF_47) U2.BP64(VSS_NCTF_48) U2.BP66(VSS_NCTF_49) U2.C3(VSS_NCTF_11) U2.C5(VSS_NCTF_12) U2.C6(VSS_20) U2.C9(VSS_21) U2.C13(VSS_22) U2.C18(VSS_23) U2.C22(VSS_24) U2.C27(VSS_25) U2.C54(VSS_26) U2.C58(VSS_27) U2.C60(VSS_28) U2.C62(VSS_NCTF_13) U2.C64(VSS_NCTF_14) U2.C66(VSS_NCTF_15) U2.D6(VSS_29) U2.D8(VSS_30) U2.D14(VSS_31) U2.D32(VSS_32) U2.D37(VSS_33) U2.D39(VSS_34) U2.D41(VSS_35) U2.D46(VSS_36) U2.D50(VSS_37) U2.D59(VSS_38) U2.D60(VSS_39) U2.E1(VSS_NCTF_16) U2.E3(VSS_NCTF_17) U2.E5(VSS_NCTF_18) U2.E7(VSS_40) U2.E9(VSS_41) U2.E13(VSS_42) U2.E14(VSS_43) U2.E16(VSS_44) U2.E18(VSS_45) U2.E22(VSS_46) U2.E25(VSS_47) U2.E27(VSS_48) U2.E30(VSS_49) U2.E32(VSS_50) U2.E34(VSS_51) U2.E37(VSS_52) U2.E41(VSS_53) U2.E43(VSS_54) U2.E45(VSS_55) U2.E46(VSS_56) U2.E50(VSS_57) U2.E54(VSS_58) U2.E58(VSS_59) U2.E61(VSS_60) U2.E62(VSS_NCTF_19) U2.E64(VSS_NCTF_20) U2.E66(VSS_NCTF_21) U2.F4(VSS_61) U2.F63(VSS_62) U2.F66(VSS_NCTF_22) U2.G3(VSS_63) U2.G7(VSS_64) U2.G10(VSS_65) U2.G48(VSS_66) U2.G50(VSS_67) U2.G56(VSS_68) U2.G59(VSS_69) U2.H4(VSS_70) U2.H21(VSS_71) U2.H22(VSS_72) U2.H29(VSS_73) U2.H44(VSS_74) U2.H58(VSS_75) U2.H62(VSS_76) U2.H63(VSS_77) U2.H66(VSS_NCTF_23) U2.J5(VSS_78) U2.J29(VSS_79) U2.J52(VSS_80) U2.J54(VSS_81) U2.J66(VSS_82) U2.K1(VSS_NCTF_24) U2.K17(VSS_83) U2.K18(VSS_84) U2.K25(VSS_85) U2.K26(VSS_86) U2.K32(VSS_87) U2.K34(VSS_88) U2.K41(VSS_89) U2.K42(VSS_90) U2.L5(VSS_91) U2.L7(VSS_92) U2.L8(VSS_93) U2.L13(VSS_94) U2.L14(VSS_95) U2.L29(VSS_96) U2.L30(VSS_97) U2.L34(VSS_98) U2.L37(VSS_99) U2.L38(VSS_100) U2.L44(VSS_101) U2.L46(VSS_102) U2.L48(VSS_103) U2.L50(VSS_104) U2.L57(VSS_105) U2.M3(VSS_106) U2.M5(VSS_107) U2.M21(VSS_108) U2.M22(VSS_109) U2.M29(VSS_110) U2.M30(VSS_111) U2.M57(VSS_112) U2.M62(VSS_113) U2.M64(VSS_114) U2.M66(VSS_115) U2.N1(VSS_NCTF_25) U2.N7(VSS_116) U2.N11(VSS_117) U2.N34(VSS_118) U2.N63(VSS_119) U2.P17(VSS_120) U2.P18(VSS_121) U2.P25(VSS_122) U2.P26(VSS_123) U2.P29(VSS_124) U2.P30(VSS_125) U2.P38(VSS_126) U2.R8(VSS_127) U2.R12(VSS_128) U2.R29(VSS_129) U2.R30(VSS_130) U2.R38(VSS_131) U2.R46(VSS_132) U2.R52(VSS_133) U2.R53(VSS_134) U2.R55(VSS_135) U2.R59(VSS_136) U2.R66(VSS_137) U2.T1(VSS_138) U2.T3(VSS_139) U2.T5(VSS_140) U2.T17(VSS_141) U2.T20(VSS_142) U2.T21(VSS_143) U2.T23(VSS_144) U2.T25(VSS_145) U2.T26(VSS_146) U2.T28(VSS_147) U2.T29(VSS_148) U2.T31(VSS_149) U2.T34(VSS_150) U2.T37(VSS_151) U2.T39(VSS_152) U2.T41(VSS_153) U2.T45(VSS_154) U2.T50(VSS_155) U2.T55(VSS_156) U2.T59(VSS_157) U2.T62(VSS_158) U2.T64(VSS_159) U2.U8(VSS_160) U2.U12(VSS_161) U2.V23(VSS_162) U2.V25(VSS_163) U2.V26(VSS_164) U2.V28(VSS_165) U2.V29(VSS_166) U2.V31(VSS_167) U2.V34(VSS_168) U2.V38(VSS_169) U2.V39(VSS_170) U2.V41(VSS_171) U2.V42(VSS_172) U2.V44(VSS_173) U2.V46(VSS_174) U2.W3(VSS_175) U2.W7(VSS_176) U2.W10(VSS_177) U2.W14(VSS_178) U2.W19(VSS_179) U2.W21(VSS_180) U2.W23(VSS_181) U2.W25(VSS_182) U2.W26(VSS_183) U2.W28(VSS_184) U2.W29(VSS_185) U2.W31(VSS_186) U2.W34(VSS_187) U2.W38(VSS_188) U2.W41(VSS_189) U2.W51(VSS_190) U2.W56(VSS_191) U2.W60(VSS_192) U2.W62(VSS_193) U2.Y4(VSS_194) U2.Y5(VSS_195) U2.Y7(VSS_196) U2.Y10(VSS_197) U2.Y14(VSS_198) U2.Y16(VSS_199) U2.Y17(VSS_200) U2.Y19(VSS_201) U2.Y51(VSS_202) U2.Y56(VSS_203) U2.Y60(VSS_204) U2.Y63(VSS_205) U2.Y65(VSS_206) U4.4(VSS) U5.4(VSS) U9.8(GND8) U9.TH(TH_PAD) U10.2(GND) U11.2(GND) U13.4(GND) U14.A1(GPIOC7_SD1WP#) U14.A2(GPIOC2_SD1DAT0) U14.A3(GPIOA6_TIMER7_MDC2) U14.A9(RGMII2RXD0_RMII2RXD0) U14.A11(RGMII1RXD2_RMII1CRSDV) U14.AA18(PLLVSS_2) U14.AA19(PLLVSS_1) U14.B1(GPIOQ2_SCL4) U14.B2(GPIOC6_SD1CD#) U14.B3(GPIOC1_SD1CMD) U14.B4(GPIOA5_TIMER6_SDA9) U14.B8(RGMIICK) U14.B9(RGMII2RXCTL_RMII4RCLK) U14.B11(RGMII1RXD1_RMII1RXD1) U14.C1(GPIOK2_SCL6) U14.C2(GPIOQ1_SDA3) U14.C3(GPIOC5_SD1DAT3) U14.C4(GPIOC0_SD1CLK) U14.C5(GPIOA4_TIMER5_SCL9) U14.C8(RGMII2RXD3_RMII2RXER) U14.C9(RGMII2RXCK_RMII2RCLK) U14.C11(RGMII1RXD0_RMII1RXD0) U14.D1(GPIOK5_SDA7_SALT4) U14.D2(GPIOK1_SDA5) U14.D3(GPIOQ0_SCL3) U14.D4(GPIOC4_SD1DAT2) U14.D5(GPIOA7_TIMER8_MDIO2) U14.D8(RGMII2RXD2_RMII2CRSDV) U14.D11(RGMII1RXCTL_RMII3RCLK) U14.D21(PEAGND_1) U14.D22(PEAGND_2) U14.E2(GPIOK4_SCL7_SALT3) U14.E3(GPIOK0_SCL5) U14.E5(GPIOC3_SD1DAT1) U14.E8(RGMII2RXD1_RMII2RXD1) U14.E10(RGMII1RXD3_RMII1RXER) U14.E11(RGMII1RXCK_RMII1RCLK) U14.F3(GPIOK7_SDA8_SALT2) U14.F4(GPIOK3_SDA6) U14.F5(GPIOQ3_SDA4) U14.G5(GPIOK6_SCL8_SALT1) U14.H1(GPIOQ7_MSDAT) U14.H2(GPIOQ6_MSCLK) U14.H3(GPIOQ5_KBDAT) U14.H4(GPIOQ4_KBCLK) U14.J3(GPIOJ3_SGPMI_MDIO4) U14.J9(GND_6) U14.J10(GND_1) U14.J11(GND_2) U14.J12(GND_3) U14.J13(GND_4) U14.J14(GND_5) U14.J18(SDA2) U14.J19(SCL2) U14.K5(GPIOJ2_SGPMO_MDC4) U14.K9(GND_12) U14.K10(GND_7) U14.K11(GND_8) U14.K12(GND_9) U14.K13(GND_10) U14.K14(GND_11) U14.K20(ENTEST2) U14.L1(ADC4) U14.L2(ADC3) U14.L3(ADC2) U14.L4(ADC1) U14.L5(ADC0) U14.L9(GND_18) U14.L10(GND_13) U14.L11(GND_14) U14.L12(GND_15) U14.L13(GND_16) U14.L14(GND_17) U14.M1(ADC9) U14.M2(ADC8) U14.M3(ADC7) U14.M4(ADC6) U14.M5(ADC5) U14.M9(GND_24) U14.M10(GND_19) U14.M11(GND_20) U14.M12(GND_21) U14.M13(GND_22) U14.M14(GND_23) U14.N1(ADC13N) U14.N2(ADC13P) U14.N3(ADC12P) U14.N4(ADC11) U14.N5(ADC10) U14.N9(GND_30) U14.N10(GND_25) U14.N11(GND_26) U14.N12(GND_27) U14.N13(GND_28) U14.N14(GND_29) U14.P4(ADCAVSS) U14.P5(ADC12N) U14.P9(GND_36) U14.P10(GND_31) U14.P11(GND_32) U14.P12(GND_33) U14.P13(GND_34) U14.P14(GND_35) U14.R5(DACAVSS) U14.V18(PLLVSS_3) U14.Y19(USB2AVSS) U15.A9(VSS0) U15.B1(VSSQ0) U15.B3(VSS1) U15.B9(VSSQ1) U15.D1(VSSQ2) U15.D8(VSSQ3) U15.E1(VSS2) U15.E2(VSSQ4) U15.E8(VSSQ5) U15.F9(VSSQ6) U15.G1(VSSQ7) U15.G8(VSS3) U15.G9(VSSQ8) U15.J2(VSS4) U15.J8(VSS5) U15.M1(VSS6) U15.M9(VSS7) U15.P1(VSS8) U15.P9(VSS9) U15.T1(VSS10) U15.T9(VSS11) U16.3(GND) U30.28(VSS) U30.TH(THERMAL_PAD) U31.4(GND) U32.34(IC(L)) U32.38(U3RXDP1) U32.39(U3RXDN1) U32.47(U3RXDP2) U32.48(U3RXDN2) U32.55(U3RXDP3) U32.56(U3RXDN3) U32.64(U3RXDP4) U32.65(U3RXDN4) U32.TH(GND) U33.4(GND) U35.TH(GND) U36.4(VSS) U37.TH(GND) U38.4(VSS) U43.15(GNDD#15) U43.50(GNDD#50) U43.74(GNDD#74) U43.117(GNDD#117) U44.1 U45.1 U46.1 U47.1 U48.1 U49.1 U50.1 U51.25(GND) U52.25(GND) U53.2(GND) U54.2(GND) U55.25(GND) U56.25(GND) U57.25(GND) U58.3(GND) U59.25(GND) U60.8(GND) U61.4(VSS) U62.12(VSS) U63.12(VSS) U64.12(VSS) U65.12(VSS) U66.12(VSS) U67.4(GND) U68.4(GND) U69.2(GND) U70.2(GND) U71.4(GND) U73.4(VSS) U84.3(GND) U85.3(GND) U86.3(GND) U87.3(GND) U88.3(GND) U89.3(GND) U92.S(SOURCE) U93.S(SOURCE) U94.S(SOURCE) U95.S(SOURCE) U96.S(SOURCE) U97.S(SOURCE) U98.S(SOURCE) U99.S(SOURCE) U101.1(GND) U102.D5(GNDIO_5) U102.D7(GNDIO_4) U102.E5(GNDIO_0) U102.E6(GNDINT_0) U102.F5(GNDINT_1) U102.F6(GNDIO_3) U102.G5(GNDIO_1) U102.G7(GNDIO_2) U103.S(SOURCE) U104.S(SOURCE) U105.S(SOURCE) U106.3(GND) U107.S(SOURCE) U108.S(SOURCE) U109.S(SOURCE) U110.S(SOURCE) U111.S(SOURCE) U114.S(SOURCE) U115.5(GND(BANK0)) U115.13(GND#13) U115.29(GND(BANK1)) U115.37(GND#37) U119.TH(EP) U120.TH(EP) U121.TH(EP) U122.TH(EP) U123.4(PGND) U123.8(GND) U123.TH(GND-EP) U124.5(S2-1) U124.6(S2-2) U124.7(S2-3) U125.2(VSS1) U125.3(VSS2) U125.14(VSS3) U125.19(VSS4) U125.30(VSS5) U125.34(VSS6) U125.36(VSS7) U125.44(VSS8) U125.50(VSS9) U125.53(VSS10) U125.57(VSS11) U125.60(VSS12) U125.62(VSS13) U125.67(VSS14) U125.68(VSS15) U125.71(VSS16) U125.77(VSS17) U125.81(VSS18) U125.86(VSS19) U125.89(VSS20) U125.90(VSS21) U125.94(VSS22) U125.95(VSS23) U125.100(VSS24) U125.102(VSS25) U125.105(VSS26) U125.111(VSS27) U125.114(VSS28) U125.119(VSS29) U125.122(VSS30) U125.125(VSS31) U128.10(GNDIO_10) U128.11(GNDINT_11) U128.32(GNDIO_32) U128.46(GNDIO_46) U128.60(GNDIO_60) U128.65(GNDINT_65) U128.79(GNDIO_79) U128.93(GNDIO_93) U129.10(GNDIO_10) U129.11(GNDINT_11) U129.32(GNDIO_32) U129.46(GNDIO_46) U129.60(GNDIO_60) U129.65(GNDINT_65) U129.79(GNDIO_79) U129.93(GNDIO_93) U130.TH(EP) U131.2(GND) U132.4(GND) U133.3(GND) U134.4(GND) U135.3(GND) U136.3(GND) U140.S(SOURCE) U145.3(GND) U146.3(GND) Y1.2(GND#2) Y1.4(GND#4)
GND2: J18.A12(GND2)
GND3: J18.A15(GND3)
GND27: J35.A70(GND27)
GND36: J18.B13(GND36)
GND37: J18.B16(GND37)
GND61: J35.B68(GND61)
GND62: J35.B69(GND62)
GNDA: C482.2 C483.2 C485.2 L37.2 U43.86(GNDA(D-))
P0V75_BMC_VTTREF_NODE1: C204.1 C205.2 C223.2 C224.1 C226.2 C227.2 C228.1 R261.2 R262.1 U14.V13(MVREF) U15.H1(VREFDQ) U15.M8(VREFCA)
P1V0_ADJ: C851.1 PR9.1 PR10.2 U130.4(ADJ)
P1V0_ADJ_S: C851.2 J28.2 PR9.2
P1V0_NODE1: C199.1 C200.1 C330.1 C331.1 C861.1 C862.1 C863.1 C864.1 C872.1 C873.1 C874.1 C875.1 C876.1 C877.1 C878.1 C879.1 C880.1 C889.1 C890.1 C891.1 J28.1 L53.1 PC27.1 PC28.1 PC29.1 R804.1 U125.1(VDDC1) U125.4(VDDAUX1) U125.15(VDDC2) U125.29(VDDC3) U125.37(VDDC4) U125.42(VDDC5) U125.46(VDDC6) U125.49(VDDC7) U125.52(VDDC8) U125.61(VDDC9) U125.72(VDDC12) U125.76(VDDAUX2) U125.85(VDDC13) U125.101(VDDC10) U125.106(VDDC14) U125.110(VDDAUX3) U125.118(VDDC15) U125.123(VDDC11) U130.1(VOUT1) U130.2(VOUT2) U130.3(VOUT3)
P1V0_PCI_SW_A: C895.1 C896.1 C897.1 C930.1 C931.1 C932.1 L53.2 U125.78(VDDA1) U125.79(VDDA2) U125.80(VDDA3) U125.92(VDDA4) U125.112(VDDA5) U125.113(VDDA6)
P1V0_SATA: C336.1 C337.1 C338.1 C339.1 C340.1 C341.1 C342.1 Q12.3(C) R804.2 U30.5(VDD_1) U30.13(VDD_2) U30.21(VDD_3) U30.51(VDD_4) U30.64(VDD_5) U30.71(VDD_6)
P1V5_CLK_NODE1: C6.1 C7.1 C8.1 L1.2 U1.25(VDD_CORE_1.5#25) U1.48(VDD_CORE_1.5#48)
P1V05_CLK_NODE1: C9.1 C10.1 C11.1 L3.2 U1.34(VDDSRC_LVIO) U1.49(VDDCPU_LVIO)
P1V5_CLK_NODE1_R: L1.1 R2.2
P1V05_CLK_NODE1_R: L3.1 R3.2
P1V05_LAN1: C417.1 C418.1 C419.1 C420.1 C421.1 C422.1 C423.1 C424.1 U35.4(VDD1P05_7) U35.11(VDD1P05_6) U35.18(VDD1P05_5) U35.27(VDD1P05_4) U35.37(VDD1P05_3) U35.41(VDD1P05_2) U35.60(VDD1P05_1)
P1V05_LAN2: C461.1 C462.1 C463.1 C464.1 C465.1 C466.1 C467.1 U37.4(VDD1P05_7) U37.11(VDD1P05_6) U37.18(VDD1P05_5) U37.27(VDD1P05_4) U37.37(VDD1P05_3) U37.41(VDD1P05_2) U37.60(VDD1P05_1)
