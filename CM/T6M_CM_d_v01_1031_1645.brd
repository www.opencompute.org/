# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M1_DQ_NODE1_DQ54: length 64.1
  TOP w0.102: v1(87.26,63.39) 86.85,63.81 86.85,66.16 86.44,66.57 86.12,66.57 85.11,67.58 U2.BD63
  TOP w0.165: v1(103.85,25.85) 104.5,25.85 106.68,28.03 J2.174
  IN3 w0.102: v1(87.26,63.39) 87.55,63.1 87.55,58.78
  IN3 w0.203: v1(103.85,25.85) 103.49,25.49 103.49,24.46 103.29,24.26 102.99,24.26 102.99,24.26 102.78,24.47 102.78,25.47 102.58,25.67 102.27,25.67 102.07,25.47 102.07,24.57 101.86,24.37 101.56,24.37 101.36,24.57 101.36,25.89 100.75,26.49 100.75,30.92 100.75,30.92 100.75,32.66 100.2,33.22 100.2,36.08 100.4,36.29 100.76,36.29 100.97,36.5 100.97,36.79 100.76,37 100.4,37 100.2,37.21 100.2,37.5 100.4,37.71 100.76,37.71 100.97,37.92 100.97,38.21 100.76,38.42 100.4,38.42 100.2,38.63 100.2,39.84 99.96,40.07 99.96,40.43 99.63,40.75 99.28,40.75 98.95,41.08 98.95,41.43 98.63,41.76 98.27,41.76 97.95,42.09 97.95,42.44 97.62,42.76 97.27,42.76 96.94,43.09 96.94,43.44 96.61,43.77 96.26,43.77 95.76,44.27 95.76,44.88 93.05,47.59 93.05,48.42 87.55,53.92 87.55,58.78
M1_DQ_NODE1_DQ55: length 63.6
  TOP w0.102: U2.BC64 86,68.08 v1(86.38,67.7)
  TOP w0.165: v1(107.56,27.63) 107.28,27.91 J2.176
  IN3 w0.102: v1(86.38,67.7) 86.76,67.32 87.43,67.32 87.84,67.73 88.9,67.73
  IN3 w0.203: 88.9,67.73 89.93,66.7 92.07,66.7 92.68,66.1 92.68,60.82 98.34,55.16 98.44,55.16 101.61,51.99 101.61,51.7 101.4,51.49 101.11,51.49 98.63,53.97 98.34,53.97 98.13,53.76 98.13,53.46 107.98,43.61 107.98,37.59 107.37,36.98 107.37,27.82 v1(107.56,27.63)
M1_DQ_NODE1_DQ56: length 80.6
  TOP w0.102: v1(88.67,70.9) 88.52,71.05 88.52,71.22 87.68,72.06 86.17,72.06 85.92,71.81 85.3,71.81 84.89,71.4 U2.AT63
  TOP w0.165: J2.183 109.38,20.95 109.38,22.98 109.79,23.39 v1(109.79,24.24)
  IN3 w0.203: v1(109.79,24.24) 109.54,23.99 109.12,23.99 108.95,23.81 108.95,23.33 109.16,23.12 110.31,23.12 110.56,23.38 110.56,24.39 110.28,24.68 110.28,25.22 109.97,25.54 109.97,26.57 110.19,26.8 110.19,31.76 110.03,31.92 110.03,34.34 110.28,34.59 110.28,46.56 103.38,53.46 103.38,53.76 103.59,53.97 103.88,53.97 106.63,51.21 106.93,51.21 107.14,51.42 107.14,51.71 103.67,55.18 103.67,55.54 97.78,61.43 96.75,61.43 95.72,62.46 95.72,63.86 96.14,64.28 96.14,66.16 93.23,69.07 89.92,69.07 88.67,70.33 v1(88.67,70.9)
M1_DQ_NODE1_DQ57: length 80.8
  TOP w0.102: U2.AT64 85.77,71.35 86.16,71.74 87.23,71.74 v1(87.68,71.3)
  TOP w0.165: v1(111.41,24.41) 111.41,24.25 110.78,23.63 110.78,23.48 109.98,22.69 J2.185
  IN3 w0.102: 90.88,72.11 90.39,72.11 90,72.5 90,72.98 89.7,73.28 88.49,73.28 88.24,73.02 88.24,72.69 87.68,72.13 v1(87.68,71.3)
  IN3 w0.203: 90.88,72.11 94.76,72.11 98.2,68.68 101.55,68.68 107.35,62.87 107.35,56.63 113.31,50.67 113.31,40.31 115.89,37.74 115.89,35.42 115.51,35.04 115.51,34.75 116.06,34.21 116.06,33.91 115.85,33.7 115.55,33.7 115.01,34.25 114.72,34.25 114.32,33.84 114.32,33.03 114.52,32.82 115.5,32.82 115.71,32.61 115.71,32.32 115.5,32.11 114.52,32.11 114.32,31.9 114.32,30.25 113.62,29.55 113.17,29.55 112.01,28.38 112.01,25.01 v1(111.41,24.41)
M1_DQ_NODE1_DQ58: length 80.8
  TOP w0.102: v1(87.81,72.86) 87.25,72.31 85.99,72.31 U2.AR65
  TOP w0.165: J2.191 111.78,20.95 111.78,23.48 111.73,23.53 v1(111.73,23.53)
  IN3 w0.102: v1(87.81,72.86) 88.02,73.07 88.02,73.16 88.39,73.53 89.79,73.53 90.58,72.75 90.86,72.75
  IN3 w0.203: 90.86,72.75 95.24,72.75 98.67,69.32 101.81,69.32 107.99,63.14 107.99,56.9 113.95,50.94 113.95,50.53 114.16,50.33 114.31,50.33 114.52,50.12 114.52,49.82 114.31,49.61 114.16,49.61 113.95,49.41 113.95,49.11 114.16,48.9 114.31,48.9 114.52,48.7 114.52,48.4 114.31,48.19 114.16,48.19 113.95,47.98 113.95,47.69 114.16,47.48 114.31,47.48 114.52,47.27 114.52,46.98 114.31,46.77 114.16,46.77 113.95,46.56 113.95,46.27 114.16,46.06 114.31,46.06 114.52,45.85 114.52,45.56 114.31,45.35 114.16,45.35 113.95,45.14 113.95,44.84 114.16,44.64 114.31,44.64 114.52,44.43 114.52,44.13 114.31,43.93 114.16,43.93 113.95,43.72 113.95,43.42 114.16,43.21 114.31,43.21 114.52,43.01 114.52,42.71 114.31,42.5 114.16,42.5 113.95,42.29 113.95,42 114.16,41.79 114.31,41.79 114.52,41.58 114.52,41.29 114.31,41.08 114.16,41.08 113.95,40.87 113.95,40.58 116.69,37.84 116.69,31.69 116.17,31.17 115.88,31.17 115.63,31.42 115.33,31.42 115.13,31.21 115.13,30.92 115.37,30.67 115.37,30.37 113.7,28.7 113.3,28.7 112.72,28.13 112.72,24.53 v1(111.73,23.53)
M1_DQ_NODE1_DQ59: length 80.5
  TOP w0.102: v1(88.61,71.79) 88.62,71.79 88.26,72.15 88.26,73.02 87.96,73.32 85.81,73.32 U2.AN65
  TOP w0.165: v1(111.43,25.29) 112.38,24.33 J2.193
  IN3 w0.102: v1(88.61,71.79) 88.61,71.54 89.58,70.57
  IN3 w0.203: 89.58,70.57 90.44,69.71 93.76,69.71 97.07,66.4 97.07,63.92 96.56,63.41 96.56,62.84 97.05,62.35 97.76,62.35 108.51,51.6 108.51,51.31 107.8,50.6 107.8,50.3 109.58,48.52 109.87,48.52 110.08,48.73 110.08,49.02 108.8,50.3 108.8,50.6 109.01,50.81 109.3,50.81 110.91,49.19 110.91,34.33 110.66,34.08 110.66,32.19 110.83,32.02 110.83,31.53 111.03,31.32 113.25,31.32 113.46,31.12 113.46,31.12 113.46,30.82 113.46,30.82 113.25,30.61 111.03,30.61 110.83,30.4 110.83,29.76 111.03,29.56 111.54,29.56 111.75,29.35 111.75,29.05 111.54,28.85 111.03,28.85 110.83,28.64 110.83,25.89 v1(111.43,25.29)
M1_DQ_NODE1_DQ60: length 80.7
  TOP w0.102: v1(84.71,72.63) 84.61,72.73 84.61,73.76 U2.AL63
  TOP w0.165: J2.180 108.48,27.17 v1(108.23,26.92)
  IN3 w0.203: v1(108.23,26.92) 108.44,27.13 108.44,30.16 108.72,30.44 108.72,35.01 109.01,35.3 109.01,44.02 102.4,50.63 102.4,50.93 102.61,51.14 102.9,51.14 108.28,45.76 108.58,45.76 108.78,45.96 108.78,46.26 94.18,60.86 94.18,60.86 93.76,61.28 93.76,66.45 92.42,67.8 89.54,67.8 88.63,68.71 87.45,68.71 87.02,69.14 86.73,69.14 86.14,68.55 85.82,68.55 85.49,68.88 85.49,69.16 85.94,69.61 85.94,69.9 85.94,69.9 85.45,70.4 85.45,71.9 v1(84.71,72.63)
M1_DQ_NODE1_DQ61: length 80.8
  TOP w0.102: v1(85.78,72.66) 85.78,72.61 85.26,72.08 U2.AR63
  TOP w0.165: J2.182 v1(109.08,26.33)
  IN3 w0.203: v1(109.08,26.33) 109.08,26.83 109.09,26.83 109.12,26.86 109.12,29.95 109.35,30.18 109.35,34.56 109.64,34.86 109.64,46.3 102.74,53.2 102.74,53.2 102.74,55.21 97.48,60.47 97.19,60.47 96.98,60.26 96.98,59.97 101.97,54.97 101.97,54.68 101.76,54.47 101.47,54.47 94.59,61.35 94.59,64.62 94.8,64.83 95.08,64.83 95.28,65.04 95.28,65.33 95.08,65.54 94.8,65.54 94.59,65.75 94.59,66.81 92.97,68.44 89.63,68.44 88.61,69.46 87.95,69.46 87.73,69.68 87.73,70.05 87.29,70.5 86.43,70.5 86.23,70.69 86.23,72.22 v1(85.78,72.66)
M1_DQ_NODE1_DQ62: length 80.8
  TOP w0.102: v1(88.53,74.16) 88.21,74.38 87.75,74.69 87.31,74.99 86.11,74.99 85.98,74.86 85.59,74.86 85.45,75 85.15,75 84.68,74.53 84.68,74.44 U2.AL62
  TOP w0.165: J2.192 112.08,26.61 113.51,25.19 v1(113.67,25.19)
  IN3 w0.102: 90.34,74.02 90.2,74.16 v1(88.53,74.16)
  IN3 w0.203: v1(113.67,25.19) 115.31,25.19 115.81,25.69 115.81,25.98 115.57,26.22 115.57,26.52 115.78,26.73 116.08,26.73 116.31,26.49 116.61,26.49 117.96,27.84 117.96,38.37 115.79,40.54 115.79,51.85 109.26,58.38 109.26,63.67 102.34,70.59 99.28,70.59 95.84,74.02 90.34,74.02
M1_DQ_NODE1_DQ63: length 80.6
  TOP w0.102: v1(86.81,74.16) 86.72,74.08 85.71,74.08 U2.AL65
  TOP w0.165: J2.194 112.68,27.22 113.32,26.58 v1(113.53,26.58)
  IN3 w0.102: v1(86.81,74.16) 87.21,73.75 89.91,73.75 90.28,73.39 90.85,73.39
  IN3 w0.203: v1(113.53,26.58) 113.53,26.28 113.74,26.07 114.23,26.07 114.44,26.28 114.44,28.12 115.58,29.27 115.88,29.27 116.62,28.53 116.9,28.53 117.12,28.75 117.12,29.03 116.38,29.77 116.38,30.07 117.33,31.01 117.33,38.1 115.16,40.27 115.16,50.63 113.83,51.96 113.83,52.25 114.01,52.44 114.01,52.73 113.8,52.94 113.51,52.94 113.32,52.76 113.03,52.76 112.82,52.96 112.82,53.26 113,53.44 113,53.74 112.8,53.95 112.5,53.95 112.32,53.76 112.02,53.76 111.82,53.97 111.82,54.27 112,54.45 112,54.74 111.79,54.95 111.5,54.95 111.31,54.77 111.02,54.77 110.81,54.98 110.81,55.27 110.99,55.45 110.99,55.75 110.78,55.96 110.49,55.96 110.31,55.77 110.01,55.77 109.8,55.98 109.8,56.28 109.99,56.46 109.99,56.75 109.78,56.96 109.48,56.96 109.3,56.78 109.01,56.78 108.62,57.16 108.62,63.4 102.07,69.95 98.93,69.95 95.5,73.39 90.85,73.39
M_DDR3_NODE1_BS0: length 60.4
  TOP w0.102: U2.BL43 74.8,64.26 74.94,64.12 74.94,63.36 74.82,63.25 74.82,62.83 75,62.65 75,61.65 75.98,60.68 75.98,59.31 76.6,58.68 v1(76.6,58.57)
  TOP w0.229: v1(91.34,24.49) 91.01,24.49 90.18,23.66 J2.119
  IN1 w0.229: v1(76.6,58.57) 76.81,58.36 77.46,58.36 78.64,57.19 78.64,56.24 82.04,52.83 83.55,52.83 86.68,49.69 87.39,49.69 90.65,46.43 90.65,42.87 90.85,42.67 91.18,42.67 91.39,42.87 91.39,45.6 91.59,45.81 91.92,45.81 92.12,45.6 92.12,41.84 91.44,41.15 91.44,32.29 91.02,31.87 91.02,26.03 91.46,25.59 91.46,24.61 v1(91.34,24.49)
M_DDR3_NODE1_BS1: length 61.4
  TOP w0.102: 75.48,58.34 75.48,58.6 75.13,58.95 75.13,60.47 74.35,61.25 74.35,62.17 74.25,62.28 74.25,63.49 73.97,63.77 U2.BL41
  TOP w0.229: J2.108 86.88,32.4 87.3,32.82 87.3,34.24 87.52,34.45 87.82,34.45 88.04,34.24 88.04,33.09 88.49,32.64 89.37,32.64 90,33.27 90,34.74 90.39,35.12 90.81,35.12 91.03,35.35 91.03,35.64 90.75,35.92 89.78,35.92 89.57,36.14 89.57,36.44 89.78,36.66 90.8,36.66 91,36.86 91,37.8 90.8,38 v3(90.16,38) 90.03,38.12 89.76,38.12 89.54,38.34 89.54,43.68 89.75,43.89 90.79,43.89 90.79,43.89 91.06,44.15 91.06,46.73 90.81,46.97 90.5,46.97 90.28,46.76 90.28,44.92 90.06,44.7 89.76,44.7 89.76,44.7 89.54,44.91 89.54,48.22 82.93,54.83 76.96,54.83 75.48,56.3 75.48,58.34
M_DDR3_NODE1_BS2: length 62.5
  TOP w0.102: U2.BN32 69.42,62.85 69.21,62.65 69.21,61.28 v1(69.44,61.05)
  TOP w0.229: v1(82.29,23.4) 81.78,22.89 J2.91
  IN1 w0.102: v1(69.44,61.05) 69.01,60.62 69.01,59.04 69.33,58.72 69.33,58.49
  IN1 w0.229: 69.33,58.49 69.33,52.77 72.5,49.59 72.5,46.93 72.29,46.72 71.9,46.72 71.68,46.5 71.68,46.2 71.9,45.98 72.29,45.98 72.5,45.77 72.5,45.46 72.29,45.25 71.9,45.25 71.68,45.03 71.68,44.72 71.9,44.51 72.29,44.51 72.5,44.29 72.5,43.99 72.29,43.77 71.9,43.77 71.68,43.56 71.68,43.25 71.9,43.04 72.29,43.04 72.5,42.82 72.5,42.51 72.29,42.3 71.9,42.3 71.68,42.08 71.68,41.78 71.9,41.56 72.29,41.56 72.5,41.35 72.5,38.48 76.43,34.56 76.43,34.01 76.64,33.79 77.79,33.79 77.99,33.59 77.99,33.26 77.79,33.05 76.64,33.05 76.43,32.84 76.43,32.53 76.64,32.32 76.93,32.32 77.14,32.1 77.14,31.8 76.93,31.58 76.64,31.58 76.43,31.36 76.43,30.52 76.82,30.14 79.08,30.14 79.26,29.96 79.26,29.94 79.79,29.41 79.79,26.93 80.3,26.41 80.26,26.41 80.3,26.37 80.3,25.02 81.26,24.07 83.33,24.07 83.9,23.5 83.9,22.67 83.7,22.47 83.21,22.47 82.96,22.72 82.96,23.01 82.57,23.4 v1(82.29,23.4)
M_DDR3_NODE1_CAS_L: length 59.3
  TOP w0.102: U2.BN46 76.81,62.78 76.81,62.63 78.1,61.34 v1(78.1,61.06)
  TOP w0.229: J2.125 91.98,22.83 92.06,22.91 v1(92.06,22.91)
  IN1 w0.102: 80.48,58.53 80.37,58.53 79.48,59.42 79.48,59.68 v1(78.1,61.06)
  IN1 w0.229: v1(92.06,22.91) 92.6,22.91 92.91,23.21 92.91,23.53 94.21,24.83 94.21,26.52 93.83,26.9 93.83,29.23 94.49,29.89 94.68,29.89 95.55,30.75 95.55,31.95 95.21,32.29 95.21,33.16 95.9,33.84 95.9,34.4 95.68,34.62 95.11,34.62 94.89,34.83 94.89,35.14 95.11,35.36 95.68,35.36 95.9,35.57 95.9,35.88 95.68,36.09 95.11,36.09 94.89,36.31 94.89,36.61 95.11,36.83 95.68,36.83 95.9,37.04 95.9,37.35 95.68,37.57 95.16,37.57 94.95,37.78 94.95,38.09 95.16,38.3 95.68,38.3 95.9,38.52 95.9,38.86 95.9,46.39 88.63,53.66 87.6,53.66 86.04,55.22 85.46,55.22 82.15,58.53 80.48,58.53
M_DDR3_NODE1_CK0N: length 63.5
  TOP w0.099: U2.BD42 74.48,67.87 74.71,68.11 v1(74.87,68.11)
  TOP w0.165: J2.113 88.38,22.15 88.23,22.31 88.23,22.91 v1(88.71,23.39)
  IN1 w0.099: 76.24,66.82 76.24,66.84 76.17,66.9 76.17,67.3 75.88,67.6 74.45,67.6 74.29,67.76 74.29,68 74.4,68.11 v1(74.87,68.11)
  IN1 w0.203: 76.24,66.82 76.24,64.94 75.35,64.06 75.35,63.64 75.65,63.34 78.08,63.34 78.42,62.99 78.42,62.19 78.08,61.84 76.45,61.84 76.07,61.46 76.07,55.47 81.66,49.88 81.96,49.88 82.17,50.09 82.74,50.09 83.14,49.68 83.14,49.12 82.93,48.91 82.93,48.61 83.14,48.4 83.43,48.4 83.64,48.61 84.21,48.61 84.61,48.21 84.61,47.64 84.4,47.43 84.4,47.14 88.09,43.45 88.09,34.61 87.69,34.2 87.69,32.38 87.49,32.19 87.49,30.29 88.42,29.36 88.42,25.78 88.01,25.38 88.01,24.55 88.25,24.31 88.25,23.84 v1(88.71,23.39)
M_DDR3_NODE1_CK0P: length 63.5
  TOP w0.099: U2.BD41 73.4,68.11 v1(73.4,68.12)
  TOP w0.165: J2.111 87.78,22.15 87.94,22.31 87.94,22.89 v1(87.44,23.39)
  IN1 w0.099: 75.91,66.82 75.91,66.84 75.97,66.9 75.97,67.22 75.79,67.4 74.36,67.4 74.09,67.67 74.09,68.03 73.99,68.12 v1(73.4,68.12)
  IN1 w0.203: 75.91,66.82 75.91,65.08 75.02,64.19 75.02,63.5 75.52,63.01 77.94,63.01 78.09,62.85 78.09,62.32 77.94,62.17 76.31,62.17 75.74,61.6 75.74,55.34 81.53,49.55 82.09,49.55 82.3,49.76 82.6,49.76 82.81,49.55 82.81,49.25 82.6,49.04 82.6,48.47 83,48.07 83.57,48.07 83.78,48.28 84.07,48.28 84.28,48.07 84.28,47.78 84.07,47.57 84.07,47 87.76,43.31 87.76,34.74 87.36,34.34 87.36,32.52 87.16,32.32 87.16,30.15 88.09,29.22 88.09,25.92 87.68,25.52 87.68,24.41 87.92,24.17 87.92,23.87 v1(87.44,23.39)
M_DDR3_NODE1_CK1N: length 63.1
  TOP w0.099: v1(74.87,66.58) 74.87,66.47 74.62,66.22 U2.BG42
  TOP w0.165: J2.114 88.68,28.09 88.53,27.93 88.53,27.53 88.07,27.07 87.09,27.07 86.97,26.95 86.97,26.64 v1(87.45,26.16)
  IN1 w0.099: 74.3,65.51 74.3,65.54 74.24,65.6 74.24,66.46 74.37,66.58 v1(74.87,66.58)
  IN1 w0.203: 74.3,65.51 74.3,65.23 73.94,64.87 73.6,64.87 73.44,64.7 73.44,64.2 74.72,62.92 74.72,54.91 81.11,48.52 81.11,48.07 81.82,47.37 82.26,47.37 83.15,46.48 83.15,45.92 82.57,45.34 82.57,45.05 82.78,44.83 83.07,44.83 83.65,45.41 84.22,45.41 85.74,43.9 85.74,42.8 85.33,42.4 84.29,42.4 84.08,42.2 84.08,41.89 84.29,41.69 85.51,41.69 86.05,41.15 86.05,39.73 85,38.69 85,38.09 85.21,37.88 86.2,37.88 86.6,37.48 86.6,36.91 86.2,36.51 85.21,36.51 85,36.3 85,36 85.21,35.79 85.8,35.79 86.2,35.4 86.2,34.82 85.8,34.42 85.21,34.42 85,34.21 85,32.13 85.15,31.98 85.81,31.98 86.12,31.67 86.12,29.63 87.19,28.56 87.19,27.24 86.99,27.03 86.99,26.63 v1(87.45,26.16)
M_DDR3_NODE1_CK1P: length 63.1
  TOP w0.099: v1(73.4,66.6) 73.4,66.59 U2.BG41
  TOP w0.165: J2.112 88.08,28.07 88.23,27.92 88.23,27.65 87.95,27.36 86.97,27.36 86.68,27.08 86.68,26.66 v1(86.18,26.16)
  IN1 w0.099: 73.97,65.51 73.97,65.53 74.04,65.59 74.04,66.48 73.92,66.6 v1(73.4,66.6)
  IN1 w0.203: v1(86.18,26.16) 86.66,26.63 86.66,27.17 86.86,27.38 86.86,28.42 85.79,29.5 85.79,31.53 85.67,31.65 85.02,31.65 84.67,31.99 84.67,34.35 85.08,34.75 85.67,34.75 85.87,34.96 85.87,35.26 85.67,35.46 85.08,35.46 84.67,35.87 84.67,36.43 85.08,36.84 86.06,36.84 86.27,37.04 86.27,37.34 86.06,37.55 85.08,37.55 84.67,37.95 84.67,38.83 85.72,39.87 85.72,41.01 85.37,41.36 84.15,41.36 83.75,41.75 83.75,42.33 84.15,42.73 85.2,42.73 85.41,42.94 85.41,43.76 84.08,45.08 83.79,45.08 83.21,44.5 82.65,44.5 82.24,44.91 82.24,45.47 82.82,46.05 82.82,46.35 82.13,47.04 81.68,47.04 80.78,47.94 80.78,48.38 74.39,54.78 74.39,62.78 73.11,64.06 73.11,64.84 73.47,65.2 73.81,65.2 73.97,65.36 73.97,65.51
M_DDR3_NODE1_CKE0: length 62.2
  TOP w0.102: U2.BL46 76.43,63.65 76.1,63.31 76.1,63.01 77.52,61.59 77.52,60.9 77.96,60.46 77.96,57.81 77.18,57.03 v1(77.18,56.51)
  TOP w0.165: v1(80.9,23.57) 80.58,23.25 J2.87
  IN1 w0.203: v1(77.18,56.51) 77.18,55.83 81.53,51.48 82.95,51.48 89.15,45.29 89.15,42.11 89.76,41.5 89.76,32.43 89.74,32.41 89.74,24.39 89.6,24.25 89.6,22.27 88.72,21.39 82.54,21.39 81.76,22.17 81.76,23.08 81.46,23.37 81.09,23.37 v1(80.9,23.57)
M_DDR3_NODE1_CKE1: length 63.6
  TOP w0.102: U2.BK45 75.66,64.6 75.66,63.88 75.51,63.73 75.51,63.38 75.75,63.13 75.75,62.41 76.27,61.9 76.44,61.9 77.09,61.25 77.09,57.8 v1(76.88,57.58)
  TOP w0.165: J2.89 v1(81.18,22.75)
  IN1 w0.203: v1(76.88,57.58) 76.88,57.58 77.22,57.58 77.97,56.83 77.97,55.94 81.79,52.12 83.21,52.12 89.83,45.5 89.83,42.41 90.52,41.73 90.52,34.16 90.74,33.93 90.74,32.51 90.37,32.14 90.37,22.14 88.96,20.73 82.29,20.73 81.1,21.91 81.1,22.67 v1(81.18,22.75)
M_DDR3_NODE1_CMDPU: length 4.7
  TOP w0.254: U2.BH34 70.53,65.46 v1(70.9,65.82)
  BOTTOM w0.254: v1(70.9,65.82) 70.69,65.62 70.69,64.59 70.53,64.44 v2(70.53,63.35) 70.53,63.2 70.2,62.87 R28.2
M_DDR3_NODE1_CS0_L: length 60.9
  TOP w0.102: v1(76.65,61.06) 76.32,61.4 76.01,61.4 75.54,61.86 75.54,62.85 U2.BN44
  TOP w0.165: J2.127 92.58,22.92 92.58,24.16 v1(92.8,24.37)
  IN1 w0.102: v1(76.65,61.06) 76.86,60.86 76.86,59.88 77.21,59.53 77.98,59.53 80.15,57.37 80.15,57.19
  IN1 w0.203: v1(92.8,24.37) 92.77,24.4 92.77,26.13 92.46,26.44 92.46,29.94 93.24,30.72 93.24,32.24 92.93,32.55 92.93,33.53 93.52,34.13 93.52,38.87 93.73,39.08 93.96,39.08 94.17,39.29 94.17,39.59 93.96,39.79 93.73,39.79 93.52,40 93.52,45.37 93.73,45.58 93.98,45.58 94.19,45.78 94.19,46.08 93.98,46.29 93.73,46.29 93.52,46.5 93.52,46.73 88.17,52.08 87.33,52.08 85.99,53.42 85.14,53.42 84.42,54.14 82.7,54.14 81.37,55.48 81.37,55.77 81.57,55.98 81.87,55.98 82.99,54.86 83.29,54.86 83.49,55.07 83.49,55.36 81.87,56.99 81.57,56.99 80.86,56.28 80.57,56.28 80.15,56.7 80.15,57.19
M_DDR3_NODE1_CS1_L: length 60.5
  TOP w0.102: U2.BP46 76.09,62.55 77.29,61.35 77.29,60.44 v1(77.55,60.18)
  TOP w0.165: v1(93.5,25.04) 93.5,24.03 93.18,23.71 93.18,22.08 93.18,22.08 J2.129
  IN1 w0.102: 80.6,57.75 80.46,57.75 78.03,60.18 v1(77.55,60.18)
  IN1 w0.203: v1(93.5,25.04) 93.5,26.3 93.09,26.71 93.09,29.49 94.14,30.54 94.35,30.54 94.83,31.02 94.83,31.73 94.55,32.01 94.55,32.54 94.34,32.75 93.8,32.75 93.59,32.96 93.59,33.26 93.8,33.46 94.34,33.46 94.55,33.67 94.55,34.03 94.21,34.38 94.21,38.34 95.21,39.34 95.21,39.99 95,40.2 94.5,40.2 94.29,40.41 94.29,40.71 94.5,40.91 95,40.91 95.21,41.12 95.21,41.42 95,41.62 94.5,41.62 94.29,41.83 94.29,42.13 94.5,42.34 95,42.34 95.21,42.54 95.21,42.84 95,43.05 94.5,43.05 94.29,43.26 94.29,43.55 94.5,43.76 95,43.76 95.21,43.97 95.21,44.26 95,44.47 94.5,44.47 94.29,44.68 94.29,44.97 94.5,45.18 95,45.18 95.21,45.39 95.21,46.15 88.58,52.79 87.55,52.79 86.08,54.27 85.24,54.27 84.36,55.15 84.36,55.4 82,57.75 80.6,57.75
M_DDR3_NODE1_DQPU: length 3.9
  TOP w0.254: U2.BG34 70.53,66.22 v1(70.9,66.58)
  BOTTOM w0.254: v1(70.9,66.58) 70.07,65.76 v2(70.07,65.12) 70.07,64.66 R29.1
M_DDR3_NODE1_DQS0N: length 69.7
  TOP w0.099: v1(61.48,65.84) 61.58,65.74 61.58,65.74 U2.BH17
  TOP w0.165: J2.10 55.08,30.35 55.24,30.5 55.24,30.85 v1(54.75,31.34)
  IN3 w0.099: 56.27,58.93 56.29,58.95 56.38,58.95 57.92,60.5 58.96,60.5 59.29,60.83 59.29,62.02 60.34,63.07 60.34,63.25 61.95,64.86 61.95,66.07 61.89,66.13 61.78,66.13 v1(61.48,65.84)
  IN3 w0.203: 56.27,58.93 55.95,58.62 55.95,58.13 54.31,56.49 53.3,56.49 52.89,56.09 52.89,55.6 52.74,55.44 52.34,55.44 52.18,55.6 52.18,56.09 51.78,56.49 50.35,56.49 48.86,55 48.86,54.43 49.22,54.07 49.22,53.78 49.01,53.57 48.72,53.57 48.36,53.93 47.79,53.93 46.67,52.81 46.67,50.69 46.56,50.58 46.56,49.97 46.67,49.86 46.67,48.9 46.56,48.79 46.56,48.19 46.67,48.08 46.67,47.12 46.56,47.01 46.56,46.4 46.67,46.29 46.67,42.31 48.48,40.51 48.91,40.51 49.47,39.95 49.47,39.64 48.4,38.57 48.4,37.99 52.77,33.63 53.35,33.63 53.76,34.04 53.76,34.62 50.24,38.13 50.24,38.44 50.46,38.65 50.77,38.65 55.86,33.56 55.86,32.87 55.22,32.23 55.22,31.81 v1(54.75,31.34)
M_DDR3_NODE1_DQS0P: length 69.7
  TOP w0.099: v1(61.48,66.6) 61.55,66.53 61.55,66.52 U2.BG17
  TOP w0.165: J2.12 55.68,30.35 55.53,30.5 55.53,30.85 v1(56.02,31.34)
  IN3 w0.099: v1(61.48,66.6) 61.75,66.33 61.97,66.33 62.15,66.16 62.15,64.77 60.55,63.17 60.55,62.99 59.5,61.94 59.5,60.74 59.05,60.29 58.01,60.29 56.52,58.81 56.52,58.72 56.5,58.7
  IN3 w0.203: 56.5,58.7 56.28,58.48 56.28,57.99 54.45,56.16 53.43,56.16 53.22,55.95 53.22,55.46 52.88,55.11 52.2,55.11 51.85,55.46 51.85,55.95 51.64,56.16 50.49,56.16 49.19,54.86 49.19,54.57 49.55,54.21 49.55,53.64 49.15,53.24 48.58,53.24 48.22,53.6 47.93,53.6 47,52.67 47,42.45 48.61,40.84 49.05,40.84 49.8,40.08 49.8,39.5 48.73,38.44 48.73,38.13 52.9,33.96 53.21,33.96 53.43,34.18 53.43,34.48 49.91,37.99 49.91,38.57 50.32,38.98 50.9,38.98 56.19,33.69 56.19,32.74 55.55,32.09 55.55,31.81 v1(56.02,31.34)
M_DDR3_NODE1_DQS1N: length 68.8
  TOP w0.099: U2.BM16 61.08,63.25 60.58,62.74 60.58,60.7 60.52,60.65 60.37,60.65 60.01,61 v1(60.01,61.01)
  TOP w0.165: J2.25 59.58,22.15 59.74,22.31 59.74,22.51 59.49,22.75 59.49,23.2 59.36,23.33 v1(59,23.33)
  IN1 w0.099: v1(60.01,61.01) 59.68,60.68 59.5,60.68 59.27,60.45 59.27,58.25 58.94,57.92 57.82,57.92 57.34,57.44 56.7,57.44 56.64,57.5 56.63,57.5
  IN1 w0.203: v1(59,23.33) 59.46,23.79 59.46,24.19 59.84,24.57 60.72,24.57 61.13,24.98 61.13,25.84 60.58,26.39 60.58,28.87 60.18,29.28 60.18,31.62 60.68,32.12 60.68,32.59 57.8,35.48 52.49,35.48 48.89,39.07 48.89,40.61 48.68,40.82 48.41,40.82 48.01,41.22 48.01,41.79 48.41,42.19 48.68,42.19 48.89,42.39 48.89,42.69 48.68,42.9 48.41,42.9 48.01,43.3 48.01,43.87 48.41,44.27 48.68,44.27 48.89,44.48 48.89,44.77 48.68,44.98 48.41,44.98 48.01,45.38 48.01,45.95 48.41,46.35 48.68,46.35 48.89,46.56 48.89,46.86 48.68,47.06 48.41,47.06 48.01,47.46 48.01,48.03 48.41,48.44 48.68,48.44 48.89,48.64 48.89,48.94 48.68,49.15 48.41,49.15 48.01,49.55 48.01,50.12 48.41,50.52 48.68,50.52 48.89,50.73 48.89,51.02 48.68,51.23 48.41,51.23 48.01,51.63 48.01,52.2 48.41,52.6 48.68,52.6 48.89,52.81 48.89,53.68 51.61,56.4 54.02,56.4 55.12,57.5 56.63,57.5
M_DDR3_NODE1_DQS1P: length 68.9
  TOP w0.099: v1(60.01,60.15) 60.31,60.44 60.6,60.44 60.78,60.62 60.78,62.66 61.26,63.14 61.37,63.14 61.52,62.99 U2.BN17
  TOP w0.165: J2.27 60.18,22.15 60.03,22.31 60.03,22.63 59.79,22.87 59.79,23.21 59.91,23.33 v1(60.27,23.33)
  IN1 w0.099: 56.63,57.17 56.65,57.17 56.72,57.23 57.42,57.23 57.9,57.72 59.02,57.72 59.47,58.17 59.47,60.37 59.58,60.48 59.68,60.48 v1(60.01,60.15)
  IN1 w0.203: 56.63,57.17 55.25,57.17 54.15,56.07 51.75,56.07 49.22,53.55 49.22,52.67 48.82,52.27 48.55,52.27 48.34,52.06 48.34,51.77 48.55,51.56 48.82,51.56 49.22,51.16 49.22,50.59 48.82,50.19 48.55,50.19 48.34,49.98 48.34,49.68 48.55,49.48 48.82,49.48 49.22,49.07 49.22,48.51 48.82,48.1 48.55,48.1 48.34,47.9 48.34,47.6 48.55,47.39 48.82,47.39 49.22,46.99 49.22,46.42 48.82,46.02 48.55,46.02 48.34,45.81 48.34,45.52 48.55,45.31 48.82,45.31 49.22,44.91 49.22,44.34 48.82,43.94 48.55,43.94 48.34,43.73 48.34,43.44 48.55,43.23 48.82,43.23 49.22,42.83 49.22,42.26 48.82,41.86 48.55,41.86 48.34,41.65 48.34,41.35 48.55,41.15 48.82,41.15 49.22,40.74 49.22,39.21 52.63,35.81 57.93,35.81 61.01,32.73 61.01,31.98 60.51,31.48 60.51,29.41 60.91,29 60.91,26.52 61.46,25.98 61.46,24.85 60.85,24.24 59.97,24.24 59.79,24.06 59.79,23.81 v1(60.27,23.33)
M_DDR3_NODE1_DQS2N: length 63.4
  TOP w0.099: v1(66.92,67.35) 66.92,67.35 66.53,67.73 U2.BD26
  TOP w0.165: v1(65.1,24.63) 65.58,24.14 65.58,23.81 65.14,23.36 65.14,22.31 64.98,22.15 J2.43
  IN3 w0.099: 64.33,57.39 64.35,57.41 64.43,57.41 65.14,58.12 65.14,59.14 65,59.28 65,62.69 65.91,63.6 65.91,64.16 66.43,64.68 66.43,65.3 66.11,65.62 66.11,66.84 66.4,67.13 66.71,67.13 v1(66.92,67.35)
  IN3 w0.203: 64.33,57.39 57.71,50.78 57.71,46.26 57.51,46.05 57.21,46.05 57,46.26 57,48.63 56.6,49.03 56.03,49.03 55.63,48.63 55.63,42.9 64.17,34.36 64.17,26.81 65.5,25.48 65.5,25.03 v1(65.1,24.63)
M_DDR3_NODE1_DQS2P: length 63.3
  TOP w0.099: U2.BE26 66.53,66.98 66.92,66.59 v1(66.92,66.58)
  TOP w0.165: J2.45 65.58,22.15 65.43,22.31 65.43,23.24 65.88,23.69 65.88,24.14 v1(66.37,24.63)
  IN3 w0.099: 64.56,57.16 64.58,57.18 64.58,57.27 64.58,57.27 65.35,58.04 65.35,59.22 65.2,59.37 65.2,62.61 66.11,63.51 66.11,64.08 66.63,64.6 66.63,65.39 66.32,65.7 66.32,66.75 66.49,66.92 66.84,66.92 66.92,66.84 v1(66.92,66.58)
  IN3 w0.203: 64.56,57.16 58.85,51.45 58.04,50.65 58.04,46.12 57.64,45.72 57.07,45.72 56.67,46.12 56.67,48.49 56.46,48.7 56.17,48.7 55.96,48.49 55.96,43.03 56.64,42.35 56.8,42.35 57.23,41.92 57.23,41.92 57.25,41.9 57.25,41.74 64.5,34.49 64.5,26.94 65.83,25.62 65.83,25.17 v1(66.37,24.63)
M_DDR3_NODE1_DQS3N: length 62.3
  TOP w0.099: U2.BM25 65.91,63.16 65.91,62.72 66.32,62.31 66.32,61 66.21,60.89 65.97,60.89 65.86,60.99 v1(65.86,61.16)
  TOP w0.165: J2.60 70.08,30.35 70.24,30.5 70.24,30.9 70.47,31.13 70.47,31.46 v1(69.98,31.95)
  IN1 w0.099: 64.93,56.84 64.93,56.87 64.99,56.93 64.99,57.58 64.75,57.81 64.75,60.36 65.22,60.83 65.53,60.83 v1(65.86,61.16)
  IN1 w0.203: v1(69.98,31.95) 70.47,32.44 70.47,32.98 61.07,42.38 61.07,48.24 61.48,48.64 62.04,48.64 62.45,48.24 62.45,43.79 62.65,43.58 62.95,43.58 63.16,43.79 63.16,50.26 64.93,52.03 64.93,52.33 64.72,52.53 64.43,52.53 61.72,49.83 61.15,49.83 60.75,50.23 60.75,50.8 64.93,54.97 64.93,56.84
M_DDR3_NODE1_DQS3P: length 62.3
  TOP w0.099: v1(65.86,60.3) 65.86,60.57 65.98,60.69 66.29,60.69 66.52,60.91 66.52,62.4 66.12,62.8 66.12,62.99 66.19,63.06 66.33,63.06 U2.BN26
  TOP w0.165: v1(71.25,31.95) 70.76,31.46 70.76,31.01 70.53,30.78 70.53,30.5 70.68,30.35 J2.62
  IN1 w0.099: 65.26,56.84 65.26,56.87 65.19,56.93 65.19,57.66 64.95,57.9 64.95,60.27 65.31,60.63 65.53,60.63 v1(65.86,60.3)
  IN1 w0.203: 65.26,56.84 65.26,54.84 61.08,50.66 61.08,50.37 61.29,50.16 61.59,50.16 64.29,52.87 64.86,52.87 65.26,52.46 65.26,51.89 63.49,50.12 63.49,49.45 63.6,49.33 63.6,48.93 63.49,48.82 63.49,48.23 63.6,48.12 63.6,47.71 63.49,47.6 63.49,43.65 63.09,43.25 62.52,43.25 62.12,43.65 62.12,48.1 61.91,48.31 61.61,48.31 61.41,48.1 61.41,42.51 70.8,33.12 70.8,32.4 v1(71.25,31.95)
M_DDR3_NODE1_DQS4N: length 61
  TOP w0.099: U2.BN55 80.93,62.78 81.18,62.53 v1(81.18,62.19)
  TOP w0.165: v1(96.02,23.58) 96.52,23.08 96.52,22.89 96.34,22.71 96.34,22.31 96.18,22.15 J2.139
  IN3 w0.099: v1(81.18,62.19) 80.98,62.39 80.98,62.7 81.12,62.84 81.51,62.84 81.91,62.44 81.91,61.73 82.37,61.27 83.27,61.27 83.54,61 83.54,60.01 82.72,59.18 82.72,58.57 82.65,58.51 82.65,58.48
  IN3 w0.203: v1(96.02,23.58) 96.33,23.58 96.53,23.78 96.53,24.12 95.92,24.73 95.92,27.68 94.71,28.89 94.71,30.06 94.71,30.06 94.71,31.29 93.94,32.06 93.94,36.84 91.73,39.06 91.43,39.06 90.84,38.46 90.27,38.46 89.87,38.86 89.87,39.43 90.46,40.03 90.46,40.32 90.26,40.53 89.96,40.53 89.37,39.94 88.8,39.94 88.4,40.34 88.4,40.91 88.99,41.5 88.99,41.79 88.78,42 88.49,42 88.29,41.8 87.72,41.8 87.32,42.2 87.32,42.77 87.52,42.97 87.52,43.27 86.12,44.66 86.12,45.23 86.44,45.55 86.44,45.84 86.23,46.05 85.94,46.05 85.62,45.73 85.05,45.73 84.65,46.14 84.65,46.7 85.08,47.14 85.08,47.43 84.87,47.64 84.58,47.64 84.15,47.21 83.58,47.21 82.65,48.13 82.65,54.39 82.53,54.51 82.53,55.12 82.65,55.24 82.65,58.48
M_DDR3_NODE1_DQS4P: length 61.1
  TOP w0.099: v1(80.41,63.05) 80.41,63.13 80.94,63.66 U2.BL55
  TOP w0.165: J2.141 96.78,22.15 96.63,22.31 96.63,22.59 96.81,22.77 96.81,23.09 v1(97.29,23.58)
  IN3 w0.099: 82.98,58.48 82.98,58.51 82.92,58.57 82.92,59.1 83.74,59.92 83.74,61.08 83.35,61.47 82.45,61.47 82.11,61.81 82.11,62.53 81.6,63.04 80.41,63.04 v1(80.41,63.05)
  IN3 w0.203: v1(97.29,23.58) 97.09,23.58 96.86,23.8 96.86,24.26 96.25,24.87 96.25,27.82 95.04,29.03 95.04,29.73 95.04,31.43 94.27,32.2 94.27,36.98 91.87,39.39 91.3,39.39 90.7,38.79 90.41,38.79 90.2,39 90.2,39.3 90.8,39.89 90.8,40.46 90.39,40.86 89.82,40.86 89.23,40.27 88.94,40.27 88.73,40.47 88.73,40.77 89.32,41.36 89.32,41.93 88.92,42.33 88.35,42.33 88.15,42.13 87.85,42.13 87.65,42.34 87.65,42.63 87.85,42.84 87.85,43.4 86.45,44.8 86.45,45.09 86.77,45.41 86.77,45.98 86.37,46.38 85.8,46.38 85.48,46.06 85.19,46.06 84.98,46.27 84.98,46.57 85.41,47 85.41,47.57 85.01,47.97 84.44,47.97 84.01,47.54 83.71,47.54 82.98,48.27 82.98,58.48
M_DDR3_NODE1_DQS5N: length 63.8
  TOP w0.102: v1(83.7,66.78) 84.1,66.39 U2.BF62
  TOP w0.165: J2.154 100.68,30.35 100.84,30.5 100.84,30.97 100.33,31.47 100.33,32.71 100.67,33.04 101.09,33.04 v1(101.31,33.27)
  IN1 w0.099: v1(83.7,66.78) 83.7,66.66 83.79,66.57 84.01,66.57 84.34,66.24 84.34,65.28 85.88,63.74 85.88,62.92 86.41,62.38 86.5,62.38 86.52,62.37
  IN1 w0.203: v1(101.31,33.27) 101.31,33.27 101.1,33.05 100.89,33.05 100.68,33.26 100.68,34.82 101.44,35.58 102.74,35.58 103.43,36.27 103.43,49.21 95.49,57.16 94.92,57.16 94.52,56.75 94.52,56.19 97.04,53.66 97.04,53.37 96.83,53.16 96.54,53.16 93.37,56.32 93.37,56.62 94.42,57.66 94.42,58.23 93.32,59.32 89.56,59.32 86.52,62.37
M_DDR3_NODE1_DQS5P: length 63.9
  TOP w0.099: U2.BH62 83.94,65.85 83.89,65.85 v1(83.65,66.1)
  TOP w0.165: v1(101.31,32.5) 101.31,32.51 101.07,32.75 100.79,32.75 100.63,32.58 100.63,31.59 101.13,31.09 101.13,30.5 101.28,30.35 J2.156
  IN1 w0.099: 86.29,62.13 86.27,62.15 86.27,62.24 85.67,62.83 85.67,63.66 84.14,65.2 84.14,66.16 83.93,66.37 83.72,66.37 83.65,66.3 v1(83.65,66.1)
  IN1 w0.203: v1(101.31,32.5) 101.31,32.5 101.09,32.72 100.75,32.72 100.35,33.12 100.35,34.96 101.3,35.91 102.61,35.91 103.1,36.41 103.1,45.46 102.98,45.58 102.98,46.19 103.1,46.31 103.1,47.1 102.98,47.22 102.98,47.83 103.1,47.96 103.1,49.07 95.35,56.83 95.06,56.83 94.85,56.62 94.85,56.32 97.37,53.8 97.37,53.23 96.97,52.83 96.4,52.83 93.04,56.19 93.04,56.75 94.09,57.8 94.09,58.09 93.19,58.99 89.43,58.99 86.29,62.13
M_DDR3_NODE1_DQS6N: length 65.1
  TOP w0.099: U2.BB65 85.67,68.45 85.75,68.38 85.86,68.38 86.17,68.69 86.98,68.69 87.65,68.01 87.65,67.02 87.96,66.72 87.96,66.08 87.65,65.78 87.65,65.1 87.86,64.89 88.2,64.89 88.31,64.78 v1(88.31,64.48)
  TOP w0.165: v1(105.45,23.3) 105.94,22.81 105.94,22.31 105.78,22.15 J2.171
  IN3 w0.099: v1(88.31,64.48) 88.31,64.82 88.42,64.92 88.59,64.92 88.78,64.73 88.78,63.27 88.72,63.2 88.72,63.19
  IN3 w0.203: v1(105.45,23.3) 105.58,23.3 105.89,23.61 105.89,23.87 105.71,24.05 105.23,24.05 104.7,24.58 104.7,25.9 104.04,26.55 103.45,26.55 102.75,27.26 102.75,29.19 102.96,29.4 102.96,39.09 102.79,39.25 102.48,39.25 101.99,39.74 101.99,40.87 102.39,41.27 103.66,41.27 103.87,41.48 103.87,41.77 103.66,41.98 101.87,41.98 100.47,43.37 100.47,44.61 100.24,44.84 99.4,44.84 99,45.25 99,46.1 98.78,46.32 97.93,46.32 96.77,47.48 96.6,47.48 96.17,47.91 96.17,47.91 96.17,48.08 95.53,48.72 95.36,48.72 94.92,49.15 94.92,49.15 94.92,49.32 94.28,49.96 94.11,49.96 93.68,50.4 93.68,50.4 93.68,50.57 93.04,51.21 92.87,51.21 92.44,51.64 92.43,51.64 92.43,51.81 91.79,52.45 91.62,52.45 91.19,52.88 91.19,53.05 89.21,55.04 89.21,58.53 88.72,59.02 88.72,63.19
M_DDR3_NODE1_DQS6P: length 65.1
  TOP w0.099: v1(88.31,65.34) 88.07,65.09 87.94,65.09 87.86,65.18 87.86,65.69 88.16,66 88.16,66.8 87.86,67.11 87.86,68.09 87.06,68.89 85.95,68.89 85.81,69.03 85.6,69.03 U2.BB63
  TOP w0.165: J2.173 106.38,22.15 106.23,22.31 106.23,22.81 v1(106.72,23.3)
  IN3 w0.099: 89.05,63.19 89.05,63.2 88.99,63.27 88.99,64.82 88.67,65.13 88.41,65.13 88.31,65.22 88.31,65.34 v1(88.31,65.34)
  IN3 w0.203: v1(106.72,23.3) 106.43,23.3 106.22,23.51 106.22,24.01 105.85,24.38 105.36,24.38 105.03,24.72 105.03,26.04 104.18,26.88 103.59,26.88 103.08,27.4 103.08,29.05 103.29,29.26 103.29,39.23 102.93,39.59 102.61,39.59 102.32,39.88 102.32,40.73 102.52,40.94 103.8,40.94 104.2,41.34 104.2,41.91 103.8,42.31 102.01,42.31 100.8,43.51 100.8,44.2 100.8,44.74 100.37,45.17 99.83,45.17 99.54,45.17 99.33,45.38 99.33,46.23 98.92,46.65 98.07,46.65 96.6,48.11 89.54,55.18 89.54,58.67 89.05,59.16 89.05,63.19
M_DDR3_NODE1_DQS7N: length 82.1
  TOP w0.099: v1(88.67,72.86) 88.94,72.86 89.07,72.99 89.07,73.15 88.69,73.53 85.42,73.53 85.28,73.39 U2.AP64
  TOP w0.165: J2.186 110.28,30.35 110.44,30.5 110.44,30.8 111.13,31.49 111.99,31.49 112.37,31.87 112.37,32.14 v1(111.88,32.63)
  IN3 w0.099: v1(88.67,72.86) 88.92,72.86 89.05,72.73 89.05,72.24 90.5,70.8 91.38,70.8 91.45,70.73 91.46,70.73
  IN3 w0.203: v1(111.88,32.63) 111.9,32.63 112.37,33.1 112.37,34.01 111.97,34.41 111.97,35.37 112.37,35.77 114.34,35.77 114.54,35.98 114.54,36.27 114.34,36.48 112.37,36.48 111.97,36.88 111.97,37.45 112.37,37.85 113.16,37.85 113.37,38.06 113.37,38.35 113.16,38.56 112.37,38.56 111.97,38.96 111.97,50.11 108.65,53.43 108.53,53.43 108.1,53.86 108.1,53.86 108.1,53.98 107.46,54.62 107.34,54.62 106.91,55.05 106.91,55.17 106.01,56.07 106.01,59.89 105.8,60.1 105.5,60.1 105.3,59.89 105.3,57.68 104.89,57.27 104.33,57.27 103.92,57.68 103.92,61.07 104.33,61.47 105.8,61.47 106.01,61.68 106.01,62.32 102.75,65.57 102.46,65.57 102.05,65.16 101.48,65.16 101.08,65.56 101.08,66.13 101.49,66.54 101.49,66.83 100.99,67.33 97.64,67.33 94.24,70.73 91.46,70.73
M_DDR3_NODE1_DQS7P: length 82
  TOP w0.099: v1(89.54,72.86) 89.4,72.86 89.27,72.99 89.27,73.24 88.78,73.73 85.34,73.73 85.04,73.44 85.04,73.3 U2.AN63
  TOP w0.165: J2.188 110.88,30.35 110.73,30.5 110.73,30.68 111.25,31.2 112.11,31.2 112.66,31.75 112.66,32.14 v1(113.15,32.63)
  IN3 w0.099: 91.46,71.06 91.41,71 90.58,71 89.26,72.33 89.26,72.72 89.4,72.86 v1(89.54,72.86)
  IN3 w0.203: v1(113.15,32.63) 112.7,33.07 112.7,34.14 112.3,34.54 112.3,35.23 112.51,35.44 114.47,35.44 114.87,35.84 114.87,36.41 114.47,36.81 112.51,36.81 112.3,37.02 112.3,37.31 112.51,37.52 113.29,37.52 113.7,37.92 113.7,38.49 113.29,38.89 112.51,38.89 112.3,39.1 112.3,50.25 106.34,56.21 106.34,60.02 105.94,60.43 105.37,60.43 104.97,60.02 104.97,57.81 104.76,57.6 104.46,57.6 104.25,57.81 104.25,60.93 104.46,61.14 105.94,61.14 106.34,61.54 106.34,62.45 102.89,65.9 102.32,65.9 101.91,65.49 101.62,65.49 101.41,65.7 101.41,65.99 101.82,66.4 101.82,66.97 101.13,67.66 97.77,67.66 94.38,71.06 91.46,71.06
M_DDR3_NODE1_DQSECCN: length 62.9
  TOP w0.099: U2.BG49 77.75,66.21 v1(77.37,65.84)
  TOP w0.165: J2.75 76.98,22.15 77.14,22.31 77.14,22.56 76.77,22.92 76.06,22.92 75.66,23.32 75.66,23.65 v1(75.17,24.14)
  IN3 w0.099: 73.66,58.59 73.66,58.62 73.72,58.68 73.72,59.38 74.61,60.26 74.61,61.89 76.7,63.99 76.7,64.16 77.82,65.28 77.82,66 77.63,66.19 77.5,66.19 77.37,66.06 v1(77.37,65.84)
  IN3 w0.203: v1(75.17,24.14) 75.64,24.61 75.64,25.26 77.21,26.83 77.21,29.96 76.11,31.06 76.11,35.96 74.9,37.17 74.57,37.17 72.59,39.14 72.59,43.6 72.99,44 73.56,44 73.96,43.6 73.96,40.91 74.17,40.71 74.47,40.71 74.67,40.91 74.67,44.5 74.47,44.71 72.99,44.71 72.59,45.11 72.59,46.43 72.47,46.55 72.47,47.16 72.59,47.29 72.59,48.15 72.47,48.27 72.47,48.88 72.59,49 72.59,49.87 72.47,49.99 72.47,50.6 72.59,50.72 72.59,51.58 72.47,51.71 72.47,52.32 72.59,52.44 72.59,57.26 73.66,58.33 73.66,58.59
M_DDR3_NODE1_DQSECCP: length 62.9
  TOP w0.099: U2.BE49 77.57,66.98 v1(77.29,66.7)
  TOP w0.165: J2.77 77.58,22.15 77.43,22.31 77.43,22.68 76.89,23.21 76.18,23.21 75.95,23.44 75.95,23.65 v1(76.44,24.14)
  IN3 w0.099: 73.99,58.59 73.99,58.62 73.93,58.68 73.93,59.3 74.81,60.18 74.81,61.81 76.91,63.91 76.91,64.08 78.02,65.2 78.02,66.09 77.72,66.39 77.49,66.39 77.29,66.6 v1(77.29,66.7)
  IN3 w0.203: v1(76.44,24.14) 75.97,24.61 75.97,25.12 77.54,26.69 77.54,30.1 76.44,31.2 76.44,36.1 75.04,37.5 74.7,37.5 72.92,39.28 72.92,43.46 73.13,43.67 73.42,43.67 73.63,43.46 73.63,40.78 74.03,40.38 74.6,40.38 75,40.78 75,44.64 74.6,45.04 73.13,45.04 72.92,45.25 72.92,57.12 73.99,58.19 73.99,58.59
M_DDR3_NODE1_ECC0: length 62.2
  TOP w0.102: v1(78.9,66.64) 78.88,66.64 78.45,66.22 U2.BG50
  TOP w0.165: v1(72.88,23.39) 72.88,22.79 72.88,22.79 72.78,22.69 J2.69
  IN3 w0.102: v1(78.9,66.64) 79.44,66.1 79.44,64.51 78.97,64.04 78.97,63.64 78.66,63.33
  IN3 w0.203: v1(72.88,23.39) 73.05,23.22 73.05,22.19 73.82,21.42 78.61,21.42 79.3,22.11 79.3,23.04 80.07,23.82 80.07,24.79 81.96,26.67 81.96,27.82 83.74,29.6 83.74,32.81 83.53,33.02 82.85,33.02 82.64,33.23 82.64,33.52 82.85,33.73 83.53,33.73 83.74,33.94 83.74,34.45 78.43,39.76 78.43,59.85 78.66,60.08 78.66,60.22 78.66,60.22 78.66,63.33
M_DDR3_NODE1_ECC1: length 61.8
  TOP w0.102: v1(77.37,68.88) 77.75,68.51 U2.BB49
  TOP w0.165: J2.71 73.38,22.06 73.66,22.34 73.66,22.36 v1(73.85,22.55)
  IN3 w0.102: v1(77.37,68.88) 76.47,67.98 76.47,67.19 75.94,66.66 75.94,65.41 74.89,64.36 74.56,64.36 72.79,62.58 72.79,61.79 71.78,60.78
  IN3 w0.203: 71.78,60.78 71.56,60.56 70.77,60.56 69.94,59.73 69.94,59 69.29,58.36 69.29,53.69 65.21,49.61 65.21,39.83 68.67,36.38 68.67,34.56 70.02,33.21 71.73,33.21 72.45,32.49 72.45,31.18 71.8,30.53 71.8,28.46 71.6,28.26 71.6,26.22 72.35,25.46 72.35,24.61 72.64,24.33 73.01,24.33 73.68,25 74,25 74.23,24.77 74.23,24.45 73.74,23.96 73.74,22.66 v1(73.85,22.55)
M_DDR3_NODE1_ECC2: length 61.8
  TOP w0.102: U2.BK51 78.68,64.74 78.98,65.04 78.98,65.09 v1(79.03,65.14)
  TOP w0.165: v1(79.01,25.38) 78.42,24.79 78.42,23.41 78.78,23.05 J2.81
  IN3 w0.102: v1(79.03,65.14) 79.03,64.88 78.71,64.56 78.71,63.84 78.09,63.22
  IN3 w0.203: 78.09,63.22 78.09,62.23 77.55,61.7 77.55,61.09 77.06,60.59 77.06,59.82 77.79,59.08 77.79,51.28 77.58,51.07 76.58,51.07 76.37,50.86 76.37,46.76 76.58,46.55 76.87,46.55 77.08,46.76 77.08,49.92 77.28,50.12 77.59,50.12 77.79,49.92 77.79,39.5 78.14,39.15 78.14,38.85 77.69,38.41 77.69,38.11 77.9,37.9 78.19,37.9 78.64,38.35 78.93,38.35 81.75,35.53 81.75,34.73 81.24,34.22 81.24,33.49 83,31.74 83,29.94 81.14,28.08 81.14,26.79 79.72,25.38 v1(79.01,25.38)
M_DDR3_NODE1_ECC3: length 61.7
  TOP w0.102: U2.BD50 78.48,67.74 v1(78.84,68.11)
  TOP w0.165: v1(79.01,23.84) 79.38,23.47 J2.83
  IN3 w0.102: v1(78.84,68.11) 78.43,67.7 78.43,67 78.5,66.94 78.5,66.19 78.43,66.13 78.43,63.96 78.11,63.63 78.06,63.63 77.51,63.09
  IN3 w0.203: 77.51,63.09 77.51,62.69 75.93,61.11 75.93,57.21 75.35,56.63 75.35,55.5 75.54,55.31 76.54,55.31 76.77,55.08 76.77,51.94 76.57,51.73 76.27,51.73 76.06,51.94 76.06,53.76 75.86,53.96 75.56,53.96 75.35,53.76 75.35,46.63 76.66,45.33 76.66,38.22 78.02,36.85 79.38,36.85 80.44,35.78 80.44,33.31 82.1,31.65 82.1,30.21 79.62,27.72 79.62,27 78.1,25.49 78.1,24.5 78.76,23.84 v1(79.01,23.84)
M_DDR3_NODE1_ECC4: length 61.8
  TOP w0.102: v1(77.37,68.12) 77.75,67.75 U2.BD49
  TOP w0.165: v1(73.73,26.96) 73.68,27.01 J2.72
  IN3 w0.102: 72.11,60.29 72.11,60.66 73.24,61.79 73.24,62.59 74.64,63.99 74.84,63.99 76.19,65.34 76.19,66.6 76.39,66.8 76.52,66.8 77.04,67.32 77.12,67.32 77.37,67.58 v1(77.37,68.12)
  IN3 w0.203: v1(73.73,26.96) 73.93,27.16 73.93,28.43 73.79,28.57 73.79,29.12 73.58,29.33 72.67,29.33 72.47,29.54 72.47,29.83 72.67,30.04 73.58,30.04 73.79,30.25 73.79,30.54 73.58,30.75 73.33,30.75 73.12,30.96 73.12,31.25 73.33,31.46 73.58,31.46 73.79,31.67 73.79,32.06 72,33.85 70.28,33.85 69.3,34.82 69.3,36.64 65.85,40.1 65.85,40.39 66.06,40.6 66.35,40.6 67.68,39.27 67.97,39.27 68.18,39.48 68.18,39.78 65.85,42.11 65.85,49.34 69.93,53.42 69.93,58.09 70.55,58.71 70.55,59.62 71.03,60.09 71.91,60.09 72.11,60.29
M_DDR3_NODE1_ECC5: length 61.9
  TOP w0.102: U2.BA50 78.84,68.87 v1(78.84,68.87)
  TOP w0.165: v1(75.39,29.03) 75.51,29.15 J2.74
  IN3 w0.102: v1(78.84,68.87) 78.07,68.1 78.07,67.77 77.41,67.11 77.12,67.11 76.74,66.73 76.74,66.66 76.42,66.34 76.42,65.22 74.9,63.7 74.79,63.7 73.82,62.73 73.82,61.71 72.68,60.57
  IN3 w0.203: 72.68,60.57 72.68,59.89 70.56,57.77 70.56,53.15 66.48,49.07 66.48,48.06 66.69,47.85 66.99,47.85 67.2,47.64 67.2,47.35 66.99,47.14 66.69,47.14 66.48,46.93 66.48,46.63 66.69,46.43 66.99,46.43 67.2,46.22 67.2,45.92 66.99,45.71 66.69,45.71 66.48,45.51 66.48,45.21 66.69,45 66.99,45 67.2,44.8 67.2,44.5 66.99,44.29 66.69,44.29 66.48,44.08 66.48,42.37 68.82,40.04 68.82,38.03 70.42,36.43 70.42,36.13 70.13,35.85 70.13,35.55 70.34,35.34 70.63,35.34 70.92,35.63 71.22,35.63 72,34.85 72.29,34.85 72.85,35.41 73.14,35.41 73.35,35.2 73.35,34.9 72.79,34.35 72.79,34.05 73,33.84 73.3,33.84 73.85,34.4 74.15,34.4 74.35,34.19 74.35,33.9 73.8,33.34 73.8,33.05 74.42,32.42 74.42,28.84 74.58,28.68 74.58,27.7 74.78,27.5 74.78,27.5 75.17,27.5 75.39,27.73 v1(75.39,29.03)
M_DDR3_NODE1_ECC6: length 61.8
  TOP w0.102: v1(77.2,65.25) 77.54,65.25 U2.BH49
  TOP w0.165: J2.80 78.48,28.06 77.48,27.06 76.38,27.06 v1(76.21,26.89)
  IN3 w0.102: v1(77.2,65.25) 74.34,62.39 74.34,61.74 73.16,60.55 73.16,59.47
  IN3 w0.203: v1(76.21,26.89) 76.16,26.94 76.16,29.5 75.06,30.6 75.06,34.73 73.63,36.15 71.59,36.15 69.45,38.3 69.45,40.3 67.89,41.86 67.89,47.49 68.1,47.7 68.4,47.7 68.6,47.49 68.6,43.72 68.81,43.52 69.11,43.52 69.31,43.72 69.31,48.2 69.11,48.41 68.1,48.41 67.89,48.62 67.89,49.58 71.2,52.89 71.2,57.51 73.16,59.47
M_DDR3_NODE1_ECC7: length 61.9
  TOP w0.102: U2.BK49 78.1,64.9 78.1,66.58 v1(78.09,66.6)
  TOP w0.165: J2.82 79.08,27.54 v1(78.7,27.16)
  IN3 w0.102: 77.01,63.31 77.42,63.73 77.42,64.26 78.23,65.07 78.23,66.46 v1(78.09,66.6)
  IN3 w0.203: 77.01,63.31 77.01,62.98 75.32,61.3 75.32,59.3 75.01,58.99 75.01,57.77 73.94,56.7 73.94,55.16 74.15,54.95 74.49,54.95 74.7,54.75 74.7,54.44 74.49,54.24 74.15,54.24 73.94,54.03 73.94,53.73 74.15,53.53 74.39,53.53 74.6,53.32 74.6,53.02 74.39,52.81 74.15,52.81 73.94,52.61 73.94,52.31 74.15,52.1 74.39,52.1 74.6,51.9 74.6,51.6 74.39,51.39 74.15,51.39 73.94,51.18 73.94,50.89 74.15,50.68 74.39,50.68 74.6,50.47 74.6,50.18 74.39,49.97 74.15,49.97 73.94,49.76 73.94,49.47 74.15,49.26 74.39,49.26 74.6,49.05 74.6,48.76 74.39,48.55 74.15,48.55 73.94,48.34 73.94,47.14 74.1,46.98 74.1,46.98 76.02,45.06 76.02,37.95 78.25,35.73 79.6,35.73 79.81,35.52 79.81,35.23 79.6,35.02 78.01,35.02 77.8,34.81 77.8,34.51 78.01,34.31 79.6,34.31 79.81,34.1 79.81,33.8 79.6,33.6 78.05,33.6 77.85,33.39 77.85,33.02 78.05,32.81 80.05,32.81 81.34,31.52 81.34,30.51 78.7,27.87 v1(78.7,27.16)
M_DDR3_NODE1_MA0: length 60.8
  TOP w0.102: U2.BK40 73.56,64.59 73.56,63.91 73.78,63.69 73.78,63.42 73.54,63.18 73.54,62.4 73.54,62.4 73.54,61.74 73.62,61.65 v1(73.62,60.35)
  TOP w0.229: J2.107 v1(86.58,24.12)
  IN1 w0.229: v1(73.62,60.35) 73.36,60.09 73.36,54.35 79.72,47.99 79.72,42.96 79.94,42.74 80.24,42.74 80.46,42.96 80.46,46.03 80.66,46.23 80.99,46.23 81.19,46.03 81.19,43.49 81.41,43.28 82.6,43.28 82.8,43.08 82.8,42.74 82.6,42.54 81.41,42.54 81.19,42.33 81.19,41.48 81.41,41.26 82.78,41.26 83.65,40.4 83.65,31.44 84.76,30.33 84.76,29.05 85.78,28.03 85.78,26.78 85.43,26.43 85.43,25.58 86.58,24.42 86.58,24.12 v1(86.58,24.12)
M_DDR3_NODE1_MA1: length 62.1
  TOP w0.102: v1(72.4,63.43) 72.4,63.43 72.82,63.85 U2.BL39
  TOP w0.229: v1(85.62,24.41) 85.62,24.01 85.98,23.65 J2.105
  IN1 w0.229: v1(85.62,24.41) 84.77,25.26 84.77,25.73 84.32,26.17 84.32,28.54 83.98,28.89 83.98,30.15 82.98,31.14 82.98,39.86 82.32,40.52 80.45,40.52 80.25,40.72 80.25,41.02 80.51,41.29 80.51,41.59 80.3,41.81 79.99,41.81 79.73,41.54 79.42,41.54 78.96,42.01 78.96,47.74 78.75,47.96 78.44,47.96 78.22,47.74 78.22,43.15 78.01,42.94 77.7,42.94 77.49,43.15 77.49,49.29 72.7,54.08 72.7,60.47 73.44,61.21 73.44,62.67 72.67,63.43 v1(72.4,63.43)
M_DDR3_NODE1_MA2: length 60.2
  TOP w0.102: 74.06,59.22 74.06,59.26 73.2,60.13 73.2,61.48 73.09,61.58 73.09,62.44 U2.BP40
  TOP w0.229: J2.106 86.28,30.85 86.1,31.04 86.1,34.73 v3(87.06,35.69) 87.79,36.42 87.79,39.91 86.54,41.16 86.54,44.71 86.75,44.92 87.06,44.92 87.27,44.71 87.27,41.52 87.49,41.3 87.79,41.3 88.01,41.52 88.01,45.44 87.79,45.66 86.75,45.66 86.54,45.87 86.54,47.01 86.22,47.32 86.22,47.62 86.96,48.36 86.96,48.67 84.59,51.04 84.28,51.04 84.06,50.82 84.06,50.52 85.92,48.67 85.92,48.36 85.7,48.15 85.4,48.15 80.17,53.37 76.4,53.37 74.06,55.72 74.06,59.22
M_DDR3_NODE1_MA3: length 63
  TOP w0.229: J2.103 85.38,22.36 85.38,22.36 85.38,22.99 v1(85.04,23.33) ; v1(72.38,64.2) 72.36,64.2 72.34,64.18 72.33,64.18 72.05,63.9 U2.BL37
  IN1 w0.229: v1(72.38,64.2) 71.71,63.53 71.71,62.89 71.88,62.72 72.42,62.72 72.78,62.36 72.78,61.4 72.04,60.67 72.04,53.8 75.35,50.48 75.35,43.96 75.57,43.74 75.88,43.74 76.09,43.96 76.09,49.01 76.31,49.23 76.61,49.23 76.83,49.01 76.83,42.88 79.85,39.86 81.54,39.86 82.32,39.07 82.32,30.85 83.18,29.99 83.18,28.51 83.54,28.15 83.54,25.93 84.13,25.35 84.13,24.24 v1(85.04,23.33)
M_DDR3_NODE1_MA4: length 60.3
  TOP w0.102: 73.35,59.35 73.35,59.44 72.8,59.98 72.8,61.28 72.6,61.48 72.6,62.91 U2.BN39
  TOP w0.229: 73.35,59.35 73.35,55.42 73.35,55.42 76.22,52.54 77.89,52.54 82.29,48.14 82.59,48.14 82.81,48.36 82.81,48.66 79.36,52.11 79.36,52.41 79.58,52.63 79.89,52.63 85.75,46.76 85.75,40.79 86.47,40.08 v3(86.47,39.37) 87.05,38.79 87.05,37.05 86.52,36.52 85.99,36.52 85.78,36.73 85.78,39.05 85.57,39.26 85.26,39.26 85.05,39.05 85.05,35.31 85.38,34.97 85.38,30.77 85.68,30.46 J2.104
M_DDR3_NODE1_MA5: length 62.6
  TOP w0.102: U2.BN37 72.13,62.95 72.13,62.01 v1(72.16,61.99)
  TOP w0.229: v1(83.46,24.99) 84.18,24.26 J2.99
  IN1 w0.229: v1(72.16,61.99) 71.42,61.25 71.42,60.77 70.41,59.76 70.41,59.33 70.65,59.08 70.65,53.32 73.91,50.06 73.91,41.45 77.75,37.61 78.04,37.61 78.27,37.84 78.27,38.13 74.7,41.7 74.7,42 74.92,42.22 75.22,42.22 79.53,37.91 79.53,32.79 79.68,32.64 80.84,32.64 80.99,32.48 80.99,30.24 81.67,29.56 81.67,25.71 82.39,24.99 v1(83.46,24.99)
M_DDR3_NODE1_MA6: length 60.8
  TOP w0.102: U2.BP37 71.72,62.41 71.72,61.77 72.41,61.08 72.41,59.58 72.64,59.35
  TOP w0.229: J2.100 84.48,30.39 84.64,30.55 84.64,34.14 84.07,34.71 v3(84.07,36.7) 84.06,39.71 84.95,40.59 84.95,46.47 84.75,46.67 84.42,46.67 84.21,46.47 84.21,41.09 84.01,40.89 83.68,40.89 83.48,41.09 83.48,45.93 83.13,46.28 83.13,46.58 83.84,47.29 83.84,47.6 83.62,47.82 83.32,47.82 82.61,47.1 82.3,47.1 77.82,51.58 77.52,51.58 77.3,51.37 77.3,51.06 78.85,49.51 78.85,49.22 78.62,48.99 78.33,48.99 76.41,50.91 76.41,51.35 72.64,55.12 72.64,59.35
M_DDR3_NODE1_MA7: length 62
  TOP w0.102: U2.BL35 70.82,63.58 71.27,63.13 71.27,62.38 71.51,62.14 71.51,61.27 71.93,60.86 71.93,59.1
  TOP w0.229: J2.98 83.88,30.81 83.7,30.99 83.7,33.49 83.05,34.14 83.05,37.04 82.67,37.42 82.67,37.9 82.88,38.12 83.11,38.12 83.33,38.33 83.33,38.64 83.11,38.85 82.88,38.85 82.67,39.07 82.67,39.37 82.88,39.59 83.11,39.59 83.33,39.81 83.33,40.11 83.11,40.33 82.88,40.33 82.67,40.54 82.67,43.62 81.8,44.49 81.8,44.79 82.54,45.53 82.54,45.83 79.66,48.71 79.35,48.71 79.14,48.49 79.14,48.19 81.49,45.83 81.49,45.53 80.21,44.24 79.96,44.24 76.92,47.28 76.92,47.59 77.13,47.8 77.44,47.8 79.84,45.41 80.14,45.41 80.36,45.62 80.36,45.93 77.56,48.73 77.2,48.73 v3(76.97,48.96) 76.94,48.96 75.63,50.27 75.63,51.12 71.93,54.83 71.93,59.1
M_DDR3_NODE1_MA8: length 59.6
  TOP w0.102: v1(71.2,59.45) 71.2,59.69 71.31,59.8 71.31,62.05 70.9,62.46 U2.BN35
  TOP w0.229: J2.97 83.58,23.37 83.58,23.37 83.58,24.1 82.84,24.85 v1(82.84,25.67)
  IN1 w0.229: v1(71.2,59.45) 71.38,59.27 71.38,53.52 74.57,50.33 74.57,43.81 79.28,39.1 80.05,39.1 80.19,38.96 80.19,33.49 80.34,33.34 80.78,33.34 80.93,33.49 80.93,38.79 81.14,39 81.45,39 81.66,38.79 81.66,30.55 82.33,29.89 82.33,26.18 v1(82.84,25.67)
M_DDR3_NODE1_MA9: length 62.8
  TOP w0.102: 70.63,58.57 70.63,58.8 69.95,59.48 69.95,60.46 70.27,60.79 70.27,62.21 70.44,62.38 70.44,62.72 70.09,63.08 70.09,63.49 U2.BM34
  TOP w0.229: J2.92 82.08,30.46 82.24,30.62 82.24,32.18 79.87,34.55 v3(79.87,36.83) 79.87,38.02 79.53,38.36 79.22,38.36 78.49,37.62 78.18,37.62 75.54,40.26 75.54,40.56 75.76,40.78 76.07,40.78 78.18,38.67 78.49,38.67 78.7,38.88 78.7,39.19 74.97,42.92 74.97,43.22 75.19,43.44 75.49,43.44 79.98,38.96 80.28,38.95 80.5,39.17 80.5,39.48 75.24,44.73 75.24,48.65 73.83,50.05 73.83,50.9 70.63,54.1 70.63,58.57
M_DDR3_NODE1_MA10: length 59.9
  TOP w0.102: U2.BN41 73.92,62.12 74.05,61.98 74.05,60.92 74.6,60.38 74.6,58.72 74.77,58.55 74.77,58.04
  TOP w0.229: J2.117 89.58,24.46 v1(89.05,24.99) ; 74.77,58.04 74.77,56.01 76.68,54.1 80.46,54.1 80.89,53.67 81.34,53.67 81.77,54.1 82.63,54.1 83.67,53.06 83.67,52.76 83.45,52.54 83.14,52.54 82.57,53.12 82.26,53.12 82.04,52.9 82.04,52.6 83.14,51.5 83.45,51.5 84.19,52.24 84.49,52.24 87.8,48.93 87.8,48.36 88.06,48.1 88.62,48.1 88.8,47.92 88.8,47.43 88.59,47.22 87.55,47.22 87.34,47 87.34,46.7 87.55,46.48 88.59,46.48 88.8,46.26 88.8,33.96 v1(88.98,33.78)
  IN1 w0.229: v1(88.98,33.78) 89.05,33.71 v1(89.05,24.99)
M_DDR3_NODE1_MA11: length 63.2
  TOP w0.102: 71.19,58.68 71.19,58.87 70.55,59.51 70.55,60.69 70.48,60.76 70.48,62.12 70.67,62.31 70.67,62.79 70.5,62.96 70.5,63.9 U2.BL34
  TOP w0.229: J2.96 83.28,30.47 82.96,30.79 82.96,32.51 81.7,33.77 81.7,34.07 82.28,34.65 82.28,34.94 82.04,35.17 81.76,35.17 81.18,34.59 80.87,34.59 80.61,34.86 80.61,36.17 80.83,36.39 81.72,36.39 81.94,36.6 81.94,36.91 81.72,37.12 80.93,37.12 80.72,37.34 80.72,37.64 80.93,37.86 81.74,37.86 81.95,38.07 81.95,38.38 81.74,38.6 81.42,38.6 81.21,38.81 81.21,39.12 81.42,39.33 81.58,39.33 81.79,39.55 81.79,41.37 80.87,42.29 80.87,42.6 81.62,43.34 81.62,43.64 81.4,43.86 81.1,43.86 80.35,43.12 80.05,43.12 77.53,45.64 77.22,45.64 77.01,45.42 77.01,45.12 80.89,41.23 80.89,40.92 80.68,40.71 80.37,40.71 75.97,45.12 75.97,45.42 76.32,45.77 v3(76.32,46.29) 76.32,46.85 75.96,47.21 75.96,48.94 74.81,50.09 74.81,50.93 71.19,54.55 71.19,58.68
M_DDR3_NODE1_MA12: length 63.3
  TOP w0.102: U2.BL32 69.65,64 69.78,63.88 69.78,63.78 69.52,63.53 69.52,63.42 69.75,63.19 69.75,62.83 69.41,62.49 69.41,61.78 69.87,61.32 69.87,60.88 69.44,60.44 v1(69.44,59.32)
  TOP w0.229: J2.95 82.98,23.85 82.63,24.2 82.22,24.2 81.62,24.8 v1(81.62,24.8)
  IN1 w0.229: v1(69.44,59.32) 69.99,58.77 69.99,53.04 73.25,49.78 73.25,38.89 77.39,34.75 77.69,34.75 77.91,34.97 77.91,35.27 74.02,39.16 74.02,39.46 74.24,39.68 74.54,39.68 78.71,35.51 78.71,32.41 79.36,31.76 79.86,31.26 79.86,30.27 80.96,29.17 80.96,25.46 v1(81.62,24.8)
M_DDR3_NODE1_MA13: length 58.2
  TOP w0.102: U2.BN48 77.46,63.27 77.81,63.27 78.09,62.98 78.09,62.36 78.98,61.47 79.16,61.47 79.79,60.84
  TOP w0.229: 79.79,60.84 79.79,59.21 80.21,58.79 83.71,58.79 84.46,58.04 84.46,57.4 84.68,57.19 84.98,57.19 85.15,57.35 85.45,57.35 85.67,57.13 85.67,56.83 85.5,56.67 85.5,56.36 85.72,56.14 86.02,56.14 86.19,56.31 86.49,56.31 86.71,56.09 86.71,55.79 86.54,55.62 86.54,55.32 87.18,54.69 87.63,54.69 88.01,55.06 88.47,55.06 88.78,54.75 88.78,54.45 88.23,53.9 88.23,53.6 88.45,53.38 88.76,53.38 89.3,53.93 89.6,53.93 89.82,53.71 89.82,53.4 89.28,52.86 89.28,52.56 89.49,52.34 89.8,52.34 90.34,52.88 90.65,52.88 90.86,52.67 90.86,52.36 90.32,51.82 90.32,51.51 90.53,51.3 90.84,51.3 91.38,51.84 91.69,51.84 91.9,51.63 91.9,51.32 91.36,50.78 91.36,50.47 91.58,50.26 91.88,50.26 92.42,50.8 92.73,50.8 95.71,47.82 95.71,46.1 96.01,45.8 96.01,45.36 95.71,45.07 95.71,44.63 96.01,44.33 96.01,43.89 95.71,43.59 95.71,43.15 96.01,42.86 96.01,42.42 95.71,42.12 95.71,37.87 95.59,37.75 v3(95.59,36.31) 95.59,35.95 95.22,35.58 95.22,34.76 95.43,34.55 95.91,34.55 96.12,34.33 96.12,34.03 95.91,33.81 95.43,33.81 95.22,33.6 95.22,31.99 94.88,31.65 93.96,31.65 93.48,31.17 J2.130
M_DDR3_NODE1_MA14: length 61.7
  TOP w0.102: 70,58.59 69.76,58.83 69.28,58.83 69,59.1 69,63.48 U2.BM31
  TOP w0.229: 70,58.59 70,53.71 73.04,50.67 73.04,49.3 73.79,48.55 74.29,48.55 74.51,48.33 74.51,48.02 74.29,47.81 72.75,47.81 72.53,47.59 72.53,47.29 72.75,47.07 74.29,47.07 74.51,46.86 74.51,46.55 74.29,46.34 72.64,46.34 72.3,46 72.3,45.52 72.64,45.18 74.27,45.18 74.49,44.97 74.49,44.66 74.27,44.44 72.88,44.44 72.52,44.09 72.52,43.59 72.88,43.23 74.04,43.23 74.26,43.01 74.26,42.47 74.82,41.91 v3(74.82,41.43) 74.82,39.94 75.13,39.63 75.13,39.32 74.64,38.83 74.64,38.04 77.87,34.8 78.18,34.8 78.4,35.02 78.4,35.32 75.44,38.28 75.44,38.59 75.65,38.8 75.96,38.8 79.14,35.62 79.14,34.26 81.48,31.91 J2.90
