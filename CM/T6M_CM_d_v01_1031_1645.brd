# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART_T6_NODE1_RXD: length 48.7
  TOP w0.102: U128.88 98.32,172.12 97.83,171.63 97.83,170.77 98.13,170.47 v1(98.13,170.38) ; R933.1 119.27,187.67 119.27,186.78 119.52,186.53 119.54,186.53 v1(119.78,186.28) 119.21,185.71 C696.1
  IN3 w0.114: v1(98.13,170.38) 98.18,170.33 98.18,168.74 98.53,168.39 98.56,168.39 98.81,168.13 98.81,167.77 98.11,167.07 98.11,166.21 98.68,165.64 101.74,165.64 102.43,166.33 104.2,166.33 104.56,165.97 104.92,165.97 105.16,166.21 106.23,166.21 106.51,166.49 106.51,168.44 108.01,169.94 108.65,169.94 111.63,172.92 111.63,173.44 111.81,173.62 111.81,175.16 111.14,175.83 111.14,177.15 111.5,177.52 113.5,177.52 113.84,177.86 113.84,181.51 115.9,183.57 115.9,184.42 v1(115.92,184.44) 115.97,184.49 116.82,184.49 118.18,185.85 119.11,185.85 119.54,186.28 v1(119.78,186.28)
UART_T6_NODE1_RXD_R: length 17.5
  TOP w0.102: R933.2 119.33,192.1 117.74,193.69 117.74,199.3 v1(118.17,199.74) 117.05,200.86 J18.B81
UART_T6_NODE1_TXD: length 5.5
  TOP w0.102: v1(104.77,171.94) 102.62,171.94 102.44,171.76 R936.1 102.35,171.39 101.81,171.39 101.57,171.62 U128.87
UART_T6_NODE1_TXD_R: length 50
  TOP w0.102: v1(103.93,171.45) 103.91,171.48 103.56,171.48 103.55,171.48 R936.2 ; J18.B82 116.05,200.75 116.93,199.87 116.93,193.76 117.64,193.05 v1(117.64,189.76) 117.64,189.45 118.32,188.78 C699.1
  IN3 w0.114: v1(117.64,189.76) 117.64,189.29 116.74,188.39 116.74,186.24 114.3,183.81 113.64,183.81 113.02,183.2 109.32,183.2 107.02,180.89 107.02,179.4 107.34,179.08 107.34,171.43 105.97,170.06 105.97,169.52 105.71,169.27 104.87,169.27 104.39,169.75 104.39,170.7 104.34,170.74 104.34,171.04 v1(103.93,171.45)
UART_T6_NODE2_RXD: length 27.8
  TOP w0.102: U128.90 100.46,173.12 101.35,174.02 102.13,174.02 102.34,174.23 102.83,174.23 103.58,173.48 104.39,173.48 v1(104.65,173.74) ; v1(106.9,190.11) 106.64,189.85 R939.1
  IN3 w0.114: v1(106.9,190.11) 106.9,190.04 106.09,189.22 106.09,183.66 104.58,182.16 104.58,180.07 104.58,180.07 104.58,179.77 104.93,179.42 104.93,178.93 105.19,178.67 105.56,178.67 106.39,177.85 106.39,175.1 105.66,174.37 105.21,174.37 104.65,173.82 v1(104.65,173.74)
  BOTTOM w0.102: v1(106.9,190.11) 106.64,189.85 R939.1
UART_T6_NODE2_RXD_R: length 17.2
  TOP w0.102: J35.B2 107.05,200.31 105.48,198.74 v1(105.48,197.7) 105.48,189.94 105.84,189.58 R939.2
UART_T6_NODE2_TXD: length 4.7
  TOP w0.102: U128.89 101.13,172.62 102.18,173.67 v3(102.59,173.67) 102.83,173.42 102.83,173.1 102.44,172.71 R942.1
UART_T6_NODE2_TXD_R: length 44
  TOP w0.102: J35.B3 106.05,199.88 104.78,198.62 104.78,190.4 v1(104.51,190.14) 104.78,189.87 104.78,189.02 105.84,187.96 C705.1 ; R942.2 103.51,172.5 103.6,172.41 104.15,172.41 v1(104.57,172.83)
  IN3 w0.114: v1(104.57,172.83) 104.57,172.92 105.09,173.44 105.51,173.44 106.7,174.63 106.7,178.4 104.9,180.21 104.9,182.02 106.42,183.55 106.42,188.02 107.51,189.11 107.51,190.26 106.97,190.79 105.17,190.79 v1(104.51,190.14)
UART_T6_NODE3_RXD: length 26.9
  TOP w0.102: U128.92 100.72,174.12 100.95,174.35 102.03,174.35 102.21,174.53 102.96,174.53 102.96,174.53 104.47,174.53 v1(104.68,174.74) ; C708.1 101.43,185.78 101.96,186.32 v1(101.96,186.64) 101.96,187.11 101.35,187.73 R945.1
  IN3 w0.114: v1(104.68,174.74) 105.58,174.74 106.07,175.23 106.07,176.63 104.82,177.88 104.82,178.59 104.62,178.8 104.62,179.29 103.41,180.5 103.41,181.16 104.26,182.01 104.26,182.29 105.74,183.76 105.74,185.9 105.41,186.23 105.29,186.23 105.29,186.23 104.92,186.23 104.92,186.23 103.51,186.23 103.02,185.74 102.55,185.74 102.23,186.06 102.23,186.37 v1(101.96,186.64)
UART_T6_NODE3_RXD_R: length 18.6
  TOP w0.102: J35.B5 104.05,198.71 v1(104.31,198.45) 104.05,198.19 104.05,193.95 100.6,190.51 100.6,189.1 R945.2
UART_T6_NODE3_TXD: length 14.8
  TOP w0.102: R948.1 100.28,184.2 99.2,183.12 v1(98.96,183.12) ; v1(97.83,174.43) 97.83,174.22 98.42,173.62 U128.91
  IN3 w0.114: v1(97.83,174.43) 99.79,176.39 99.79,180.76 100.05,181.01 100.05,181.37 99.79,181.63 99.79,182.29 v1(98.96,183.12)
UART_T6_NODE3_TXD_R: length 21.8
  TOP w0.102: R948.2 100.28,186.63 99.6,187.31 99.6,187.96 99.83,188.19 99.83,188.2 C711.1 100.06,188.62 100.06,190.85 103.51,194.31 v1(103.51,196.98) 103.51,199.05 103.05,199.52 J35.B6
UART_T6_NODE4_RXD: length 25.7
  TOP w0.102: U128.96 100.46,176.12 100.58,176 104.5,176 v1(104.52,176.02) ; R951.1 99.14,187.11 v1(99.82,186.43) 99.14,185.75 C714.1
  IN3 w0.114: v1(99.82,186.43) 101.6,184.65 103.18,184.65 103.83,185.3 104.86,185.3 105.12,185.05 105.12,184.68 104.01,183.58 103.33,183.58 102.48,182.73 102.48,182.26 102.54,182.21 102.54,177.31 103.83,176.02 v1(104.52,176.02)
UART_T6_NODE4_RXD_R: length 18.2
  TOP w0.102: J35.B7 102.05,201.66 102.48,201.22 102.48,200.4 102.17,200.09 v1(102.17,195.93) 101.94,195.7 101.94,193.44 99.14,190.64 R951.2
UART_T6_NODE4_TXD: length 12.2
  TOP w0.102: R954.1 98,184.8 v1(98,184.04) ; v1(97.4,176.26) 98.04,175.63 99.78,175.63 U128.95
  IN3 w0.114: v1(97.4,176.26) 97.4,177.28 97.45,177.32 97.45,180.32 98.94,181.81 98.94,182.25 98,183.19 v1(98,184.04)
UART_T6_NODE4_TXD_R: length 21.3
  TOP w0.102: J35.B8 101.05,199.91 101.05,199.91 v1(101.05,199.39) 100.63,198.97 100.63,193.43 98,190.79 C717.1 98.48,188.04 98.48,188.03 98.56,187.96 98.56,186.66 98.48,186.59 98.48,186.13 98,185.64 R954.2
UART_T7_NODE1_RXD: length 24
  TOP w0.102: v1(140.58,177.18) 140.59,177.18 141.16,176.61 U129.27
  IN3 w0.114: v1(132.98,186.49) 132.91,186.42 132.84,186.42 132.27,185.85 128.32,185.85 v1(127.71,186.46)
  BOTTOM w0.102: v1(140.58,177.18) 140.43,177.34 140.43,181.01 138.47,182.97 138.05,182.97 134.99,186.03 134.99,186.22 134.17,187.05 133.78,187.05 133.22,186.49 v1(132.98,186.49) ; C718.1 127.46,186.22 v1(127.71,186.46) 128.48,187.23 R955.1
UART_T7_NODE1_RXD_R: length 17
  BOTTOM w0.102: J18.A70 128.05,201.65 128.48,201.21 128.48,198.1 v2(128.25,197.87) 128.25,197.14 128.48,196.91 R955.2
UART_T7_NODE1_TXD: length 23.1
  TOP w0.102: U129.26 v1(142.95,177.11)
  IN3 w0.114: v1(126.67,184.16) 126.67,183.94 126.9,183.71 126.9,183.5 127.34,183.06 132.34,183.06 133.19,183.9 137.8,183.9 139.72,181.99 139.72,180.94 142.81,177.85 142.81,177.25 v1(142.95,177.11)
  BOTTOM w0.102: v1(126.67,184.16) 126.32,184.51 R958.1
UART_T7_NODE1_TXD_R: length 20.6
  BOTTOM w0.102: J18.A71 127.05,202 126.87,201.82 126.87,197.42 127.48,196.81 127.48,196.08 v2(127.45,196.06) 127.33,195.94 C721.1 126.67,187.86 126.67,186.73 126.87,186.53 126.87,186.18 126.33,185.63 126.32,185.63 R958.2
UART_T7_NODE2_RXD: length 27.3
  TOP w0.102: U129.29 v1(140.66,175.61)
  IN3 w0.114: v1(134.11,186.5) 134.09,186.5 133.12,185.54 127.88,185.54 126.62,186.79 126.21,186.79 v1(125.74,186.33)
  BOTTOM w0.102: v1(134.11,186.5) 134.11,186.48 134.45,186.13 134.45,185.68 137.46,182.67 138.34,182.67 140.12,180.89 140.12,177.45 140.07,177.39 140.07,176.97 140.12,176.92 140.12,176.45 140.66,175.91 v1(140.66,175.61) ; R961.1 126.19,187.47 125.76,187.04 125.76,186.34 v1(125.74,186.33) 125.17,185.76 C724.1
UART_T7_NODE2_RXD_R: length 16.8
  BOTTOM w0.102: J18.A72 126.05,198.16 126.23,197.97 v2(126.23,197.59) 126.23,194.89 126.19,194.85 R961.2
UART_T7_NODE2_TXD: length 25.3
  TOP w0.102: v1(142.95,175.84) 142.68,176.11 U129.28
  IN3 w0.114: v1(124.33,184.09) 124.77,184.53 125.81,184.53 126.07,184.27 126.07,183.97 126.53,183.51 126.53,183.41 127.21,182.74 134.43,182.74 135.06,182.1 137.53,182.1 138.71,180.93 139.17,180.93 141.47,178.63 142.56,176.23 v1(142.95,175.84)
  BOTTOM w0.102: v1(124.33,184.09) 124.33,184.38 124.03,184.68 R964.1
UART_T7_NODE2_TXD_R: length 20.6
  BOTTOM w0.102: R964.2 124.03,186.26 124.21,186.43 124.21,187.3 124.34,187.42 124.34,188.18 124.68,188.53 C727.1 125.05,194.56 125.45,194.96 v2(125.45,199.36) 125.05,199.76 J18.A73
UART_T7_NODE3_RXD: length 31.2
  TOP w0.102: U129.34 139.54,173.11 v1(139.42,173.22)
  IN3 w0.114: v1(139.42,173.22) 139.29,173.36 139.29,176.61 139.2,176.7 139.01,176.89 138.8,177.1 138.8,177.92 138.54,178.18 135.06,178.18 133.88,179.36 127.24,179.36 125.98,180.61 125.98,181.7 125.73,181.96 124.64,181.96 123.59,183.01 v1(123.59,183.41)
  BOTTOM w0.102: v1(123.59,183.41) 123.51,183.49 123.51,185.33 123.24,185.61 C730.1 122.89,186.39 123.32,186.82 123.32,187.53 123.52,187.73 R967.1
UART_T7_NODE3_RXD_R: length 17.4
  BOTTOM w0.102: R967.2 123.9,194.23 124.33,194.65 v2(124.33,197.52) 123.48,198.36 123.48,201.69 123.05,202.12 J18.A75
UART_T7_NODE3_TXD: length 25.4
  TOP w0.102: U129.33 140.68,173.61 v1(140.68,173.61)
  IN3 w0.114: v1(140.68,173.61) 141.1,174.03 141.1,177.27 141.09,177.3 140.76,177.62 140.75,177.62 139.46,178.91 139.24,178.91 136.41,180.82 136.41,180.96 135.88,181.17 130.06,182.35 127.08,182.35 v1(126.09,183.33)
  BOTTOM w0.102: R970.1 123.76,182.66 124.29,183.18 124.65,183.18 124.87,182.96 125.73,182.96 v1(126.09,183.33)
UART_T7_NODE3_TXD_R: length 23.6
  BOTTOM w0.102: J18.A76 122.05,199.76 122.92,198.89 v2(122.92,195.81) 122.92,194.58 122.76,194.42 C733.1 122.38,188.53 122.13,188.28 122.08,188.23 122.08,184.08 122.34,183.81 R970.2
UART_T7_NODE4_RXD: length 33.3
  TOP w0.102: U129.36 141.21,172.11 141.05,171.95 140.21,171.95 139.91,172.26 v1(138.09,172.26)
  IN3 w0.114: v1(138.09,172.26) 138.09,172.76 138.62,173.29 138.62,176.38 138.09,176.91 135.08,176.91 133.43,178.56 126.93,178.56 122.83,182.66 122.83,182.67 v1(121.62,183.88)
  BOTTOM w0.102: v1(121.62,183.88) 121.16,184.34 121.16,185.32 120.88,185.61 C736.1 120.6,186.02 121.04,186.46 121.04,187.35 121.42,187.73 R973.1
UART_T7_NODE4_RXD_R: length 16.9
  BOTTOM w0.102: J18.A77 121.05,200.33 121.58,199.8 v2(121.58,199.51) 121.58,188.95 121.62,188.91 R973.2
UART_T7_NODE4_TXD: length 2.5
  TOP w0.102: U129.35 140.57,172.61 v1(140.45,172.49)
  BOTTOM w0.102: R976.1 141.48,172.52 141.46,172.49 v1(140.45,172.49)
UART_T7_NODE4_TXD_R: length 53.4
  IN1 w0.114: v1(119.7,186.96) 119.91,187.16 120.53,187.16 124.3,183.39 v1(125.38,183.39)
  IN3 w0.114: v1(125.38,183.39) 126.92,181.85 127.55,181.85 127.8,181.6 127.8,181.23 128.93,180.11 134.49,180.11 134.8,179.8 136.9,179.8 137.89,178.81 138.81,178.81 140.13,177.49 140.13,174.39 140.24,174.29 140.24,173.38 141.34,172.27 v1(143.7,172.27)
  BOTTOM w0.102: R976.2 143.51,172.47 v1(143.7,172.27) ; v1(119.7,186.96) 119.92,187.17 119.92,188.36 120.09,188.53 C739.1 120.48,189.32 119.96,189.84 119.96,199.61 v2(120.12,199.77) 120.08,199.82 120.08,205.17 J18.A78
UART_T8_NODE1_RXD: length 30.3
  TOP w0.102: U129.38 140.33,171.11 140.16,170.94 138.38,170.94 137.63,171.69 137.63,173.34 v1(138.16,173.88) ; C742.1 132.67,187.61 v1(133.19,187.09) 133.68,187.59 R979.1
  BOTTOM w0.102: v1(133.19,187.09) 133.75,187.66 134.79,187.66 135.3,187.14 135.3,186.16 138.18,183.28 140.04,183.28 140.73,182.59 140.73,177.75 141.09,177.39 141.09,176.97 140.83,176.71 140.83,176.22 141.18,175.86 141.18,175.41 140.86,175.09 139.37,175.09 v1(138.16,173.88)
UART_T8_NODE1_RXD_R: length 17.5
  TOP w0.102: R979.2 133.68,192.21 132.05,193.85 132.05,199.54 v1(131.86,199.72) 132.05,199.9 J18.B66
UART_T8_NODE1_TXD: length 4
  TOP w0.102: v1(139.52,171.61) U129.37
  BOTTOM w0.102: R982.1 139.76,171.36 v1(139.52,171.61)
UART_T8_NODE1_TXD_R: length 46.5
  TOP w0.102: v1(131.55,183.9) 131.07,184.39 131.07,185.27 130.96,185.38 130.96,187.81 131.65,188.5 C745.1 131.65,193.33 131.05,193.93 J18.B67
  IN3 w0.114: v1(143.41,171.17) 144.28,172.05 144.28,176.88 140.04,181.13 140.04,182.12 137.94,184.22 133.06,184.22 132.43,183.59 131.87,183.59 v1(131.55,183.9)
  BOTTOM w0.102: v1(143.41,171.17) 143.06,171.17 142.87,171.36 R982.2
UART_T8_NODE2_RXD: length 43.1
  TOP w0.102: C748.1 130.51,186.14 v1(130.36,186.29) 130.08,186.57 130.08,187.29 R985.1 ; v1(138.13,170.4) 138.95,170.4 139.55,169.8 140.49,169.8 140.8,170.11 U129.40
  IN3 w0.114: v1(130.36,186.29) 130.07,186.58 130.07,187.12 129.76,187.44 124.75,187.44 124.31,187 124.31,186.16 123.33,185.18 123.33,183.89 123.15,183.72 123.15,182.79 126.9,179.04 133.75,179.04 135.55,177.23 138.22,177.23 138.97,176.48 138.97,172.98 138.97,172.97 138.97,171.24 v1(138.13,170.4)
UART_T8_NODE2_RXD_R: length 17
  TOP w0.102: R985.2 130.51,193.16 129.97,193.7 129.97,198.09 v1(129.82,198.23) 129.97,198.38 129.97,205.12 J18.B68
UART_T8_NODE2_TXD: length 3.3
  TOP w0.102: U129.39 140.3,170.61 v1(140.08,170.39)
  BOTTOM w0.102: R988.1 140.16,170.3 v1(140.08,170.39)
UART_T8_NODE2_TXD_R: length 51
  TOP w0.102: v1(128.86,183.57) 129.12,183.83 129.12,186.28 128.81,186.6 128.81,187.94 129.37,188.5 C751.1 129.37,189.04 129.06,189.35 129.06,199.39 v1(129.27,199.59) 129.57,199.9 129.57,202.02 129.05,202.55 J18.B69
  IN3 w0.114: v1(128.86,183.57) 129.86,184.58 138.03,184.58 140.35,182.25 140.35,181.26 144.61,177.01 144.61,171.26 v1(143.56,170.21)
  BOTTOM w0.102: v1(143.56,170.21) 143.46,170.3 R988.2
UART_T8_NODE3_RXD: length 31.5
  TOP w0.102: v1(138.35,168.96) 138.65,168.67 140.43,168.67 140.88,169.11 U129.42 ; R991.1 C754.1 127.88,185.61 127.66,185.38 127.66,184.04 128.13,183.58 v1(128.13,183.5)
  BOTTOM w0.102: v1(128.13,183.5) 128.15,183.47 128.15,181.09 127.67,180.6 127.67,173.25 128.95,171.96 130.59,171.96 131.15,171.4 132.3,171.4 133.32,170.38 136.36,170.38 136.58,170.16 137.16,170.16 v1(138.35,168.96)
UART_T8_NODE3_RXD_R: length 17.2
  TOP w0.102: R991.2 128.22,192.8 127.38,193.65 v1(127.38,199.62) 127.05,199.96 J18.B71
UART_T8_NODE3_TXD: length 3.1
  TOP w0.102: U129.41 140.87,169.61 140.38,169.12 v1(140.11,169.12)
  BOTTOM w0.102: R994.1 140.26,169.26 v1(140.11,169.12)
UART_T8_NODE3_TXD_R: length 54.8
  TOP w0.102: J18.B72 126.05,193.95 127.08,192.92 C757.1 127.08,188.5 126.86,188.29 126.85,188.29 126.52,187.96 126.52,186.92 127.11,186.33 127.11,184.14 127.34,183.91 v1(127.34,183.68)
  IN3 w0.114: v1(127.34,183.68) 127.34,183.74 128.49,184.89 138.16,184.89 140.7,182.35 140.7,181.36 144.92,177.14 144.92,170.22 v1(143.81,169.11)
  BOTTOM w0.102: R994.2 143.65,169.26 v1(143.81,169.11)
UART_T8_NODE4_RXD: length 43.8
  TOP w0.102: C760.1 125.94,185.85 v1(126.44,186.36) 125.94,186.86 R997.1 ; v1(140.48,166.22) 140.59,166.11 U129.48
  IN3 w0.114: v1(126.44,186.36) 127.57,185.22 138.29,185.22 141.02,182.48 141.02,181.5 145.24,177.28 145.24,169.67 144.31,168.74 144.31,165.83 143.14,164.66 142.77,164.66 142.4,165.03 141.67,165.03 v1(140.48,166.22)
UART_T8_NODE4_RXD_R: length 17.2
  TOP w0.102: R997.2 125.94,192.91 124.88,193.97 124.88,195.59 v1(124.9,195.62) 125.05,195.76 J18.B73
UART_T8_NODE4_TXD: length 4
  TOP w0.102: U129.47 143.33,166.61 v1(143.43,166.5)
  BOTTOM w0.102: R1000.1 141.55,166.44 142,166.89 143.06,166.89 143.43,166.52 v1(143.43,166.5)
UART_T8_NODE4_TXD_R: length 56.9
  TOP w0.102: J18.B74 124.05,202.22 124.51,201.76 124.51,200.27 124.05,199.81 v1(124.05,199.47) 124.05,199.47 124.05,193.63 124.79,192.89 C763.1 124.79,188.5 125.35,187.94 125.35,186.77 124.94,186.37 v1(124.94,183.87)
  IN3 w0.114: v1(142.95,165.1) 143.87,166.02 143.87,167.88 139.86,171.89 139.86,173.4 139.81,173.45 139.81,177.36 139.12,178.05 139.12,178.06 138.67,178.5 135.47,178.5 134.21,179.76 127.32,179.76 126.36,180.72 126.36,181.78 124.94,183.19 v1(124.94,183.87)
  BOTTOM w0.102: v1(142.95,165.1) 142.35,165.7 R1000.2
UART_T9_NODE1_RXD: length 36.6
  TOP w0.102: U129.53 144.56,165.19 v1(144.5,165.25)
  IN3 w0.114: v1(144.5,165.25) 145.69,164.05 151.74,164.05 152.03,164.34 152.03,164.78 151.2,165.61 151.2,166.13 150.25,167.08 150.25,175.69 149.69,176.26 149.69,180.2 148.77,181.12 148.77,181.6 147.57,182.8 147.57,184.84 146.91,185.5 146.91,186.22 v1(146.91,186.22)
  BOTTOM w0.102: R956.1 147.38,187.47 146.91,187.01 v1(146.91,186.22) 147.4,185.73 C719.1
UART_T9_NODE1_RXD_R: length 18.7
  BOTTOM w0.102: J18.A55 143.05,201.98 143.49,201.54 143.49,198.55 v2(144,198.04) 144.39,197.66 144.39,196.86 146.67,194.57 146.67,191.54 147.4,190.81 R956.2
UART_T9_NODE1_TXD: length 22.6
  TOP w0.102: v1(145.79,172.5) 145.79,171.58 144.89,170.68 144.89,168.73 144.06,167.89 U129.52
  BOTTOM w0.102: v1(145.79,172.5) 145.89,172.6 145.89,173.51 146.43,174.05 146.43,174.47 145.79,175.11 145.79,184.08 146.26,184.55 R959.1
UART_T9_NODE1_TXD_R: length 22.1
  BOTTOM w0.102: J18.A56 142.05,200.22 v2(142.7,199.57) 142.7,196.69 146.26,193.13 C722.1 145.67,187.69 145.67,186.67 146.26,186.09 R959.2
UART_T9_NODE2_RXD: length 28.4
  TOP w0.102: U129.55 v1(145.56,166.33)
  IN3 w0.114: v1(145.56,166.33) 145.56,166.34 145.99,166.34 148.45,168.79 148.45,177.36 146.2,179.61 146.2,181.56 144.53,183.22 144.53,184.11 144.57,184.15 v1(144.57,186.1)
  BOTTOM w0.102: R962.1 145.11,186.68 145.1,186.68 144.84,186.42 144.84,186.4 144.57,186.13 v1(144.57,186.1) 145.11,185.55 C725.1
UART_T9_NODE2_RXD_R: length 19.1
  BOTTOM w0.102: J18.A57 141.05,200.56 140.48,199.99 140.48,197.79 v2(141.32,196.96) 145.11,193.16 R962.2
UART_T9_NODE2_TXD: length 22.4
  TOP w0.102: U129.54 145.06,165.44 144.83,165.67 144.83,167.93 v1(145.75,168.84)
  BOTTOM w0.102: v1(145.75,168.84) 145.25,169.34 145.25,177.39 144.19,178.45 144.19,184.16 143.97,184.38 R965.1
UART_T9_NODE2_TXD_R: length 22.3
  BOTTOM w0.102: J18.A58 140.05,201.41 139.81,201.17 139.81,198.87 v2(139.66,198.73) 139.66,197.59 143.97,193.29 C728.1 144.61,187.63 144.61,186.81 143.97,186.17 R965.2
UART_T9_NODE3_RXD: length 27.9
  TOP w0.102: v1(146.63,167.9) 146.63,164.82 146.56,164.75 U129.57
  IN3 w0.114: v1(146.63,167.9) 146.63,168.13 148,169.5 148,177 145.87,179.13 145.87,181.43 144.21,183.09 144.21,184.25 142.7,185.77 v1(142.7,186.22)
  BOTTOM w0.102: R968.1 142.83,186.35 v1(142.7,186.22) 142.83,186.08 C731.1
UART_T9_NODE3_RXD_R: length 19.1
  BOTTOM w0.102: R968.2 142.83,192.44 138.26,197.01 138.26,198.29 138.49,198.53 v2(138.49,199.62) 138.48,199.63 138.48,201.46 138.05,201.89 J18.A60
UART_T9_NODE3_TXD: length 25.2
  TOP w0.102: R971.1 141.49,183.97 v1(141.54,183.92) ; U129.56 146.06,168.32 146.53,168.79 v1(146.53,170.01)
  IN3 w0.114: v1(141.54,183.92) 141.98,184.36 143,184.36 143.26,184.11 143.26,183.33 145.49,181.1 145.49,179 146.53,177.96 v1(146.53,170.01)
UART_T9_NODE3_TXD_R: length 23.6
  TOP w0.102: R971.2 142.8,185.58 C734.1 142.83,185.68 143.13,185.98 143.13,186.46 142.9,186.68 142.9,189.1 v1(142.24,189.77)
  BOTTOM w0.102: J18.A61 137.05,198.95 137.64,198.36 137.64,197.02 141.6,193.06 141.6,190.41 v1(142.24,189.77)
UART_T9_NODE4_RXD: length 35.4
  TOP w0.102: U129.67 v1(151.56,164.49) ; C737.1 R974.1 138.71,184.81 v1(139.1,185.19)
  IN3 w0.114: v1(151.56,164.49) 150.8,165.25 150.8,166.03 149.94,166.89 149.94,175.56 149.26,176.24 149.26,177.48 147.44,179.3 147.44,182.31 146.68,183.07 146.68,184.28 146.27,184.69 146.27,186.19 145.74,186.72 144.48,186.72 144.18,186.42 143.15,186.42 142.92,186.65 142.31,186.65 142.01,186.36 141.02,186.36 139.85,185.19 v1(139.1,185.19)
UART_T9_NODE4_RXD_R: length 22.4
  TOP w0.102: R974.2 138.26,185.96 v1(138.54,186.25)
  BOTTOM w0.102: J18.A62 v2(136.05,199.81) 136.05,196.82 140.54,192.32 140.54,189.41 138.54,187.41 v1(138.54,186.25)
UART_T9_NODE4_TXD: length 4.9
  TOP w0.102: v1(149.81,166.32) 151.06,165.07 U129.66
  BOTTOM w0.102: R977.1 150.47,165.66 v1(149.81,166.32)
UART_T9_NODE4_TXD_R: length 56.2
  TOP w0.102: C740.1 140.08,189.08 v1(139.51,189.65)
  BOTTOM w0.102: J18.A63 135.05,198.18 134.94,198.07 134.94,196.36 139.51,191.78 v1(139.51,189.65) 139.51,189.09 137.4,186.98 137.4,186.7 137.29,186.59 137.29,185.06 138.72,183.63 140.12,183.63 141.3,182.45 141.3,179.17 141.49,178.98 141.49,174.83 140.83,174.18 140.37,174.18 140.03,173.84 140.03,172.96 139.01,171.93 139.01,171.4 139.39,171.02 139.39,169.12 139.9,168.61 142.76,168.61 142.77,168.62 143.19,168.62 144.91,166.9 145.97,166.9 146.88,165.99 148.43,165.99 149.25,165.17 R977.2
UART_T10_NODE1_RXD: length 28.6
  TOP w0.102: C743.1 v1(147.4,186.64) 147.78,187.02 R980.1 ; U129.69 152.56,164.93 152.29,165.2 152.29,165.58 v1(152.04,165.82)
  IN3 w0.114: v1(147.4,186.64) 147.4,185.71 147.97,185.13 147.97,182.91 149.46,181.42 149.74,181.42 150.92,180.24 150.92,179 150,178.08 150,176.39 150.57,175.82 150.57,167.91 152.04,166.44 v1(152.04,165.82)
UART_T10_NODE1_RXD_R: length 17.1
  TOP w0.102: J18.B51 147.05,198.33 v1(147.57,197.81) 147.4,197.64 147.4,192.97 147.78,192.59 R980.2
UART_T10_NODE1_TXD: length 25.1
  TOP w0.102: v1(152.06,170.38) 152.06,166.72 151.56,166.22 151.56,165.29 152.06,164.79 U129.68 ; v1(146.24,183.62) 146.26,183.62 R983.1
  BOTTOM w0.102: v1(152.06,170.38) 151.52,170.92 151.52,179.68 149.09,182.11 148.05,182.11 146.55,183.62 v1(146.24,183.62)
UART_T10_NODE1_TXD_R: length 20.5
  TOP w0.102: R983.2 146.26,186.09 146.48,186.31 146.48,186.4 147.21,187.12 147.21,187.96 C746.1 146.64,189.81 146.47,189.97 v1(146.47,195.92) 146.26,196.14 146.26,197.65 146.05,197.86 J18.B52
UART_T10_NODE2_RXD: length 30.1
  TOP w0.102: C749.1 145.11,186.08 v1(145.27,186.24) 145.49,186.46 R986.1 ; v1(149.12,171.46) 151.65,171.46 152.6,170.51 152.6,166.86 153.56,165.9 U129.71
  IN3 w0.114: v1(145.27,186.24) 145.27,184.89 145.62,184.54 145.62,182.64 147.11,181.14 147.11,179.18 148.84,177.45 148.84,176.2 149.12,175.92 v1(149.12,171.46)
UART_T10_NODE2_RXD_R: length 17.1
  TOP w0.102: J18.B53 145.05,198.68 145.11,198.61 145.11,196.99 v1(145.41,196.7) 145.11,196.4 145.11,189.29 145.49,188.91 R986.2
UART_T10_NODE2_TXD: length 3.6
  TOP w0.102: U129.70 153.06,162.72 152.19,161.85 v1(151.99,161.85)
  BOTTOM w0.102: v1(151.99,161.85) 152.15,162 R989.1
UART_T10_NODE2_TXD_R: length 52.1
  TOP w0.102: J18.B54 144.05,202.38 144.62,201.81 144.62,197.9 143.97,197.25 v1(143.97,196.31) 143.97,189.72 144.35,189.34 C752.1 144.88,188 144.88,187.03 144.14,186.29 144.14,185.92 144.4,185.65 144.4,183.54 143.81,182.94 142.82,182.94 142.11,182.23 v1(141.73,182.23)
  BOTTOM w0.102: v1(141.73,182.23) 141.73,179.18 144.34,176.57 144.34,168.49 145.1,167.72 145.65,167.72 146.37,167 149.85,167 152.17,164.68 152.17,164.19 R989.2
UART_T10_NODE3_RXD: length 35
  TOP w0.102: C755.1 143.84,185.78 143.43,186.19 143.43,186.77 v1(143.34,186.86) R992.1 ; v1(154.13,165.29) 154.17,165.29 154.56,164.9 U129.73
  IN3 w0.114: v1(154.13,165.29) 151.57,167.86 151.57,178.02 152.18,178.64 152.18,180.5 150.85,181.84 149.5,181.84 148.3,183.03 148.3,185.62 147.85,186.07 147.85,186.88 147.39,187.34 143.83,187.34 143.35,186.86 v1(143.34,186.86)
UART_T10_NODE3_RXD_R: length 17.2
  TOP w0.102: J18.B56 142.05,198.13 v1(142.02,198.1) 142.5,197.63 142.5,191.84 143.34,191.01 R992.2
UART_T10_NODE3_TXD: length 2.8
  TOP w0.102: U129.72 154.06,162.22 153.85,162.01 v1(153.84,162.01)
  BOTTOM w0.102: R995.1 153.13,162.72 v1(153.84,162.01)
UART_T10_NODE3_TXD_R: length 51.1
  TOP w0.102: J18.B57 v1(141.05,199.57) 141.05,196.7 141.68,196.06 141.68,189.22 142.12,188.78 C758.1 141.58,187.99 141.58,186.54 141.06,186.02 141.06,184.25 141.1,184.2 141.1,183.75 141.36,183.49 142.14,183.49 v1(142.22,183.41)
  BOTTOM w0.102: v1(142.22,183.41) 142.26,183.37 142.26,179.08 144.64,176.69 144.64,168.62 145.23,168.03 145.78,168.03 146.42,167.39 150.84,167.39 151.66,166.58 152.57,166.58 153.13,166.01 R995.2
UART_T10_NODE4_RXD: length 40.9
  TOP w0.102: v1(155.25,165.99) 155.25,165.75 155.56,165.44 U129.75 ; C761.1 139.9,185.61 139.44,186.06 v1(139.44,186.18) 139.56,186.3 139.94,186.3 141.1,187.46 R998.1
  IN3 w0.114: v1(155.25,165.99) 152.55,168.69 152.55,180.58 150.97,182.17 149.62,182.17 148.62,183.17 148.62,186.04 148.17,186.49 148.17,187.11 147.49,187.79 141.49,187.79 139.89,186.18 v1(139.44,186.18)
UART_T10_NODE4_RXD_R: length 17.1
  TOP w0.102: R998.2 141.1,195.29 v1(140.16,196.23) 140.05,196.34 J18.B58
UART_T10_NODE4_TXD: length 3.4
  TOP w0.102: v1(155.71,161.98) 155.7,161.98 155.06,162.62 U129.74
  BOTTOM w0.102: v1(155.71,161.98) 154.9,162.78 R1001.1
UART_T10_NODE4_TXD_R: length 52.7
  TOP w0.102: v1(142.75,181.15) 142.19,181.15 139.68,183.66 139.68,185.28 138.98,185.98 138.98,186.73 138.51,187.19 138.51,188.13 138.91,188.53 C764.1 139.07,196.99 v1(138.85,197.21) 138.61,197.45 138.61,201.2 139.05,201.65 J18.B59
  BOTTOM w0.102: R1001.2 154.1,163.89 153.59,164.4 153.59,165.98 152.69,166.88 151.98,166.88 150.45,168.41 146.23,168.41 146.16,168.33 145.54,168.33 144.95,168.92 144.95,177.04 142.75,179.24 v1(142.75,181.15)
UART_T11_NODE1_RXD: length 28.8
  TOP w0.102: v1(158.65,165.61) U129.77
  IN3 w0.114: v1(158.65,165.61) 159.06,165.19 160.45,165.19 161.69,166.44 161.69,167.53 162.09,167.92 162.09,169.24 163.78,170.93 163.78,176.65 164.18,177.05 164.18,179.38 v1(164.6,179.79)
  BOTTOM w0.102: R957.1 162.19,187.47 162.19,186.06 162.51,185.74 C720.1 162.79,185.35 163.07,185.07 163.07,184.79 163.07,184.79 163.07,183.58 163.7,182.95 163.7,182.47 163.93,182.24 163.93,180.46 v1(164.6,179.79)
UART_T11_NODE1_RXD_R: length 18.8
  BOTTOM w0.102: R957.2 162.51,192.95 159.82,195.64 159.82,197.42 158.93,198.31 v2(158.93,199.39) 158.48,199.84 158.48,201.21 158.05,201.64 J18.A40
UART_T11_NODE1_TXD: length 24.3
  TOP w0.102: U129.76 159.14,165.11 159.54,165.51 v1(159.54,165.93)
  IN3 w0.114: v1(163.4,180.09) 163.4,179.6 163.82,179.18 163.82,177.52 163.46,177.16 163.46,171.15 161.77,169.47 161.77,168.13 161.09,167.44 161.04,167.44 v1(159.54,165.93)
  BOTTOM w0.102: R960.1 161.51,184.55 161.91,184.15 161.91,183.02 163.4,181.53 v1(163.4,180.09)
UART_T11_NODE1_TXD_R: length 22.2
  BOTTOM w0.102: R960.2 161.37,186.09 160.73,186.72 160.73,187.64 C723.1 161.37,192.68 158.39,195.66 158.39,198.16 v2(157.12,199.42) 157.05,199.5 J18.A41
UART_T11_NODE2_RXD: length 26.6
  TOP w0.102: v1(158.59,167.69) 158.16,168.11 U129.82
  IN3 w0.114: v1(159.48,184) 162.55,180.93 162.55,179.35 163.08,178.82 163.08,177.89 162.58,177.39 162.58,171.46 161.04,169.92 161.04,168.43 160.78,168.17 160.28,168.17 159.79,167.69 v1(158.59,167.69)
  BOTTOM w0.102: v1(159.48,184) 159.48,185.1 159.23,185.35 C726.1 158.83,185.49 159.24,185.91 159.24,186.99 158.83,187.41 R963.1
UART_T11_NODE2_RXD_R: length 18
  BOTTOM w0.102: R963.2 158.83,194.7 156.47,197.05 156.47,197.38 v2(156.1,197.75) 156.05,197.8 J18.A42
UART_T11_NODE2_TXD: length 24.7
  TOP w0.102: v1(156.04,167.5) 156.15,167.61 U129.81
  IN3 w0.114: v1(156.04,167.5) 156.66,168.12 158.89,168.12 159.73,168.12 159.95,168.35 159.95,169.4 160.69,170.14 160.69,170.99 162.2,172.5 162.2,180.03 v1(159.15,183.08)
  BOTTOM w0.102: v1(159.15,183.08) 158.93,183.3 158.72,183.3 158.19,183.83 158.19,184.05 R966.1
UART_T11_NODE2_TXD_R: length 21.4
  BOTTOM w0.102: J18.A43 v2(155.05,199.59) 155.12,199.52 155.12,197.44 155.77,196.8 155.77,195.45 157.69,193.53 C729.1 158.25,187.84 158.25,186.63 157.69,186.07 R966.2
UART_T11_NODE3_RXD: length 25.8
  TOP w0.102: v1(159.51,168.56) 158.97,169.11 U129.84
  IN3 w0.114: v1(159.51,168.56) 159.51,169.41 160.38,170.27 160.38,172.13 161.33,173.09 161.33,173.56 160.27,174.61 160.27,178.48 160.91,179.11 160.91,180.7 158.31,183.31 158.31,184.25 157.13,185.43 v1(157.13,186.07)
  BOTTOM w0.102: C732.1 156.54,185.48 v1(157.13,186.07) 157.13,187.17 156.7,187.6 R969.1
UART_T11_NODE3_RXD_R: length 18.2
  BOTTOM w0.102: J18.A45 153.05,201.65 153.48,201.21 153.48,198.55 153.86,198.17 v2(153.86,197.04) 153.86,195.66 156.54,192.97 R969.2
UART_T11_NODE3_TXD: length 25.3
  TOP w0.102: U129.83 156.47,168.61 155.92,168.06 155.78,168.06 155.25,167.53 v1(155.25,167.53)
  IN3 w0.114: v1(155.25,167.53) 156.42,168.7 158.36,168.7 160.04,170.38 160.04,173.14 160.1,173.2 160.1,174.04 159.9,174.24 159.9,181.11 157.81,183.2 v1(156.71,183.2)
  BOTTOM w0.102: v1(156.71,183.2) 156.59,183.2 155.4,184.39 R972.1
UART_T11_NODE3_TXD_R: length 21.7
  BOTTOM w0.102: J18.A46 152.05,199.8 v2(152.45,199.39) 152.45,196.84 152.62,196.67 152.62,195.48 155.4,192.7 C735.1 154.81,187.81 154.81,186.66 155.35,186.12 155.4,186.07 R972.2
UART_T11_NODE4_RXD: length 23.6
  TOP w0.102: U129.86 159.09,170.11 v1(159.12,170.08)
  IN3 w0.114: v1(153.76,186.45) 153.76,186.05 154.29,185.52 154.29,183.66 155.17,182.78 156,182.78 158.01,180.77 158.01,171.19 v1(159.12,170.08)
  BOTTOM w0.102: C738.1 154.26,185.95 v1(153.76,186.45) 153.88,186.57 153.88,187.22 R975.1
UART_T11_NODE4_RXD_R: length 18.2
  BOTTOM w0.102: J18.A47 151.05,197.98 v2(151.57,197.46) 151.45,197.34 151.45,194.51 154.26,191.7 R975.2
UART_T11_NODE4_TXD: length 18.8
  TOP w0.102: U129.85 v1(158.47,169.61)
  IN3 w0.114: v1(153.14,183.47) 153.95,183.47 157.65,179.78 157.65,170.43 v1(158.47,169.61)
  BOTTOM w0.102: R978.1 153.11,183.5 153.14,183.47 v1(153.14,183.47)
UART_T11_NODE4_TXD_R: length 21.8
  BOTTOM w0.102: R978.2 153.11,185.78 152.54,186.35 152.54,187.78 C741.1 153.11,188.76 153.07,188.8 153.07,191.29 150.62,193.74 150.62,196.35 v2(149.97,197) 149.75,197.22 149.75,199.68 150.05,199.97 J18.A48
UART_T12_NODE1_RXD: length 26
  TOP w0.102: U129.88 156.61,171.11 v1(155.59,170.08) ; v1(164.15,182.68) 164.22,182.76 164.22,185.35 163.97,185.61 C744.1 163.66,186.25 163.19,186.72 163.19,187.26 R981.1
  IN1 w0.114: v1(155.59,170.08) 156.43,170.93 158.91,170.93 160.43,172.45 160.43,174.75 160.29,174.89 160.29,177.29 162.82,179.83 162.82,181.77 163.74,182.68 v1(164.15,182.68)
UART_T12_NODE1_RXD_R: length 17.5
  TOP w0.102: R981.2 163.66,190.3 163.81,190.45 v1(163.81,198.17) 162.16,199.82 162.16,199.82 162.05,199.92 J18.B36
UART_T12_NODE1_TXD: length 19
  TOP w0.102: U129.87 158.72,170.61 158.87,170.76 160.71,170.76 163.08,173.12 163.08,178.96 162.83,179.21 162.83,181.15 162.62,181.36 162.62,182.37 v1(162.95,182.7) 162.95,182.7 162.95,184.35 162.51,184.78 R984.1
UART_T12_NODE1_TXD_R: length 20.7
  TOP w0.102: J18.B37 161.05,199.35 162.52,197.87 v1(162.52,195.96) 162.52,188.54 C747.1 161.88,187.9 161.88,186.81 162.51,186.18 R984.2
UART_T12_NODE2_RXD: length 23.5
  TOP w0.102: R987.1 160.91,187.26 160.91,186.55 161.37,186.09 C750.1 160.99,185.61 160.8,185.41 v1(160.8,183.5) ; v1(155.59,171.35) 156.34,172.11 U129.90
  IN1 w0.114: v1(160.8,183.5) 160.8,183.37 159.96,182.53 159.96,174.77 160.11,174.62 160.11,172.58 158.79,171.26 155.68,171.26 v1(155.59,171.35)
UART_T12_NODE2_RXD_R: length 17.2
  TOP w0.102: J18.B38 160.05,199.45 161.17,198.32 v1(161.17,196.54) 161.37,196.34 R987.2
UART_T12_NODE2_TXD: length 15.2
  TOP w0.102: U129.89 158.46,171.61 v1(158.55,171.7) ; R990.1 v1(160.23,184.13)
  IN1 w0.114: v1(158.55,171.7) 159.79,172.93 159.79,173.7 159.64,173.85 159.64,182.66 160.23,183.25 v1(160.23,184.13)
UART_T12_NODE2_TXD_R: length 20.9
  TOP w0.102: R990.2 160.23,186.05 159.64,186.63 159.64,187.94 C753.1 160.23,189.69 159.16,190.76 v1(159.16,196.89) 159.61,197.34 159.61,201.73 159.05,202.29 J18.B39
UART_T12_NODE3_RXD: length 18.9
  TOP w0.102: C756.1 157.69,186.06 157.76,186.14 158.41,186.14 v1(158.74,186.47) 158.32,186.88 158.32,187.46 158.06,187.73 R993.1 ; v1(158.59,173.41) 158.29,173.11 U129.92
  IN1 w0.114: v1(158.74,186.47) 158.7,186.47 158.7,186.48 158.39,186.16 158.39,183.75 158.52,183.62 158.52,179.74 159.29,178.97 159.29,174.87 158.59,174.17 v1(158.59,173.41)
UART_T12_NODE3_RXD_R: length 16.9
  TOP w0.102: R993.2 157.69,190.72 157.5,190.9 v1(157.5,197.4) 157.05,197.86 J18.B41
UART_T12_NODE3_TXD: length 15.6
  TOP w0.102: U129.91 v1(158.5,172.61) ; R996.1 157.09,184.26 157.09,183.7 157.88,182.92 v1(157.88,182.32)
  IN3 w0.114: v1(157.88,182.32) 159.59,180.61 159.59,173.9 159.79,173.7 159.79,173.34 159.06,172.61 v1(158.5,172.61)
UART_T12_NODE3_TXD_R: length 20.4
  TOP w0.102: R996.2 156.54,186.13 157.12,186.71 157.12,187.95 C759.1 156.54,193.9 156.73,194.09 v1(156.73,195.86) 156.05,196.54 J18.B42
UART_T12_NODE4_RXD: length 16.7
  TOP w0.102: C762.1 155.4,185.84 v1(156,186.44) 155.9,186.54 155.9,187.47 155.64,187.73 R999.1 ; v1(158.85,175.32) 158.57,175.32 158.35,175.11 U129.96
  IN1 w0.114: v1(156,186.44) 157.24,185.2 157.24,181.96 157.72,181.48 157.72,176.45 v1(158.85,175.32)
UART_T12_NODE4_RXD_R: length 16.9
  TOP w0.102: J18.B43 155.05,196.28 v1(154.96,196.19) 155.4,195.75 R999.2
UART_T12_NODE4_TXD: length 13.4
  TOP w0.102: v1(155.37,183.28) 154.91,183.28 154.26,183.93 R1002.1 ; U129.95 158.41,174.61 v1(158.47,174.67)
  IN1 w0.114: v1(155.37,183.28) 155.47,183.28 157.41,181.34 157.41,175.73 v1(158.47,174.67)
UART_T12_NODE4_TXD_R: length 20.6
  TOP w0.102: J18.B44 154.05,202.23 154.51,201.77 154.51,198.66 v1(154.31,198.46) 154.01,198.16 154.01,191.14 154.26,190.89 C765.1 154.92,187.86 154.92,186.6 154.26,185.93 R1002.2
UART_TX_P1: length 21.4
  TOP w0.102: v1(160.06,42.58) 160.44,42.58 160.55,42.69 163.11,42.69 165.4,40.39 169.92,40.39 171.59,38.72 171.59,37.39 171.24,37.03 U51.13 ; v1(160.06,42.58) 159.04,42.58 158.73,42.89 U43.124 ; v1(160.06,42.58) 160.06,43.19 160.53,43.66 R1009.2 R1010.2
UART_TX_P1_L: length 361.7
  TOP w0.102: v1(44.03,199.57) 44.05,199.59 44.05,205.19 J35.B63 ; U51.10 174.43,35.09 175.19,34.33 175.19,21.44 168.54,14.79 151.46,14.79 149.61,12.95 138.3,12.95 136.33,14.92 135.23,14.92 v1(134.78,15.38)
  IN1 w0.114: v1(134.78,15.38) 134.54,15.61 132,15.61 131.77,15.38 120.96,15.38 119.02,13.44 101.99,13.44 101.68,13.13 101.62,13.07 100.44,13.07 100.2,13.3 98.85,13.82 95.74,16.93 79.61,16.93 78.78,17.75 77.94,17.75 76.9,18.79 70.18,18.79 68.12,20.86 53.99,20.86 53.58,21.26 52.01,21.26 48.86,24.41 48.86,27.82 48.72,27.96 48.71,27.97 41.09,35.59 41.09,41.62 38.62,44.08 38.62,53.7 40.1,55.17 40.1,79.22 31.97,87.35 31.97,91.88 31.97,91.88 31.97,92.15 31.97,92.15 31.97,92.6 26,98.56 25.55,98.56 24.77,99.34 24.58,99.34 20.31,103.61 20.31,120.4 19.95,120.77 19.95,139.52 20.26,139.83 20.26,140.2 19.94,140.51 19.94,147.02 18.73,148.23 18.73,150.51 18.98,150.75 18.98,152.57 18.75,152.8 18.75,160.79 22.93,164.97 22.93,165.54 23.49,166.1 24.64,166.1 29.23,170.69 29.23,184.52 41.69,196.98 42.63,196.98 43.86,198.21 43.86,199.4 v1(44.03,199.57)
UART_TX_P2: length 178.1
  TOP w0.102: v1(153.13,44.16) 152.78,44.51 152.78,45.84 153.29,46.35 U43.5 153.29,49.11 152.73,49.68 R1024.2 R1020.2 ; U52.13 v1(20.67,23.12)
  IN3 w0.114: v1(20.67,23.12) 20.67,13.66 24.78,9.55 32.85,9.55 33.9,10.6 45.61,10.6 46.17,11.15 47.66,11.15 48.62,12.12 49.02,12.12 49.49,12.12 50.32,12.96 50.32,13.6 51.27,14.54 54.77,14.54 55.46,15.23 75.68,15.23 75.92,14.99 77.1,14.99 77.12,15.01 77.75,15.01 78.12,14.64 98.05,14.64 99.85,12.84 125.76,12.84 132,19.09 132,29.1 137.32,34.41 138.22,34.41 138.95,35.14 139.99,35.14 144.28,39.43 149.24,39.43 153.13,43.32 v1(153.13,44.16)
UART_TX_P2_L: length 217.1
  TOP w0.102: U52.10 22.62,31.46 25.85,34.69 38.88,34.69 40.84,36.65 40.84,38.38 39.44,39.78 39.44,44.25 v1(39.15,44.54)
  IN1 w0.114: v1(44.36,198.62) 44.36,197.28 43.74,196.66 41.82,196.66 29.55,184.39 29.55,170.56 19.4,160.41 19.4,155.88 19.65,155.63 19.65,147.77 20.91,146.51 20.91,140.03 20.27,139.39 20.27,120.9 20.63,120.54 20.63,103.74 24.71,99.66 24.95,99.66 25.73,98.88 26.14,98.88 32.31,92.71 32.31,87.46 32.42,87.34 32.42,87.34 40.41,79.35 40.41,54.25 38.94,52.77 38.94,44.75 v1(39.15,44.54)
  BOTTOM w0.102: v1(44.36,198.62) 44.58,198.84 44.58,199.77 44.05,200.3 J35.A63
UART_TX_P3: length 263.8
  TOP w0.102: v1(145.23,53.98) 145.24,53.98 145.89,53.98 146.4,53.47 146.4,51.96 R1159.2 145.75,51.31 v1(145.75,49.31) ; v1(147.06,177.17) U129.18 147.06,179.64 147.09,179.67 147.09,180.54 147.05,180.57 R1160.1
  IN1 w0.114: v1(145.23,53.98) 144.86,54.35 144.86,67.03 146.19,68.35 146.19,69.34 149.15,72.29 149.15,74.33 160.33,85.51 164.82,85.51 164.85,85.49 167.17,85.49 167.72,86.03 173.98,86.03 174.44,85.57 187.7,85.57 187.88,85.75 190.3,85.75 202.96,98.41 202.96,122.1 203.17,122.3 203.17,128.27 202.96,128.47 202.96,147.48 202.53,147.91 202.53,153.49 193.65,162.37 183.25,162.37 181.36,164.26 168.79,164.26 168.72,164.33 167.75,164.33 167.27,164.82 165.54,164.82 165.4,164.68 161.27,164.68 161.1,164.85 158.32,164.85 157.62,165.55 155.07,165.55 153.62,167 152.88,167 151.49,168.39 149.64,168.39 148.18,169.86 148.18,176 147.06,177.12 v1(147.06,177.17)
  IN3 w0.114: v1(145.75,49.31) 145.75,49.04 146.7,48.09 155.21,48.09 157.23,46.07 157.23,32.21 161.54,27.9 163.17,27.9 166.57,24.5 166.57,23.4 J5.2
UART_TX_P3_R: length 9.4
  TOP w0.102: R1135.2 R1134.2 147.03,54.92 146.7,54.59 146.7,51.47 R1159.1 146.27,50.02 146.55,49.74 v1(146.55,49.02) 146.55,48.74 146.79,48.49 U43.18
UART_TX_P4: length 321.6
  TOP w0.102: v1(90.65,181.43) 91.03,181.06 U128.15 ; U129.15 v1(148.56,180.36) ; U135.4 142.18,55.77 142.78,55.17 v1(142.78,52.89) 142.72,52.82 v1(142.72,49.35)
  IN1 w0.114: v1(142.78,52.89) 142.78,52.95 141.37,54.37 141.37,66.85 145.2,70.69 145.2,71.85 147.56,74.22 147.56,74.99 160.91,88.34 174,88.34 174.25,88.09 190.39,88.09 199.81,97.51 199.81,125.09 200.27,125.55 200.27,141.58 199.35,142.51 199.34,147.37 188.11,158.61 183.54,158.61 181.01,161.14 172.36,161.14 171.76,160.53 168.98,160.53 168.86,160.42 168.5,160.42 166.95,161.97 165.66,161.97 v1(164.68,162.95)
  IN2 w0.114: v1(148.56,180.36) 148.56,180 147.79,179.23 140.38,179.23 139.57,180.04 136.65,180.04 136.52,179.92 125.53,179.92 123.47,181.97 120.78,181.97 120.53,181.73 116.82,181.73 116.65,181.56 115.73,181.56 115.21,181.05 112.6,181.05 112.14,181.51 106.68,181.51 106.49,181.71 102.23,181.71 101.78,182.15 100.06,182.15 99.71,182.51 97.25,182.51 97.12,182.37 93.43,182.37 93.4,182.4 92.08,182.4 91.1,181.43 v1(90.65,181.43)
  IN3 w0.114: J6.2 161.08,22.63 161.08,27.11 156.37,31.82 156.37,45.59 154.6,47.37 145,47.37 143.01,49.35 v1(142.72,49.35)
  BOTTOM w0.102: v1(148.56,180.36) 148.56,179.86 149.52,178.9 149.52,173.24 150.58,172.18 150.58,170.24 153.01,167.81 153.67,167.81 154.47,167.01 155.48,167.01 155.82,166.68 156.82,166.68 160.55,162.95 v1(164.68,162.95)
UART_TX_P4_BUF: length 10.1
  TOP w0.102: R1161.2 141.14,51.59 141.45,51.89 141.45,53.49 141.17,53.77 140.24,53.77 139.75,54.26 139.75,55.9 139.23,56.42 ; R1162.1 138.85,58.26 138.74,58.16 v1(138.74,57.85) 138.96,57.85 139.59,57.22 139.59,56.79 139.23,56.42 ; 139.23,56.42 U135.2
UART_TX_P4_R: length 3.6
  TOP w0.102: U43.28 141.79,48.31 141.78,48.31 v1(141.34,48.74) 141.14,48.95 R1161.1
UART_TX_P5: length 255.9
  TOP w0.102: v1(135.74,30.42) 136.55,31.24 137.12,31.24 137.29,31.07 U43.66 ; U55.13 15.29,161.84 14.39,160.95 v1(14.39,160.39)
  IN1 w0.114: v1(44.95,22.06) 44.37,22.64 44.37,24.57 44.18,24.75 43.08,26.86 36.13,33.8 36.13,37.76 32.11,41.79 31.48,43.66 31.48,44.75 30.65,47.53 30.65,49.53 29.6,51.89 28.66,56.18 28.66,68.67 26.7,81.12 26.68,81.14 26.68,88.76 25.99,89.45 23.91,91.54 23.91,92.26 18.17,98 17.1,98 16.84,97.74 15.33,97.74 14.8,98.27 14.36,100.56 14.36,160.36 v1(14.39,160.39)
  IN2 w0.114: v1(135.74,30.42) 134.25,29.83 127.81,29.83 123.51,25.54 123.51,23.94 117.8,18.23 114.86,17.91 113.97,17.97 113.25,18.12 112.89,18.12 112.85,18.08 109.7,18.08 108.09,17.86 79.2,17.86 79.04,17.92 75.86,19.12 52.79,19.12 52.78,19.13 52.72,19.13 52.57,19.28 47.71,21.12 45.88,21.12 v1(44.95,22.06)
UART_TX_P5_L: length 69.8
  TOP w0.102: v1(24.8,159.46) 24.31,159.95 19.83,159.95 17.24,162.54 U55.10 ; v1(51.45,198.29) 51.45,199.44 52.05,200.04 J35.B55
  IN1 w0.114: v1(24.8,159.46) 24.85,159.51 25.11,159.51 27,161.4 28.25,161.4 42.42,175.57 42.42,182.02 42.28,182.15 42.28,185.93 41.47,186.75 41.47,188.98 42.47,189.98 43.78,189.98 51.45,197.65 v1(51.45,198.29)
UART_TX_P6: length 254
  TOP w0.102: v1(16.85,145.3) 15.92,146.23 U56.13 ; U43.77 142.79,31.37 143.31,31.89 v1(143.77,31.89)
  IN1 w0.114: v1(143.77,31.89) 143.77,27.94 143.58,27.75 143.58,26.93 143.78,26.73 143.78,22.66 136.09,14.97 134.79,14.58 131.23,14.58 130.54,13.9 124.68,13.9 119.22,12.49 102.63,12.49 102.26,12.11 100.04,12.11 99.73,12.42 99.73,12.42 99.67,12.48 92.42,15.24 79.95,15.24 78.38,16.8 77.41,16.8 76.43,17.78 69.58,17.78 68.54,18.11 66.07,19.76 53.93,19.76 52.23,20.28 51.56,20.28 50.4,20.67 49.39,21.67 47.91,23.92 47.91,27.42 39.72,35.61 39.72,39.28 36.35,42.65 36.35,52.96 35.09,56.69 34.31,59.83 34.05,61.81 34.05,62.18 34.37,62.73 34.63,63.72 34.63,65.87 35.04,66.29 35.04,82.02 30.23,86.83 30.23,92.09 26.05,96.27 24.67,96.27 23,97.94 23,98.27 18.08,103.19 18.08,142.07 16.85,145.03 v1(16.85,145.3)
UART_TX_P6_L: length 84.6
  TOP w0.102: U56.10 17.87,146.92 19.8,144.99 25.21,144.99 v1(25.75,144.46)
  IN1 w0.114: v1(53.47,197.76) 53.47,197.35 46.9,190.79 46.9,189.69 46.57,189.35 45.45,189.35 45.26,189.17 45.26,189.17 43.65,187.56 43.65,182.94 43.79,182.8 43.79,174.86 33.9,164.97 33.9,155.48 27.81,149.39 26.65,149.39 25.91,148.65 25.91,145.79 25.75,145.63 v1(25.75,144.46)
  BOTTOM w0.102: J35.A55 52.05,199.4 53.47,197.97 v1(53.47,197.76)
UART_TX_RP5_L: length 33.2
  TOP w0.102: J18.B22 176.05,200.11 174.16,198.22 174.16,196.53 176.04,194.65 176.3,194.4 176.33,194.4 177.09,193.63 177.09,193.12 176.35,192.37 176.35,191.83 v1(176.29,191.77) 176.29,190.66 177.36,189.59 177.36,187.15 174.65,184.44 174.65,179.21 176.4,177.45 U57.10
UART_TX_RP6_L: length 31
  BOTTOM w0.102: J18.A21 177.05,201.89 175.64,200.47 v2(175.64,196.37) 175.64,195.59 175.36,195.31 175.36,187.32 175.05,187.01 175.05,186.33 174.43,185.72 174.43,184.91 173.82,184.3 173.82,183.33 173.51,183.02 173.51,177.97 173,177.45 U59.10
USB0_DN: length 80
  TOP w0.102: U32.42 183.92,100.54 184.01,100.44 186.35,100.44 186.45,100.54 v1(186.45,100.97)
  TOP w0.107: R265.2 181.05,36.94 181.03,36.96 L42.1 179.74,36.96 179.4,37.3 179.06,37.3 v1(178.57,36.81)
  BOTTOM w0.107: v1(178.57,36.81) 178.57,37.18 178.67,37.29 179.64,37.29 180.44,38.09 180.44,42.44 177.07,45.81 177.07,63.16 188.54,74.62 188.54,99.65 187.69,100.49 186.56,100.49 186.45,100.6 v1(186.45,100.97)
USB0_DP: length 79
  TOP w0.102: U32.41 183.94,100.14 184.04,100.23 186.35,100.23 186.45,100.13 v1(186.45,99.7)
  TOP w0.107: v1(178.57,38.08) 179.03,37.61 179.4,37.61 179.74,37.96 L42.4 180.3,37.95 R264.2
  BOTTOM w0.107: v1(186.45,99.7) 186.45,100.07 186.56,100.18 187.56,100.18 188.22,99.51 188.22,74.75 176.76,63.29 176.76,45.68 180.13,42.31 180.13,38.22 179.51,37.6 178.67,37.6 178.57,37.71 v1(178.57,38.08)
USB0_L_DN: length 19.1
  TOP w0.107: R265.1 182.27,36.94 182.29,36.96 L42.2 183.5,36.96 183.84,37.3 186.15,37.3 186.89,38.04 186.89,38.48 187.62,39.2 U53.6 187.62,40.93 187.97,41.28 188.73,41.28 189.36,40.65 193.77,40.65 194.4,41.27 194.4,42.64 194.65,42.88 194.89,42.88 J14.2
USB0_L_DP: length 20.5
  TOP w0.107: R264.1 183.1,37.95 L42.3 183.5,37.96 183.84,37.61 186.02,37.61 186.58,38.17 186.58,38.46 185.72,39.32 U53.4 185.72,40.76 186.11,41.14 187.39,41.14 187.84,41.6 188.86,41.6 189.49,40.96 193.64,40.96 194.09,41.41 194.09,42.77 194.52,43.2 194.89,43.2 J14.3
USB1_DN: length 78.5
  TOP w0.107: v1(187.17,104.86) 186.68,104.37 184.11,104.37 183.87,104.14 U32.51 ; v1(178.58,40.53) 179.06,41.01 179.51,41.01 179.85,40.67 L43.1 180.35,40.66 R267.2
  BOTTOM w0.107: v1(178.58,40.53) 178.58,40.9 178.47,41.01 177.73,41.01 175.65,43.09 175.65,63.74 185.41,73.5 185.41,103.44 186.35,104.38 187.07,104.38 187.17,104.49 v1(187.17,104.86)
USB1_DP: length 77.6
  TOP w0.107: v1(187.17,103.59) 186.71,104.06 184.24,104.06 183.92,103.74 U32.50 ; v1(178.58,41.8) 179.06,41.32 179.51,41.32 179.85,41.66 L43.4 181.35,41.66 R266.2
  BOTTOM w0.107: v1(187.17,103.59) 187.17,103.96 187.07,104.07 186.48,104.07 185.72,103.31 185.72,73.37 175.96,63.61 175.96,43.22 177.86,41.32 178.47,41.32 178.58,41.43 v1(178.58,41.8)
USB1_L_DN: length 16.7
  TOP w0.107: R267.1 183.15,40.66 L43.2 183.61,40.67 183.95,41.01 184.95,41.01 185.3,41.36 185.52,41.36 185.95,41.79 187.2,41.79 187.62,42.21 U53.1 187.62,43.81 186.86,44.56 186.86,44.78 187.19,45.1 188.8,45.1 191.02,42.88 192.27,42.88 J14.6
USB1_L_DP: length 15.3
  TOP w0.107: J14.7 192.27,43.2 191.15,43.2 188.93,45.42 187.06,45.42 186.55,44.91 186.55,44.6 185.72,43.77 U53.3 185.72,42 185.39,41.67 185.16,41.67 184.82,41.32 183.95,41.32 183.61,41.66 L43.3 183.14,41.68 R266.1
USB2_DN: length 75.6
  TOP w0.107: v1(178.41,56.83) 178.89,57.32 179.41,57.32 179.75,56.97 L44.1 180.26,56.98 R269.2 ; U32.59 179.68,105.45 179.73,105.5 179.73,107.63 v1(179.25,108.1)
  BOTTOM w0.107: v1(178.41,56.83) 178.88,57.3 179.7,57.3 181.9,59.5 181.9,64.38 191.5,73.98 191.5,104.49 186.26,109.72 180.38,109.72 179.73,109.07 179.73,108.58 v1(179.25,108.1)
USB2_DP: length 74.1
  TOP w0.107: R268.2 180.28,58 L44.4 179.75,57.97 179.41,57.63 178.88,57.63 v1(178.41,58.1) ; v1(180.52,108.1) 180.04,107.63 180.04,105.45 180.08,105.41 U32.58
  BOTTOM w0.107: v1(178.41,58.1) 178.9,57.61 179.57,57.61 181.58,59.63 181.58,64.51 191.18,74.11 191.18,104.36 186.13,109.41 180.51,109.41 180.04,108.94 180.04,108.58 v1(180.52,108.1)
USB2_L_DN: length 19.1
  TOP w0.107: J15.2 195.74,62.05 194.9,62.9 194.66,62.9 194.41,62.65 194.41,61.29 193.78,60.67 189.37,60.67 188.74,61.3 187.98,61.3 187.63,60.95 U54.6 187.63,59.22 186.9,58.5 186.9,58.06 186.16,57.32 183.85,57.32 183.51,56.97 L44.2 183.05,56.98 R269.1
USB2_L_DP: length 20.5
  TOP w0.107: R268.1 183.03,58 L44.3 183.51,57.97 183.85,57.63 186.03,57.63 186.59,58.19 186.59,58.48 185.73,59.33 U54.4 185.73,60.77 186.12,61.16 187.4,61.16 187.85,61.61 188.87,61.61 189.5,60.98 193.65,60.98 194.09,61.42 194.09,62.79 194.53,63.22 194.89,63.22 J15.3
USB3_DN: length 72.3
  TOP w0.107: v1(175.41,108.67) 175.88,108.19 175.88,105.7 176.08,105.51 U32.68 ; v1(179.12,60.56) 179.59,61.02 180.07,61.02 L45.1 180.43,60.67 R271.2
  BOTTOM w0.107: v1(179.12,60.56) 179.12,60.93 179.02,61.03 178.37,61.03 177.87,61.53 177.87,62.62 189.26,74.01 189.26,104.57 186.94,106.89 176.85,106.89 175.88,107.85 175.88,108.56 175.78,108.67 v1(175.41,108.67)
USB3_DP: length 71.9
  TOP w0.107: U32.67 176.48,105.56 176.2,105.83 176.2,108.19 v1(176.68,108.67) ; v1(179.12,61.83) 179.61,61.34 180.07,61.34 L45.4 180.41,61.68 R270.2
  BOTTOM w0.107: v1(176.68,108.67) 176.31,108.67 176.2,108.56 176.2,107.98 176.98,107.21 187.07,107.21 189.58,104.7 189.58,73.88 178.19,62.49 178.19,61.66 178.5,61.35 179.02,61.35 179.12,61.45 v1(179.12,61.83)
USB3_L_DN: length 15.7
  TOP w0.107: R271.1 183.2,60.67 L45.2 183.55,61.02 184.96,61.02 185.3,61.37 185.53,61.37 185.96,61.81 187.21,61.81 187.63,62.23 U54.1 187.63,63.91 187.16,64.38 187.16,64.55 187.32,64.71 189.22,64.71 191.03,62.9 192.27,62.9 J15.6
USB3_L_DP: length 14.8
  TOP w0.107: R270.1 L45.3 183.55,61.34 184.83,61.34 185.17,61.69 185.4,61.69 185.73,62.02 U54.3 185.73,63.93 186.55,64.76 186.92,64.76 187.19,65.02 189.35,65.02 191.16,63.22 192.27,63.22 J15.7
USB_NODE1_PECREQ_L: length 3.3
  TOP w0.102: U32.13 174.67,99.34 174.52,99.19 174.24,99.19 174.2,99.14 173.5,99.14 v1(173.2,98.85) 172.7,98.34 R533.2
USB_NODE1_RREF: length 4.6
  TOP w0.102: R526.1 183.51,94.44 184.01,94.94 v1(184.01,95.28) 183.66,95.64 182.93,95.64 182.08,96.49 U32.33
USB_NODE1_SMI_L: length 108.6
  TOP w0.102: v1(161.66,107.58) 162.17,108.09 171.07,108.09 171.98,107.18 R525.2 173.81,106.37 175.28,104.9 U32.1 ; U2.G62 v1(84.62,86.12)
  IN2 w0.114: v1(161.66,107.58) 161.66,104.51 147.08,89.93 109.72,89.93 105.21,94.44 100.88,94.44 100.19,93.75 100.19,93.74 99.36,93.74 98.01,92.39 91.42,92.39 87.04,88 86.21,88 84.62,86.42 v1(84.62,86.12)
USB_NODE1_XTA1: length 6.5
  TOP w0.102: U32.31 181.28,95.31 181.67,94.92 C365.1 181.67,92.97 181.94,92.7 v1(181.94,92.68) 181.94,92.59 Y3.2
USB_NODE1_XTA2: length 6.3
  TOP w0.102: U32.30 180.88,95.25 180.69,95.07 C366.1 180.69,93.24 v1(180.6,93.14) 180.6,92.52 Y3.1
USB_OC_PU: length 4.5
  TOP w0.203: U32.22 v1(177.68,95.79) ; 179.05,96.02 179.28,96.25 U32.26 ; 178.47,96.05 178.48,96.05 U32.24 ; 177.13,95.95 176.88,96.2 U32.20
USB_WAKE_N: length 8.7
  TOP w0.102: U32.3 174.76,103.34 v1(173.73,104.37) 173.23,104.87 171.59,104.87 171.25,104.52 168.61,104.52 R534.2 R520.2
USBPWR_P0: length 1.1
  TOP w0.508: U53.5 v1(186.67,39.17)
  vias: v1(189.36,34.74) v1(189.83,38.01) v1(189.85,36.83) v1(196.54,33.1) v1(196.56,32.17) v1(196.56,31.36) v1(199.55,33.08) v1(199.57,32.15) v1(199.58,31.34) v1(201.79,32.97) v1(202.77,32.97) v1(203.7,32.32) v1(203.7,31.5)
USBPWR_P1: length 1.1
  TOP w0.406: U54.5 v1(186.68,59.19)
  vias: v1(184.43,54.59) v1(184.41,51.68) v1(184.83,55.21) v1(184.81,50.98) v1(185.23,54.6) v1(185.2,51.69) v1(187.25,51.69) v1(187.25,50.84) v1(187.72,53.87) v1(187.8,56.17) v1(187.79,55.07) v1(188.19,52.25) v1(189.27,52.29)
VGA_HSYNC: length 11.6
  TOP w0.102: U132.3 38.44,50.99 38.26,50.81 36.19,50.81 35.46,51.54 33.44,51.54 32.72,52.26 v1(30.8,52.26) 30.46,51.93 R638.1
VGA_VSYNC: length 14.4
  TOP w0.102: R637.1 v1(28.22,60.71) 30.23,61.14 32.44,61.14 33.48,60.65 34.76,60.65 35.79,60.04 36.58,59.41 37.88,58.11 38.44,57.03 38.44,56.07 38.44,56.06 U132.6
VR_CPU_NODE1_INTVRMEN: length 11.3
  TOP w0.102: R163.1 R166.1 v3(90.12,90.01) 89.72,90.01 88.89,89.19 88.89,86.24 87.82,85.17 87.51,85.17 86.97,84.63 86.1,84.63 85.87,84.86 U2.J64
VR_HSC_NODE1_GATE: length 14.3
  TOP w0.508: R1021.2 v1(45.97,174.42) ; Q22.4 v1(55.09,180.48)
  IN2 w0.508: v1(45.97,174.42) 47.64,176.09 52.16,176.09 53.77,177.71 53.77,179.16 v1(55.09,180.48)
VR_HSC_NODE1_GATE_R: length 3.2
  TOP w0.102: C779.1 R1021.1 46.14,176.03 46.14,176.45 v1(45.94,176.65) 46.17,176.88 U100.9
VR_HSC_NODE1_TIMER: length 4.5
  TOP w0.254: U100.5 44.33,182.22 44.09,182.45 v1(44.09,183.12) 43.69,183.53 43.69,184.65 C780.1
  BOTTOM w0.102: v1(44.09,183.12) 44.09,183.12 v2(45.55,183.12)
VR_NODE1_VDDR_1V5_CNTL: length 204.7
  TOP w0.254: v1(83.08,84.76) 83.08,84.72 82.62,84.26 U2.L59
  TOP w0.508: Q43.1 v1(45.1,4.87)
  IN1 w0.508: v1(98.33,18.64) 100.51,20.82 114.96,20.82 118.68,24.53 118.68,30 117.88,30.8 117.88,48.28 125.84,56.24 125.84,59.81 126.14,60.1 126.14,66.14 126.93,66.93 126.93,70.46 126.15,71.24 126.15,77.14 119.53,83.76 111.57,83.76 v1(111.11,84.22)
  IN3 w0.508: v1(83.08,84.76) 83.08,84.45 83.46,84.08 84.05,84.08 84.33,84.35 85.07,84.35 85.86,83.57 85.86,83.2 86.38,82.67 89.09,82.67 90.15,83.74 91.47,83.74 91.88,83.33 92.85,83.33 93.43,83.9 94.29,83.9 94.75,83.45 94.75,82.39 95.32,81.82 97.74,81.82 98,82.07 104.56,82.07 105.62,83.13 106.87,83.13 108.13,84.38 109.91,84.38 109.93,84.4 110.93,84.4 111.11,84.22 v1(111.11,84.22)
  BOTTOM w0.508: v1(83.08,84.76) 83.08,84.14 83.26,83.96 R77.2 ; v1(45.1,4.87) 42.84,7.13 42.84,15.94 47.17,20.27 47.42,20.03 47.95,20.03 48.24,20.33 54.81,20.33 55.65,19.48 77.24,19.48 78.99,17.74 97.43,17.74 v1(98.33,18.64)
VR_PVCCP_NODE1_BOOT1:
  vias: v1(122.42,132.46)
VR_PVCCP_NODE1_COMP: length 5.3
  TOP w0.178: PU8.5 123.26,134.7 123.39,134.83
  TOP w0.254: v1(126.71,134.55) 126.25,135.01 PC102.1 125.92,134.89 PC108.1 125.23,134.91 PR68.1 123.46,134.91 123.39,134.83
VR_PVCCP_NODE1_COMP_RC: length 1.7
  TOP w0.254: PC102.2 127.06,135.22 PR66.1 v1(128.04,134.5)
VR_PVCCP_NODE1_EN: length 26.8
  TOP w0.178: 117.9,131.49 118.1,131.7 PU8.32
  TOP w0.254: PC122.1 124.56,139.53 v1(124.49,139.6)
  IN1 w0.254: v1(124.49,139.6) 125.28,140.39 125.28,141.92 124.78,142.42 116.37,142.42 116,142.05 116,141.06 116.78,140.28 116.78,139.39 116.43,139.03 116.43,137.95 117.06,137.31 117.06,133.17 117.68,132.55 117.68,131.68 117.31,131.31 v1(116.54,131.31)
  vias: v1(115.63,131.22)
