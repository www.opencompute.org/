# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_DDR3_NODE1_MA15: length 61.8
  TOP w0.102: 69.15,58.55 68.7,59 68.7,60.48 68.7,60.48 U2.BP31
  TOP w0.229: 69.15,58.55 69.35,58.34 69.35,53.33 71.31,51.37 71.31,50.83 71.7,50.45 72.11,50.45 72.32,50.24 72.32,49.93 72.11,49.71 71.7,49.71 71.48,49.5 71.48,49.19 71.7,48.98 72.11,48.98 72.32,48.76 72.32,48.46 72.11,48.24 71.7,48.24 71.48,48.03 71.48,44.74 71.74,44.49 71.74,43.22 73.21,41.75 73.21,41.2 73.43,40.98 73.86,40.98 74.07,40.77 74.07,40.46 73.86,40.25 73.43,40.25 73.21,40.03 73.21,39.72 73,39.5 72.69,39.5 72.48,39.72 72.48,41.42 72.26,41.63 71.96,41.63 71.74,41.42 71.74,39 72.47,38.27 72.77,38.27 73.35,38.85 73.66,38.85 73.87,38.63 73.87,38.33 73.29,37.75 73.29,37.45 73.51,37.23 73.81,37.23 73.95,37.37 74.26,37.37 74.47,37.15 74.47,36.84 74.33,36.71 74.33,36.4 74.55,36.19 74.86,36.19 74.99,36.32 75.3,36.32 75.51,36.11 75.51,35.8 75.38,35.67 75.38,35.36 75.9,34.84 76.23,34.84 v3(76.54,34.53) 76.81,34.25 76.81,33.94 76.52,33.64 76.15,33.64 75.98,33.48 75.98,30.81 76.17,30.62 76.9,30.62 77.11,30.83 77.11,31.22 76.87,31.46 76.87,32.91 77.74,33.78 78.13,33.78 78.58,33.33 78.58,33.03 78.15,32.59 78.15,32.13 78.51,31.76 78.89,31.76 79.58,32.46 79.88,32.46 80.88,31.45 J2.88
M_DDR3_NODE1_MON1N: length 15.3
  TOP w0.127: v1(72.88,66.2) 72.52,65.84 U2.BG38
  IN3 w0.17: v1(70.89,61.02) 71.57,61.71 71.57,62.55 71.47,62.65 71.47,62.65 70.63,63.49 70.63,64.44 70.84,64.65 71.9,64.65 72.41,65.16 72.41,66.09 72.53,66.2 v1(72.88,66.2)
  BOTTOM w0.17: v1(70.89,61.02) 70.59,61.32 70.42,61.32 70.25,61.15 70.25,56.31 R32.2 70.19,55.85 70.19,55.36 R33.2
M_DDR3_NODE1_MON1P: length 15
  TOP w0.127: U2.BG37 71.79,65.86 71.43,66.22 v1(71.42,66.22)
  IN3 w0.17: v1(71.42,66.22) 71.84,66.22 72.11,65.94 72.11,65.29 71.77,64.95 70.71,64.95 70.33,64.57 70.33,63.37 71.26,62.44 71.26,62.26 v1(70.89,61.89)
  BOTTOM w0.17: R33.1 69.91,55.36 69.91,55.85 R32.1 69.98,56.43 v1(69.98,57.36) 69.98,61.26 70.31,61.59 70.59,61.59 v1(70.89,61.89)
M_DDR3_NODE1_MON2N: length 7.5
  TOP w0.127: v1(72.88,66.96) 72.52,66.6 U2.BF38
  BOTTOM w0.17: v1(72.88,66.96) 72.42,66.51 72.42,65.25 72.69,64.98 73.26,64.98 73.61,64.64 74.04,64.21 v1(74.04,63.75) 74.04,62.82 R34.2 74.05,62.28 74.05,61.79 R35.2
M_DDR3_NODE1_MON2P: length 7.6
  TOP w0.127: v1(71.42,66.98) 71.79,66.61 U2.BF37
  BOTTOM w0.17: R35.1 73.78,61.79 73.78,62.28 R34.1 73.74,62.77 73.74,64.08 73.4,64.43 73.14,64.69 72.57,64.69 72.13,65.13 v1(72.13,65.76) 72.13,66.27 v1(71.42,66.98)
M_DDR3_NODE1_ODT0: length 61.4
  TOP w0.102: 78.59,61.06 78.59,61.16 77.02,62.73 77.02,63.6 U2.BL48
  TOP w0.165: 78.59,61.06 78.59,58.1 78.72,57.97 78.94,57.97 79.2,57.71 79.2,57.43 79.01,57.23 78.08,57.23 77.81,56.96 77.81,56.58 78.08,56.3 79.65,56.3 79.9,56.55 79.9,57.45 80.09,57.65 82.57,57.65 82.77,57.45 82.77,57.17 82.57,56.98 80.83,56.98 80.63,56.78 80.63,56.5 80.83,56.3 83.64,56.3 91.73,48.21 v3(92.19,48.21) 92.19,48.21 92.53,48.54 92.86,48.54 93.51,47.89 93.51,47.6 93.03,47.12 93.03,46.44 92.84,46.26 92.66,46.26 92.46,46.06 92.46,45.78 92.66,45.58 92.84,45.58 93.04,45.39 93.04,45.11 92.84,44.91 92.66,44.91 92.46,44.71 92.46,44.44 92.66,44.24 92.84,44.24 93.04,44.04 93.04,43.76 92.84,43.57 92.68,43.57 92.49,43.37 92.49,43.09 92.68,42.89 92.84,42.89 93.04,42.69 93.04,42.42 92.84,42.22 92.67,42.22 92.47,42.02 92.47,41.74 92.67,41.55 92.84,41.55 93.04,41.35 93.04,41.07 92.84,40.87 92.71,40.87 92.51,40.68 92.51,40.4 92.71,40.2 92.84,40.2 93.04,40 93.04,39.72 92.84,39.53 92.79,39.53 92.59,39.33 92.59,38.73 93.38,37.94 93.38,36.71 93.68,36.41 93.68,36.04 93.38,35.74 93.38,35.1 93.74,34.74 93.74,34.16 93.51,33.93 92.46,33.93 92.28,33.75 92.28,33.42 92.48,33.23 93.07,33.23 93.28,33.02 93.28,32.68 93.07,32.48 92.4,32.48 92.28,32.36 92.28,29.15 J2.126
M_DDR3_NODE1_ODT1: length 60.5
  TOP w0.102: U2.BP49 77.7,62.55 77.7,62.4 79.23,60.87 79.23,60.46
  TOP w0.165: 79.23,60.46 79.23,58.88 79.91,58.2 83.24,58.2 83.68,57.77 83.68,57.18 91.29,49.56 92.9,49.56 95.03,47.43 95.03,39.71 94.83,39.51 94.56,39.51 94.36,39.71 94.36,46.83 94.16,47.03 93.88,47.03 93.69,46.83 93.69,38.96 94.43,38.22 v3(94.43,37.33) 94.43,33.17 94.43,32.62 94,32.2 93.78,32.2 92.88,31.3 J2.128
M_DDR3_NODE1_ODTPU: length 4.3
  TOP w0.254: v1(69.43,65.84) 69.8,65.46 U2.BH32
  BOTTOM w0.254: R30.1 67.37,63.56 67.37,64.41 67.62,64.66 68.02,64.66 68.37,65.01 v2(68.37,65.1) 68.37,65.37 68.84,65.84 v1(69.43,65.84)
M_DDR3_NODE1_RAS_L: length 58.8
  TOP w0.102: U2.BP43 74.64,61.53 75.61,60.56 75.61,59.03 76.19,58.46 76.19,58.14
  TOP w0.229: J2.122 91.08,30.73 90.55,31.27 89.94,31.27 89.71,31.49 89.71,31.82 89.94,32.05 90.27,32.05 90.74,32.52 91.49,32.52 91.7,32.72 91.7,33.05 91.49,33.26 90.94,33.26 90.73,33.46 90.73,33.98 90.94,34.19 91.7,34.19 92.51,35 92.51,35.29 v3(92.02,35.79) 91.78,36.03 91.78,36.55 91.99,36.77 92.44,36.77 92.66,36.98 92.66,37.29 92.44,37.5 91.99,37.5 91.78,37.72 91.78,38.71 91.57,38.91 91.57,38.92 90.53,38.92 90.3,39.14 90.3,42.91 90.51,43.11 90.84,43.11 91.04,42.91 91.04,40.01 91.24,39.81 91.57,39.81 91.78,40.01 91.78,47.12 83.29,55.61 77.18,55.61 76.19,56.6 76.19,58.14
M_DDR3_NODE1_WE_L: length 61.5
  TOP w0.102: U2.BL44 75.32,63.89 75.2,63.77 75.2,63.31 75.04,63.14 75.04,62.91 75.27,62.68 75.27,61.78 76.59,60.45 v1(76.59,59.57)
  TOP w0.229: J2.121 90.78,23.07 v1(91.17,23.46)
  IN1 w0.102: v1(76.59,59.57) 76.59,59.52 77,59.12 77.58,59.12 79.46,57.24 79.46,56.95
  IN1 w0.229: v1(91.17,23.46) 91.4,23.69 91.4,23.74 92.12,24.46 92.12,25.86 91.76,26.23 91.76,30.16 92.19,30.59 92.44,30.84 92.44,31.73 92.45,31.74 92.24,31.95 92.24,34.15 92.85,34.76 92.85,36.53 92.63,36.75 92.46,36.75 92.25,36.97 92.25,37.27 92.46,37.49 92.63,37.49 92.85,37.7 92.85,38.01 92.63,38.22 92.46,38.22 92.25,38.44 92.25,38.74 92.46,38.96 92.63,38.96 92.85,39.17 92.85,39.48 92.63,39.7 92.46,39.7 92.25,39.91 92.25,40.22 92.46,40.43 92.63,40.43 92.85,40.65 92.85,46.31 92.32,46.84 92.01,46.84 91.78,46.62 91.48,46.62 91.26,46.83 91.26,47.14 91.49,47.36 91.49,47.67 91.27,47.89 90.97,47.89 90.74,47.66 90.44,47.66 90.22,47.87 90.22,48.18 90.45,48.41 90.45,48.71 90.23,48.93 89.93,48.93 89.7,48.7 89.39,48.7 89.18,48.92 89.18,49.22 89.41,49.45 89.41,49.75 89.19,49.97 88.88,49.97 88.66,49.74 88.35,49.74 88.14,49.96 88.14,50.26 88.36,50.49 88.36,50.79 88.06,51.1 87.57,51.1 87.15,50.67 86.77,50.67 85.81,51.63 85.81,51.93 86.01,52.13 86.01,52.44 85.79,52.65 85.48,52.65 85.29,52.46 84.98,52.46 83.94,53.49 82.42,53.49 79.46,56.45 79.46,56.95
M_NODE1_DIMM_RST_L: length 68.2
  TOP w0.102: U2.BC38 72.49,68.12 v1(72.88,67.73) ; v1(64.33,25.78) 64.33,25.77 64.08,25.52 62,25.52 61.08,26.44 J2.30
  IN1 w0.114: v1(72.88,67.73) 72.25,67.1 72.25,65.49 71.51,64.74 66.19,64.74 63.69,62.25 63.69,61.95 63.16,61.43 63.16,60.24 62.99,60.06 62.99,59.08 61.38,57.47 61.38,56.7 52.37,47.69 52.37,42.47 53.04,41.8 54.38,41.8 56.45,39.73 58.46,39.73 65.01,33.18 65.01,26.15 64.64,25.78 v1(64.33,25.78)
MATE_N: length 243.1
  TOP w0.102: v1(57.96,182.35) 57.67,182.64 U93.G 57.67,184.58 56.97,185.28 C604.1 56.4,186.12 R1007.2
  BOTTOM w0.102: v1(57.96,182.35) 57.67,182.64 R835.2 56.93,184.52 56.61,184.2 55.7,184.2 55.14,184.76 55.14,185.47 55.92,186.26 55.92,190.17 55.47,190.63 46.45,190.63 45.79,189.97 45.79,187.05 45.13,186.39 45.13,184.35 46.07,183.41 46.07,181.86 44.34,180.14 44.34,170.54 43.53,169.72 43.53,168.83 44.24,168.12 44.24,155.27 42.54,153.57 35.43,153.57 32.66,150.8 26.79,150.8 23.54,147.55 23.54,142.75 26.03,140.26 26.03,137.52 23.87,135.36 20.49,135.36 18.15,133.02 18.15,106.17 22.29,102.03 25.04,102.03 27.37,99.69 27.37,89.97 40.4,76.94 40.4,65.38 43.07,62.71 43.07,41 40.71,38.63 28.14,38.63 J36.2
MATE_R_N: length 47
  TOP w0.102: v1(26.38,200.58) 26.05,200.91 J35.B81
  IN1 w0.114: v1(38.52,196.37) 38.52,196.39 35.32,199.6 27.36,199.6 v1(26.38,200.58)
  BOTTOM w0.102: v1(56.47,185.01) 56.78,185.32 R835.1 57.67,191.66 56.53,192.8 56.52,192.8 54.22,195.1 39.82,195.1 38.52,196.39 v1(38.52,196.37)
Net_221: length 6.5
  BOTTOM w0.102: 182.05,205.2 182.05,202.31 181.62,201.88 181.62,200.04 181.62,200.04 181.62,199.52 v1(182.04,199.1)
Net_222: length 5.4
  TOP w0.102: 184.05,205.2 v1(184.05,199.76)
Net_223: length 6.4
  TOP w0.102: 183.05,205.2 v1(183.05,198.85)
Net_224: length 5.5
  TOP w0.102: v1(180.81,199.62) 181.48,200.29 181.48,201.72 181.05,202.16 181.05,204.7
Net_225: length 6.9
  BOTTOM w0.102: 185.05,205.2 185.05,202.98 184.6,202.53 184.6,199.49 184.11,199 v1(184.11,198.66)
Net_226: length 7.8
  BOTTOM w0.102: v1(183.84,197.72) 183.57,197.99 183.57,202.22 184.05,202.7 184.05,205.2
Net_2330: length 6.9
  BOTTOM w0.102: v1(40.05,198.68) 39.62,199.11 39.62,200.35 40.05,200.78 40.05,205.2
Net_2331: length 6.8
  TOP w0.102: v1(37.07,198.75) 37.51,199.19 37.51,200.2 37.05,200.66 37.05,205.2
Net_2332: length 5.6
  TOP w0.102: 40.05,205.2 v1(40.05,199.58)
Net_2333: length 7
  BOTTOM w0.102: 38.05,205.2 38.05,200.92 37.49,200.37 37.49,199.23 v1(38.05,198.68)
Net_2334: length 5.6
  BOTTOM w0.102: 39.05,205.2 v1(39.05,199.59)
NODE1_BIOS_MB_REV_ID0: length 15.3
  TOP w0.102: v1(76.8,83.76) 77.47,83.1 U2.N48
  BOTTOM w0.102: R86.2 R88.2 76.21,95.47 76.52,95.17 76.52,92.85 v2(76.66,92.71) 76.66,92.51 76.77,92.4 76.77,90.58 77.04,90.31 77.04,88.7 77.46,87.1 77.56,87.01 77.56,84.52 v1(76.8,83.76)
NODE1_BIOS_MB_REV_ID1: length 16.9
  TOP w0.102: U2.L52 79.46,84.28 v1(78.88,84.28)
  BOTTOM w0.102: R92.2 82.88,98.3 82.88,97.3 82.62,97.03 82.03,97.03 81.29,96.3 R90.2 81.07,96.08 81.07,94.51 80.01,93.44 80.01,90.75 79.98,90.45 79.98,88.03 79.64,87.69 79.64,85.04 v1(78.88,84.28)
NODE1_BIOS_MB_REV_ID2: length 14.2
  TOP w0.102: v1(83.72,84.78) 83.72,84.8 83.02,85.5 U2.H59
  BOTTOM w0.102: v1(83.72,84.78) 84.08,85.14 85.83,85.14 87.41,86.73 87.41,88.89 87.27,89.03 v2(87.27,89.84) 87.27,90.5 88.12,91.35 88.12,92.62 87.5,93.24 R96.2 R94.2
NODE1_USB_TESTMODE: length 2.9
  TOP w0.102: U30.20 162.21,60.76 162.83,60.15 v1(163.26,60.15) 163.38,60.02 R503.2
OSC1_48MHZ: length 2.3
  TOP w0.102: OSC4.3 129.71,39.91 130.38,40.58 v1(130.77,40.58) R618.1
P2E_CPU_BMC_NODE1_RX_C_DN: length 9.1
  TOP w0.127: C203.2 86.47,120.63 85.5,120.63 85.11,121.01 v4(85.11,122.84) 85.11,124.58 83.35,126.34 83.35,126.62 82.97,127 U14.E21
P2E_CPU_BMC_NODE1_RX_C_DP: length 9
  TOP w0.127: U14.E22 82.97,126.29 84.81,124.46 84.81,123.17 84.64,123.01 84.64,122.7 84.81,122.53 84.81,122.05 84.65,121.89 84.65,121.6 84.81,121.45 84.81,120.89 85.37,120.32 v4(85.82,120.32) 86.37,120.32 C202.2
P2E_CPU_BMC_NODE1_RX_DN: length 67.8
  TOP w0.127: U125.88 137.08,140.58 137.04,140.62 136.78,140.62 136.02,139.86 136.02,139.35 135.64,138.97 135.24,138.97 v1(134.77,138.49) ; C203.1 88,120.58 88.93,120.58 v1(89.15,120.8)
  IN3 w0.127: v1(134.77,138.49) 134.28,138.98 132.17,138.98 126.66,143.37 126.1,143.75 125.16,143.84 125.01,143.72 124.63,143.76 124.51,143.91 124.13,143.95 123.99,143.83 123.61,143.87 123.49,144.01 123.11,144.05 122.96,143.93 122.58,143.97 122.46,144.12 121.83,144.18 121.61,144.18 121.21,144.14 121.08,143.99 120.7,143.96 120.55,144.09 120.17,144.05 120.04,143.9 119.66,143.87 119.51,144 119.13,143.96 119,143.81 118.62,143.78 118.47,143.91 118.09,143.87 117.96,143.72 117.58,143.69 117.43,143.81 117.05,143.78 116.92,143.63 116.54,143.6 116.39,143.72 115.25,143.62 113.87,142.03 111.92,141.66 108.19,141.55 105.3,140.78 104.53,139.88 104.21,139.11 102.65,137.06 102.26,135.78 102.2,134.94 101.79,134.21 100.14,132.57 97.19,129.42 95.69,128.55 94.78,127.15 91.44,122.79 89.42,121.83 89.32,121.8 88.89,121.77 88.19,121.34 88.04,120.98 88.08,120.72 88.23,120.57 88.92,120.57 v1(89.15,120.8)
P2E_CPU_BMC_NODE1_RX_DP: length 67.9
  TOP w0.127: C202.1 88.02,120.27 88.93,120.27 v1(89.15,120.04) ; v1(134.77,139.76) 135.26,139.27 135.51,139.27 135.71,139.48 135.71,139.99 136.66,140.93 137.06,140.93 137.11,140.98 U125.87
  IN3 w0.127: v1(134.77,139.76) 134.28,139.27 132.27,139.27 126.83,143.6 126.21,144.03 121.84,144.47 121.6,144.47 115.11,143.91 113.72,142.3 111.89,141.96 108.18,141.84 108.12,141.83 105.13,141.04 104.28,140.04 103.96,139.26 102.39,137.2 101.97,135.83 101.91,135.03 101.55,134.39 99.93,132.77 97,129.65 95.48,128.77 94.54,127.31 91.25,123.02 89.3,122.09 88.8,122.05 87.95,121.54 87.74,121.02 87.81,120.58 88.11,120.28 88.92,120.28 v1(89.15,120.04)
P2E_CPU_BMC_NODE1_TX_C_DN: length 5
  TOP w0.127: U125.83 137.11,142.58 137.06,142.53 136.32,142.53 135.82,142.02 135.13,142.02 134.93,142.22 v1(134.93,142.53)
  BOTTOM w0.127: C188.1 134.19,142.05 134.44,142.05 v1(134.93,142.53)
P2E_CPU_BMC_NODE1_TX_C_DP: length 4.9
  TOP w0.127: U125.84 137.1,142.18 137.05,142.22 136.45,142.22 135.94,141.71 135.07,141.71 134.93,141.57 v1(134.93,141.26)
  BOTTOM w0.127: C187.1 134.19,141.74 134.44,141.74 v1(134.93,141.26)
P2E_CPU_BMC_NODE1_TX_DN: length 68.9
  TOP w0.127: v1(82.51,122.22) 82.78,122.22 82.86,122.3 82.86,122.79 82.69,122.96 82.69,123.34 82.86,123.51 82.86,123.72 82.69,123.89 82.69,124.15 82.86,124.32 82.86,124.53 82.7,124.68 82.7,124.89 82.86,125.05 82.86,125.32 82.77,125.41 82.53,125.41 82.42,125.51 82.42,125.76 82.29,125.89 82.29,126.34 U14.F22
  IN3 w0.127: v1(131.87,142.52) 131.38,142.03 130.89,142.03 129.49,143.43 126.24,145.42 122.03,145.84 114.65,144.8 112.93,143.2 111.85,143.09 111.56,143.08 106.92,142.87 104.47,142.09 103.75,141.25 103.72,141.2 102.98,139.85 101.94,138.66 99.36,134.1 96.57,132.04 91.8,125.38 89.64,123.67 87.58,123.12 84.19,124.05 83.77,124.02 83.62,123.97 83.1,123.66 82.97,123.51 82.81,123.16 82.81,122.52 v1(82.51,122.22)
  BOTTOM w0.127: C188.2 132.68,142.05 132.33,142.05 v1(131.87,142.52)
P2E_CPU_BMC_NODE1_TX_DP: length 68.9
  TOP w0.127: v1(83.4,122.22) 83.16,122.46 83.16,125.45 82.59,126.02 82.59,126.56 U14.F21
  IN3 w0.127: v1(83.4,122.22) 83.1,122.52 83.1,123.09 83.22,123.34 83.29,123.43 83.74,123.7 83.83,123.73 84.16,123.76 87.58,122.82 89.72,123.39 89.82,123.44 92.02,125.17 96.78,131.83 99.58,133.91 102.18,138.49 103.22,139.68 103.97,141.04 103.98,141.07 104.64,141.84 106.97,142.58 111.58,142.78 111.87,142.8 113.05,142.92 114.79,144.53 122.03,145.54 122.46,145.5 122.6,145.33 122.98,145.3 123.14,145.43 123.52,145.39 123.66,145.23 124.04,145.19 124.21,145.33 124.58,145.29 124.72,145.12 125.1,145.09 125.27,145.22 126.14,145.14 129.3,143.2 130.76,141.73 131.38,141.73 v1(131.87,141.25)
  BOTTOM w0.127: v1(131.87,141.25) 132.37,141.75 132.67,141.75 C187.2
P2E_CPU_NIC1_NODE1_RX_DN: length 141.7
  TOP w0.127: v1(67.9,151.48) 67.43,151.95 67.1,151.95 C392.1 ; v1(54.53,64.99) 54.62,64.9 U2.BJ4
  IN3 w0.127: v1(54.53,64.99) 54.56,65.32 54.71,65.45 55.05,65.45 55.52,65.93 55.52,66.8 54.57,67.61 50.98,67.44 45.77,66.96 43.27,68.12 41.53,72.68 40.16,77.73 38.69,80.76 30.85,90.4 27.93,100.82 24.92,103.5 23.4,103.68 22.63,104.62 22.69,106.54 22.69,106.83 22.32,109.35 22.86,111.66 22.89,112.53 23.29,133.08 24.62,135.21 29.35,137.84 30.56,138.68 31.44,138.88 34.58,139.61 36.75,141.36 45.06,150.24 50.65,150.69 53.98,150.85 59.77,151.38 61.58,152.67 62.44,152.67 64.31,151.97 67.78,151.97 67.9,151.84 v1(67.9,151.48)
P2E_CPU_NIC1_NODE1_RX_DP: length 141.8
  TOP w0.127: v1(67.9,152.75) 67.41,152.25 67.17,152.25 C391.1 ; U2.BH3 54.74,66.09 v1(54.63,66.2)
  IN3 w0.127: v1(54.63,66.2) 54.6,65.86 54.71,65.74 54.92,65.74 55.23,66.05 55.23,66.66 54.47,67.31 51,67.15 45.72,66.66 43.04,67.9 41.25,72.59 39.89,77.62 38.44,80.6 30.59,90.26 27.67,100.66 24.79,103.22 23.24,103.4 22.33,104.52 22.4,106.54 22.4,106.81 22.02,109.36 22.57,111.7 22.6,112.54 23,133.17 24.41,135.43 29.2,138.09 30.44,138.95 31.38,139.17 34.45,139.88 36.56,141.57 44.92,150.52 50.63,150.98 53.96,151.14 59.66,151.66 61.48,152.96 62.49,152.96 64.36,152.26 67.78,152.26 67.9,152.39 v1(67.9,152.75)
P2E_CPU_NIC1_NODE1_TX_C_DN: length 12.5
  TOP w0.127: U2.BK9 57.73,64.89 57.73,65.12 v1(58.05,65.44)
  BOTTOM w0.127: v1(58.05,65.44) 58.05,65.45 57.81,65.45 57.55,65.19 57.55,64.73 56.77,63.96 54.49,63.96 53.37,65.08 52.48,65.08 51.49,64.09 48.66,64.09 C20.1
P2E_CPU_NIC1_NODE1_TX_C_DP: length 12.4
  TOP w0.127: U2.BH8 56.68,65.46 v1(56.67,65.45)
  BOTTOM w0.127: v1(56.67,65.45) 56.67,65.45 57.09,65.45 57.25,65.29 57.25,64.85 56.64,64.26 55.9,64.26 55.75,64.41 55.37,64.41 55.22,64.26 54.62,64.26 53.5,65.38 52.35,65.38 51.36,64.39 50.66,64.39 50.53,64.52 50.15,64.52 50.02,64.39 49.64,64.39 49.51,64.52 49.13,64.52 49,64.39 48.66,64.39 C19.1
P2E_CPU_NIC1_NODE1_TX_DN: length 138.1
  TOP w0.127: U35.23 61.74,154.17 61.84,154.27 62.69,154.27 63.02,153.95 63.36,153.95 v1(63.85,153.45)
  IN3 w0.127: v1(44.96,63.61) 45.45,64.09 45.87,64.09 46.28,64.42 46.34,65.15 46.17,65.65 45.43,66.01 44.5,66.25 42.39,67.33 41.06,69.41 37.77,79.48 28.08,91.15 27.6,94.14 26.65,100.01 26.43,100.56 25.09,102.1 24.16,102.57 23.07,102.61 21.54,104.2 20.61,107.15 20.7,110.86 20.7,120.09 20.52,131.58 22.4,134.99 23.76,136.22 26.11,138.73 28.78,139.45 28.78,139.45 30.37,140.2 33.48,140.55 34.02,141.01 44.54,152.67 51.22,154.12 53.35,154.66 57.09,154.8 61.76,154.68 63.03,153.94 63.73,153.94 63.85,153.81 v1(63.85,153.45)
  BOTTOM w0.127: v1(44.96,63.61) 45.45,64.09 47.15,64.09 C20.2
P2E_CPU_NIC1_NODE1_TX_DP: length 138.1
  TOP w0.127: U35.24 61.7,154.67 61.8,154.58 62.82,154.58 63.15,154.25 63.38,154.25 v1(63.85,154.72)
  IN3 w0.127: v1(44.96,64.88) 45.45,64.39 45.77,64.39 46,64.57 46.04,65.11 45.93,65.44 45.33,65.73 44.4,65.97 42.19,67.1 40.8,69.28 37.51,79.34 27.81,91.02 27.31,94.1 26.36,99.93 26.18,100.4 24.9,101.87 24.08,102.28 22.94,102.33 21.28,104.05 20.32,107.11 20.41,110.87 20.41,120.09 20.23,131.65 22.17,135.17 23.56,136.43 25.95,138.99 28.67,139.72 30.29,140.49 33.36,140.84 33.82,141.22 44.39,152.94 51.16,154.4 53.31,154.95 57.09,155.09 61.84,154.97 63.11,154.23 63.73,154.23 63.85,154.36 v1(63.85,154.72)
  BOTTOM w0.127: v1(44.96,64.88) 45.45,64.39 47.15,64.39 C19.2
P2E_CPU_NIC2_NODE1_RX_DN: length 222.4
  TOP w0.127: v1(45.13,69.11) 45.13,69.24 45.31,69.42 45.82,69.42 46.2,69.15 46.38,68.91 46.64,68.57 47.22,67.83 48.32,66.98 49.04,66.98 51.05,67.31 51.66,67.31 53.6,67.31 53.83,67.08 54.32,67.08 U2.BD4 ; v1(161.58,156.48) 162.08,155.98 162.38,155.98 C436.1
  IN3 w0.127: v1(161.58,156.48) 162.07,155.99 162.59,155.99 164.39,155.73 164.88,155.76 165.89,155.89 166.41,155.71 166.87,155.01 166.85,154.45 166.98,154.01 167.39,153.58 168.26,152.64 169.78,148.35 169.88,147.17 169.25,143.42 169.11,138.96 168.61,137.94 166.87,137 164.42,134.43 160.79,132.07 158.37,130.87 156.82,130.75 153.95,130.2 152.79,128.93 151.26,128.14 149.35,128.14 148.91,128.13 143.33,128.74 142.92,128.8 142.91,128.8 140.77,128.72 139.89,127.93 139.62,126.54 139.9,124.1 139.93,122.13 137.97,119.76 137.82,119.3 137.7,117.26 134.93,111.62 133.77,109.52 133.64,109.21 131.32,107.8 126.74,107.47 121.18,107.42 119.18,106.89 117.58,106.92 115.53,106.79 113.42,107.22 113.16,107.3 112.24,107.54 111.96,107.54 111.29,107.65 108.14,107.85 106.07,107.98 101.33,109.7 97.64,109.7 95.41,110.1 94.16,111.7 90.58,113.64 84.96,114.37 80.25,113.88 78.15,114.04 74.54,112.73 68.86,113.49 63.06,112.93 62.39,113.04 61.62,113.51 60.95,115.12 59.81,116.22 57.87,116.47 55.93,116.22 55.24,115.52 54.34,113.48 54.22,111.77 54.08,109.69 52.75,106.66 51.61,100.27 47.89,96.07 45.52,86.55 45.39,83.96 45.32,75.7 45.57,74.89 45.77,74.25 45.85,73.95 46.53,71.56 46.43,70.13 45.9,69.6 45.26,69.6 45.13,69.47 v1(45.13,69.11)
P2E_CPU_NIC2_NODE1_RX_DP: length 222.4
  TOP w0.127: U2.BD2 54.25,67.38 53.96,67.38 53.73,67.61 52.35,67.61 52,67.61 51.87,67.75 51.49,67.75 51.35,67.61 51.03,67.61 50.85,67.58 50.7,67.69 50.33,67.63 50.22,67.48 49.84,67.42 49.7,67.53 49.32,67.47 49.21,67.32 49.02,67.29 48.43,67.29 48.26,67.41 48.23,67.6 47.93,67.83 47.74,67.81 47.44,68.04 46.96,68.66 46.99,68.87 46.76,69.18 46.54,69.2 46.41,69.37 45.92,69.72 45.35,69.72 45.13,69.94 v1(45.13,70.38) ; v1(161.58,155.21) 162.05,155.68 162.4,155.68 C435.1
  IN3 w0.127: v1(45.13,70.38) 45.13,70.02 45.26,69.89 45.78,69.89 46.14,70.26 46.24,71.53 46.15,71.84 45.99,71.93 45.89,72.3 45.97,72.45 45.87,72.82 45.71,72.91 45.61,73.27 45.69,73.43 45.49,74.16 45.31,74.26 45.19,74.62 45.29,74.8 45.03,75.65 45.1,83.97 45.23,86.6 47.63,96.21 51.33,100.41 52.47,106.74 53.79,109.76 53.93,111.79 54.05,113.5 54.07,113.6 55,115.69 55.79,116.49 57.87,116.77 59.95,116.49 61.19,115.29 61.86,113.71 62.49,113.32 63.07,113.23 63.42,113.26 63.53,113.4 63.91,113.44 64.06,113.32 64.44,113.36 64.55,113.5 64.93,113.54 65.07,113.42 65.45,113.46 65.57,113.6 65.95,113.64 66.09,113.52 66.47,113.56 66.59,113.7 66.97,113.74 67.11,113.62 67.49,113.66 67.61,113.8 67.99,113.84 68.13,113.72 68.87,113.79 74.5,113.03 78.11,114.34 80.25,114.17 84.96,114.67 90.68,113.92 94.35,111.93 95.57,110.36 97.66,109.99 101.38,109.99 106.13,108.27 108.16,108.14 111.32,107.94 111.98,107.83 112.28,107.83 113.49,107.51 115.55,107.09 117.58,107.22 119.15,107.19 121.14,107.71 126.73,107.76 131.23,108.08 133.41,109.41 133.51,109.64 134.67,111.76 137.41,117.34 137.53,119.35 137.71,119.91 139.64,122.23 139.61,124.08 139.33,126.55 139.62,128.08 140.65,129.01 142.96,129.09 142.96,129.09 143.37,129.03 146.82,128.66 146.98,128.79 147.36,128.75 147.49,128.58 147.87,128.54 148.04,128.67 148.41,128.63 148.55,128.47 148.93,128.42 149.35,128.44 151.19,128.44 152.61,129.17 153.81,130.47 156.78,131.04 158.29,131.16 160.65,132.32 164.23,134.66 166.69,137.23 168.39,138.15 168.82,139.04 168.96,143.45 169.58,147.18 169.49,148.29 168,152.48 167.17,153.38 166.72,153.86 166.55,154.41 166.58,154.93 166.22,155.47 165.86,155.59 164.9,155.47 164.38,155.43 162.57,155.7 162.07,155.7 v1(161.58,155.21)
P2E_CPU_NIC2_NODE1_TX_C_DN: length 11.8
  TOP w0.127: U2.BD8 v1(58.16,66.71)
  BOTTOM w0.127: v1(58.16,66.71) 58.16,67.15 58.02,67.28 57.74,67.28 57.63,67.18 55.06,67.18 54.69,66.81 54.05,66.81 53.91,66.67 53.52,66.67 53.38,66.81 v4(52.89,66.81) 48.66,66.81 C18.1
P2E_CPU_NIC2_NODE1_TX_C_DP: length 11.9
  TOP w0.127: U2.BD10 58.39,67.56 58.67,67.56 58.8,67.43 v1(58.8,67.27)
  BOTTOM w0.127: v1(58.8,67.27) 58.46,67.27 58.15,67.59 57.61,67.59 57.51,67.48 v4(56.53,67.48) 54.93,67.48 54.56,67.12 48.74,67.12 C17.1
P2E_CPU_NIC2_NODE1_TX_DN: length 212.2
  TOP w0.127: v1(165.02,154.34) 165.55,153.82 167.72,153.82 167.83,153.71 167.99,153.71 168.13,153.85 U37.23
  IN3 w0.127: v1(43.52,72.06) 44.01,72.55 44.01,72.56 43.8,73.95 43.6,75.87 43.75,77.19 43.6,86.17 45.29,95.83 45.98,97.75 50.25,102.19 50.69,112.51 51.7,113.7 51.78,113.8 51.88,113.92 51.99,114.01 52.1,114.11 52.3,114.28 53.93,116.51 54.96,117.48 58.04,117.91 60.66,117.58 62.59,115.74 64.89,114.8 68.85,114.97 74.18,114.15 77.6,115.32 80,115.16 84.99,115.84 90.98,114.93 94.48,113.23 95.66,111.85 97.93,111.15 97.93,111.14 97.94,111.14 98.35,111.13 102.51,111.18 107.19,110.5 108.88,110.56 110.97,109.84 113.05,109.26 120.67,109.41 127.17,109.12 129.62,109.34 129.67,109.34 131.19,109.68 132.66,110.61 134.44,113.63 136.03,116.8 136.39,117.8 136.49,118.83 136.53,119.47 136.87,120.97 138.46,122.46 138.14,127.83 138.9,129.42 141.36,131.27 142.69,131.72 145.8,131.46 150.31,132.04 155.08,132.09 157.52,132.11 157.64,132.11 157.64,132.11 159.37,132.91 163.58,137.77 167.26,139.66 167.71,140.3 167.91,144.11 167.71,146.91 166.8,147.99 166.52,149.01 166.56,150.2 166.45,151.13 166.35,151.27 166.21,151.48 164.24,152.07 163.9,152.64 163.87,153.43 164.28,153.85 164.53,153.85 v1(165.02,154.34)
  BOTTOM w0.127: v1(43.52,72.06) 43.67,72.06 43.85,71.88 43.85,68.34 45.34,66.85 47.06,66.85 C18.2
P2E_CPU_NIC2_NODE1_TX_DP: length 212.2
  TOP w0.127: v1(165.02,153.07) 165.46,153.51 167.59,153.51 167.7,153.4 168.02,153.4 168.07,153.35 U37.24
  IN3 w0.127: v1(165.02,153.07) 164.53,153.56 164.4,153.56 164.17,153.31 164.19,152.73 164.44,152.32 164.98,152.15 165.15,152.24 165.51,152.13 165.6,151.97 166.39,151.73 166.59,151.44 166.73,151.23 166.85,150.21 166.81,149.04 167.07,148.13 167.26,147.91 167.45,147.89 167.7,147.6 167.68,147.4 168,147.03 168.04,146.52 168.18,146.39 168.2,146.01 168.08,145.87 168.11,145.49 168.25,145.37 168.28,144.99 168.15,144.85 168.21,144.11 168,140.2 167.45,139.43 163.77,137.53 159.55,132.67 157.71,131.82 157.64,131.82 155.08,131.79 150.33,131.74 145.81,131.17 142.72,131.42 141.5,131.01 139.13,129.23 138.44,127.77 138.76,122.35 137.13,120.82 136.82,119.43 136.78,118.81 136.68,117.74 136.3,116.69 134.7,113.49 132.88,110.4 131.3,109.4 129.7,109.05 129.64,109.05 127.17,108.82 127.15,108.82 120.66,109.11 113.05,108.97 112.97,108.98 110.88,109.56 108.83,110.27 107.17,110.2 102.49,110.89 98.34,110.83 97.93,110.85 97.92,110.85 97.92,110.85 95.5,111.59 94.29,112.99 90.9,114.64 84.98,115.54 80.01,114.87 77.64,115.02 74.2,113.85 68.83,114.67 64.84,114.51 62.43,115.49 60.53,117.3 58.04,117.61 55.09,117.21 54.15,116.32 52.51,114.09 52.29,113.89 52.09,113.72 51.92,113.51 50.98,112.4 50.54,102.07 46.23,97.59 45.57,95.75 43.9,86.14 44.04,77.18 43.89,75.87 44.09,73.99 44.3,72.59 44.3,72.55 v1(44.79,72.06)
  BOTTOM w0.127: C17.2 47.06,67.16 45.46,67.16 44.15,68.47 44.15,69.11 44.28,69.24 44.28,69.62 44.15,69.75 44.15,70.13 44.28,70.26 44.28,70.64 44.15,70.77 44.15,71.88 44.33,72.06 v1(44.79,72.06)
P2E_CPU_PCIE_SW_NODE1_RX_C_DN: length 5.9
  TOP w0.127: U125.74 137.11,146.18 137.06,146.22 136.8,146.22 135.94,145.37 135.94,144.71 135.54,144.3 135.13,144.3 134.93,144.1 v1(134.93,143.81)
  BOTTOM w0.127: C186.1 134.19,144.3 134.44,144.3 v1(134.93,143.81)
P2E_CPU_PCIE_SW_NODE1_RX_C_DP: length 5.9
  TOP w0.127: U125.73 137.11,146.58 137.06,146.53 136.67,146.53 135.64,145.5 135.64,144.84 135.41,144.61 135.13,144.61 134.93,144.81 v1(134.93,145.08)
  BOTTOM w0.127: v1(134.93,145.08) 134.44,144.6 134.19,144.6 C185.1
P2E_CPU_PCIE_SW_NODE1_RX_DN: length 156
  TOP w0.127: U2.AY5 55.89,69.3 v1(56.25,68.94)
  BOTTOM w0.102: v1(56.25,68.94) 55.94,69.26 55.94,69.36 55.94,69.7 56.11,69.88 56.11,70.49 55.88,70.73 55.41,70.73 55.36,70.78 55.33,70.78
  BOTTOM w0.127: C186.2 133.03,143.94 132.7,144.27 132.7,144.27 132.68,144.29 130.3,144.29 127.93,144.04 118.48,144.47 111.04,145.31 106.79,143.99 106.13,143.1 106.17,142.85 105.94,142.55 105.7,142.51 104.18,140.46 104.24,132.63 104.63,121.7 104.64,121.4 103.69,118.86 103.65,114.01 103.09,111.03 101.6,109.93 98.68,109.52 96.43,109.54 95.62,109.34 95.13,108.44 93.95,106.76 91.89,105.47 89.68,103.66 83.76,103.78 83.46,103.78 80.78,103.76 v4(79.32,103.76) 78.41,103.76 77.05,102.57 76.42,102.24 75.3,102.26 71.73,102.26 68.47,103.26 62.65,103.26 60.98,103.01 60.84,103.01 57.27,101.81 52.17,101.23 50.18,99.49 47.9,97.16 47.06,94.49 47.9,84.6 48,77.57 48.07,77.34 48.23,77.24 48.33,76.87 48.24,76.7 48.33,76.33 48.5,76.24 48.6,75.87 48.5,75.7 48.65,75.14 48.85,74.81 49.03,74.77 49.22,74.44 49.18,74.25 49.37,73.93 49.56,73.88 49.75,73.55 49.7,73.37 49.97,72.93 50.77,72.11 52.2,71.37 52.73,71.25 53.91,71.25 55,70.78 55.33,70.78
P2E_CPU_PCIE_SW_NODE1_RX_DP: length 156
  TOP w0.127: v1(55.42,68.95) 55.77,68.6 U2.BB5
  BOTTOM w0.102: v1(55.42,68.95) 55.74,69.26 55.74,69.36 55.74,69.79 55.91,69.96 55.91,70.41 55.79,70.53 55.41,70.53 55.36,70.48 55.33,70.48
  BOTTOM w0.127: 55.33,70.48 54.93,70.48 53.84,70.95 52.69,70.95 52.17,71.06 52.13,71.06 50.59,71.87 49.72,72.74 48.37,75.02 47.7,77.53 47.6,84.59 46.76,94.53 47.63,97.32 49.97,99.71 52.04,101.52 57.2,102.11 60.79,103.32 60.96,103.32 62.63,103.57 68.52,103.57 71.78,102.56 75.3,102.56 76.35,102.55 76.87,102.83 78.3,104.06 80.78,104.06 83.46,104.08 83.76,104.08 89.58,103.97 91.71,105.71 93.73,106.98 94.87,108.6 95.42,109.61 96.39,109.85 98.66,109.82 101.48,110.23 102.81,111.21 103.34,114.04 103.39,118.91 104.35,121.5 104.32,121.69 103.93,132.62 103.88,140.56 106.61,144.25 111.01,145.62 118.51,144.78 127.93,144.34 130.28,144.6 v4(130.87,144.6) 132.68,144.6 133.03,144.96 C185.2
P2E_CPU_PCIE_SW_NODE1_TX_C_DN: length 8
  TOP w0.102: v5(57.45,69.73) 57.81,69.37 U2.AY9
  BOTTOM w0.102: v5(57.45,69.73) 57.6,69.73 57.75,69.58 57.75,69.39 57.61,69.25 57.14,69.25 56.41,68.53 55.26,68.53 55.24,68.51 55.15,68.51 55.14,68.52
  BOTTOM w0.127: 55.14,68.52 55.02,68.64 v4(54.67,68.64) 54.02,68.64 53.85,68.81 53.56,68.81 53.39,68.64 51.88,68.64 51.78,68.75 51.76,68.75 C16.1
P2E_CPU_PCIE_SW_NODE1_TX_C_DP: length 8.1
  TOP w0.102: U2.AY11 58.58,69.37 v5(58.21,69.73)
  BOTTOM w0.102: v5(58.21,69.73) 57.95,69.47 57.95,69.31 57.69,69.05 57.22,69.05 56.5,68.32 55.34,68.32 55.33,68.31 55.31,68.31 55.23,68.31 55.05,68.31 54.96,68.31 54.95,68.3 54.93,68.3 54.92,68.31
  BOTTOM w0.127: C15.1 51.95,68.34 v4(52.65,68.34) 54.89,68.34 54.92,68.31
P2E_CPU_PCIE_SW_NODE1_TX_DN: length 164.4
  TOP w0.127: v1(136.68,149.13) 136.17,149.13 135.94,148.9 135.94,148.6 136.42,148.13 137.04,148.13 137.09,148.18 U125.69
  BOTTOM w0.127: v1(136.68,149.13) 136.2,148.65 136.2,148.12 135.09,147.32 131.52,146.27 122.35,146.14 116.59,146.94 109,146.57 104.66,144.84 102.17,139.6 102.14,135.81 103.08,127.6 103.24,126.34 103.09,124.64 103.2,123.07 103.18,122.76 103.14,122.19 101.4,115.05 100.43,111.66 98.98,110.88 96.56,110.76 94.4,111.1 92.97,110.69 92.33,109.88 91.39,107.57 89.84,105.85 88.52,105.08 82.99,105.08 76.42,105.05 74.58,104.49 73.82,104.47 73.68,104.47 72.59,104.47 64.54,104.61 64.54,104.61 55.43,104.31 55.41,104.31 53.56,103.98 53.33,103.94 52.45,103.55 49.9,101.02 45.9,97.02 45.52,95.78 45.63,95.58 45.52,95.21 45.32,95.11 45.21,94.74 45.01,94.08 44.6,92.71 44.35,77.4 45.47,75.28 45.63,74.47 45.8,74.35 45.88,73.98 45.76,73.81 45.84,73.43 46.01,73.32 46.08,72.95 45.97,72.78 46.05,72.4 46.22,72.29 46.29,71.91 46.18,71.74 46.42,70.52 46.96,69.93 48.25,69.72 49.25,68.71 49.59,68.52 50.31,68.54 C16.2
P2E_CPU_PCIE_SW_NODE1_TX_DP: length 164.3
  TOP w0.127: v1(135.41,149.13) 135.64,148.9 135.64,148.48 136.29,147.82 137.03,147.82 137.08,147.78 U125.70
  BOTTOM w0.127: C15.2 50.35,68.24 49.51,68.21 49.07,68.47 48.1,69.43 46.8,69.64 46.14,70.37 45.19,75.12 45.19,75.12 45.18,75.17 44.04,77.33 44.29,92.76 45.03,95.2 45.03,95.2 45.63,97.18 49.69,101.24 52.27,103.8 53.24,104.23 53.51,104.28 55.37,104.61 55.41,104.62 64.84,104.93 64.84,104.91 72.59,104.77 73.68,104.77 73.81,104.78 74.53,104.79 76.38,105.35 82.99,105.38 88.43,105.38 89.64,106.09 91.12,107.74 92.06,110.03 92.73,110.88 92.88,110.98 94.38,111.41 96.58,111.07 98.9,111.18 100.18,111.87 101.1,115.13 102.84,122.24 102.88,122.78 102.89,123.06 102.78,124.64 102.94,126.34 102.78,127.56 101.83,135.79 101.86,139.67 104.43,145.08 108.93,146.88 116.6,147.25 122.37,146.44 131.48,146.58 134.96,147.6 135.89,148.28 135.89,148.65 v1(135.41,149.13)
P2E_CPU_SATA_NODE1_RX_C_DN: length 5.6
  TOP w0.127: U30.39 160.76,69.47 160.72,69.64 160.72,70.46 162.34,72.08 v4(162.34,72.39) 162.34,73.2 C332.2
P2E_CPU_SATA_NODE1_RX_C_DP: length 5.6
  TOP w0.127: C333.2 162.04,73.16 162.04,72.21 160.41,70.58 v4(160.41,70.21) 160.41,69.64 160.36,69.51 U30.40
P2E_CPU_SATA_NODE1_RX_DN: length 162.3
  TOP w0.102: U2.BM9 57.93,63.43 57.93,63.25 57.55,62.87 57.55,62.32 57.5,62.32 57.5,62.29
  TOP w0.127: 57.5,62.29 57.5,61.02 57.23,60.75 57.03,60.75 56.85,60.56 56.85,60.37 56.52,60.04 56.12,60.04 55.95,60.21 55.65,60.21 55.49,60.04 55.28,60.04 52.49,60.39 52.48,60.39 52.36,60.43 50.48,61.95 49.97,62.59 49,62.59 v1(48.71,62.88) ; C332.1 162.32,74.7 162.32,76.99 v1(162.81,77.48)
  BOTTOM w0.127: v1(48.71,62.88) 48.42,62.59 47.99,62.59 47.4,62.22 47.38,61.14 51.89,47.23 57.99,39.48 63.36,37.12 65.56,36.99 66.49,36.99 70.51,37.69 70.53,37.69 83.74,41.08 83.75,41.08 101.29,42.13 105.98,42.41 121.51,53.27 122.26,53.79 128.61,55.15 133.03,58.28 134.58,60.98 142.72,68.24 145.1,71.42 146.46,72.67 147.91,73.58 147.94,73.6 152.56,74.51 155.62,74.78 157.46,75.7 157.6,75.7 157.6,75.7 158.25,75.83 161.55,75.83 162.29,76.57 162.29,76.96 v1(162.81,77.48)
P2E_CPU_SATA_NODE1_RX_DP: length 162.2
  TOP w0.102: U2.BN10 58.13,63.16 57.76,62.79 57.76,62.35 57.81,62.3 57.81,62.29
  TOP w0.127: v1(161.54,77.48) 162.01,77.01 162.01,74.68 C333.1 ; 57.81,62.29 57.81,60.9 56.65,59.74 55.26,59.74 52.38,60.1 52.38,60.1 52.37,60.1 52.26,60.15 52.21,60.16 50.26,61.74 49.83,62.28 49,62.28 v1(48.71,61.99)
  BOTTOM w0.127: v1(48.71,61.99) 48.42,62.28 48.08,62.28 47.71,62.05 47.68,61.18 47.81,60.8 47.97,60.71 48.09,60.35 48,60.19 48.12,59.83 48.28,59.75 48.4,59.38 48.32,59.22 48.44,58.86 48.6,58.78 48.72,58.41 48.63,58.25 48.75,57.89 48.91,57.81 49.03,57.44 48.95,57.28 49.07,56.92 49.23,56.84 49.34,56.48 49.26,56.32 49.38,55.95 49.54,55.87 49.66,55.51 49.58,55.35 52.16,47.37 58.18,39.73 58.68,39.51 58.86,39.58 59.21,39.43 59.28,39.25 59.63,39.09 59.81,39.16 60.16,39.01 60.23,38.83 60.57,38.68 60.75,38.75 61.1,38.6 61.17,38.42 61.52,38.26 61.7,38.33 62.05,38.18 62.12,38 63.43,37.42 65.57,37.3 66.47,37.3 70.48,37.99 70.49,37.99 83.7,41.38 83.74,41.38 101.27,42.43 105.87,42.71 121.34,53.52 122.13,54.08 128.48,55.44 132.8,58.49 134.34,61.18 142.5,68.44 144.88,71.62 146.27,72.91 147.76,73.85 147.85,73.89 152.52,74.81 155.53,75.08 157.39,76.01 157.6,76.01 157.6,76.01 158.22,76.13 158.5,76.13 158.63,76.26 159.01,76.26 159.14,76.13 159.52,76.13 159.65,76.26 160.03,76.26 160.15,76.13 160.54,76.13 160.66,76.26 161.05,76.26 161.17,76.13 161.43,76.13 161.99,76.69 161.99,77.03 v1(161.54,77.48)
P2E_CPU_SATA_NODE1_TX_C_DN: length 12.1
  TOP w0.127: U2.BB19 63.01,68.5 v1(63.22,68.3)
  BOTTOM w0.127: v1(63.22,68.3) 62.99,68.07 62.51,68.07 62.09,67.65 v4(62.09,67.32) 62.09,65.34 59.2,62.45 57.71,62.45 57.03,61.77 57.03,61.23 C22.1
P2E_CPU_SATA_NODE1_TX_C_DP: length 12
  TOP w0.127: U2.BD19 63.04,67.74 v1(63.22,67.56)
  BOTTOM w0.127: v1(63.22,67.56) 63.02,67.76 62.64,67.76 62.39,67.52 62.39,67.27 62.53,67.13 62.53,66.75 62.39,66.62 62.39,65.22 62.16,64.98 62.16,64.89 62.16,64.89 62.16,64.8 61.89,64.53 61.8,64.53 61.8,64.53 61.7,64.53 v4(61.27,64.09) 60.88,63.71 60.88,63.61 60.88,63.61 60.88,63.52 60.61,63.25 60.52,63.25 60.42,63.25 60.15,62.98 60.15,62.88 60.15,62.88 60.15,62.79 59.88,62.52 59.79,62.52 59.69,62.52 59.32,62.15 57.83,62.15 57.33,61.65 57.33,61.17 C21.1
P2E_CPU_SATA_NODE1_TX_DN: length 146.1
  TOP w0.127: U30.43 159.16,69.45 159.11,69.58 159.11,70.22 159.28,70.39 159.28,78.62 v1(159.77,79.11)
  BOTTOM w0.127: C22.2 56.97,59.72 56.97,59.52 56.85,59.4 56.77,59.32 56.02,58.81 55.67,58.19 56.06,46.98 58.04,42.34 59.65,40.77 64.77,38.57 65.91,38.51 66.06,38.52 70.86,39.02 70.86,39.04 83.53,42.29 83.56,42.29 101.29,43.35 105.56,43.61 121.46,54.72 121.76,54.94 127.96,56.27 131.2,58.55 134.09,62.34 142.41,70.46 143.87,73.24 146.46,75.36 148.55,75.87 151.34,76.48 151.44,76.5 155.39,77.58 158.9,77.58 159.5,78.19 159.5,78.84 v1(159.77,79.11)
P2E_CPU_SATA_NODE1_TX_DP: length 146.1
  TOP w0.127: v1(158.5,79.11) 158.98,78.63 158.98,70.52 158.8,70.35 158.8,69.58 158.76,69.45 U30.44
  BOTTOM w0.127: C21.2 57.27,59.66 57.27,59.39 57.06,59.18 56.96,59.08 56.25,58.6 55.98,58.11 56.36,47.05 58.3,42.52 59.82,41.03 60.34,40.81 60.51,40.88 60.86,40.73 60.94,40.55 61.29,40.4 61.46,40.47 61.81,40.32 61.88,40.14 62.24,39.99 62.41,40.06 62.76,39.91 62.83,39.74 63.18,39.58 63.36,39.66 63.71,39.51 63.78,39.33 64.84,38.87 65.9,38.81 70.69,39.31 83.5,42.6 83.55,42.6 101.27,43.66 105.45,43.91 120.64,54.52 121.63,55.22 127.84,56.55 130.99,58.77 133.87,62.54 142.16,70.65 143.62,73.44 146.32,75.64 148.49,76.17 151.28,76.78 151.36,76.8 155.34,77.89 157.16,77.89 157.3,78.03 157.68,78.03 157.82,77.89 158.77,77.89 159.2,78.31 159.2,78.87 158.96,79.11 v1(158.5,79.11)
P2E_CPU_USB_NODE1_RX_C_DN: length 5.5
  TOP w0.127: U32.8 174.54,101.34 174.5,101.38 v4(173.97,101.38) 170.3,101.38 C364.2
P2E_CPU_USB_NODE1_RX_C_DP: length 5.6
  TOP w0.127: C363.2 170.45,101.69 v4(170.99,101.69) 174.5,101.69 174.54,101.74 U32.7
P2E_CPU_USB_NODE1_RX_DN: length 54.1
  TOP w0.127: v1(142.7,130) 142.99,130 143.18,130.19 143.18,131.46 141.84,132.8 141.84,134.62 141.77,134.69 U125.103 ; C364.1 168.86,101.46 168.14,101.46 v1(167.64,100.96)
  BOTTOM w0.127: v1(167.64,100.96) 167.16,101.44 165.84,101.44 163.72,103.57 163.02,107.89 163.02,116.07 160.75,121.49 157.03,125.21 154.12,125.21 151.2,128.13 147.06,128.13 146.67,128.51 143.77,128.51 143.18,129.11 143.18,129.82 143,130 v1(142.7,130)
P2E_CPU_USB_NODE1_RX_DP: length 54.1
  TOP w0.127: v1(143.97,130) 143.61,130 143.49,130.13 143.49,131.59 142.14,132.93 142.14,134.67 142.17,134.69 U125.104 ; v1(167.64,102.23) 168.11,101.77 168.86,101.77 C363.1
  BOTTOM w0.127: v1(167.64,102.23) 167.16,101.75 165.97,101.75 164,103.71 163.32,107.91 163.32,116.13 161.01,121.66 157.15,125.52 154.24,125.52 151.33,128.43 150.35,128.43 150.22,128.57 149.83,128.57 149.7,128.43 149.32,128.43 149.19,128.57 148.81,128.57 148.68,128.43 148.3,128.43 148.16,128.57 147.78,128.57 147.65,128.43 147.18,128.43 146.8,128.82 145.67,128.82 145.53,128.95 145.15,128.95 145.02,128.82 143.9,128.82 143.49,129.23 143.49,129.8 143.68,130 v1(143.97,130)
P2E_CPU_USB_NODE1_TX_C_DN: length 6.5
  TOP w0.127: U125.108 143.77,135.1 143.72,135.06 143.72,134.15 v4(144.11,133.77) 144.57,133.31 145.16,133.31 146.16,132.31 146.16,131.74 146.16,131.73 146.16,131.62 146.16,131.24 C190.1
P2E_CPU_USB_NODE1_TX_C_DP: length 6.5
  TOP w0.127: U125.107 143.37,135.08 143.42,135.04 143.42,134.03 144.44,133 145.04,133 v4(145.4,132.63) 145.86,132.18 145.86,131.74 145.86,131.73 145.86,131.24 145.5,130.89 C189.1
P2E_CPU_USB_NODE1_TX_DN: length 58.3
  TOP w0.127: v1(150.3,130.88) 150.3,130.46 150.16,130.31 149.45,130.31 148.95,129.81 148.75,129.81 148.48,129.54 148.48,129.34 148.21,129.07 147.57,129.07 147.44,129.19 147.06,129.19 146.93,129.07 146.48,129.07 146.16,129.39 146.16,129.73 C190.2 ; v1(166.74,98.69) 167.22,99.18 169.98,99.18 172.34,100.14 174.39,100.14 174.43,100.18 174.78,100.18 174.83,100.14 U32.11
  BOTTOM w0.127: v1(150.3,130.88) 150.3,130.61 150.51,130.4 151.47,130.4 155.07,126.79 158.05,126.79 162.24,122.61 164.84,116.16 164.84,111.8 164.86,111.11 166.1,105.65 169.12,102.64 169.12,100.13 168.17,99.18 167.22,99.18 v1(166.74,98.69)
P2E_CPU_USB_NODE1_TX_DP: length 58.3
  TOP w0.127: C189.2 145.5,130.09 145.86,129.73 145.86,129.26 146.36,128.76 148.33,128.76 149.58,130.01 150.13,130.01 150.3,129.84 v1(150.3,129.61) ; v1(166.74,99.96) 167.22,99.48 169.92,99.48 172.28,100.45 174.26,100.45 174.3,100.49 174.75,100.49 174.79,100.54 U32.10
  BOTTOM w0.127: v1(150.3,129.61) 150.3,129.91 150.49,130.09 151.34,130.09 151.88,129.55 151.88,129.46 151.88,129.46 151.88,129.37 152.15,129.1 152.24,129.1 152.33,129.1 152.6,128.83 152.6,128.74 152.6,128.65 152.87,128.38 152.96,128.38 153.05,128.38 153.32,128.11 153.32,128.02 153.32,128.02 153.32,127.93 153.59,127.66 153.68,127.66 153.68,127.66 153.77,127.66 154.04,127.39 154.04,127.3 154.04,127.3 154.04,127.21 154.31,126.94 154.4,126.94 154.49,126.94 154.94,126.49 157.92,126.49 161.98,122.43 164.54,116.1 164.54,115.64 164.4,115.51 164.4,115.13 164.54,115 164.54,114.62 164.4,114.49 164.4,114.1 164.54,113.97 164.54,113.59 164.4,113.46 164.4,113.08 164.54,112.95 164.54,111.79 164.56,111.07 165.83,105.5 166.49,104.84 166.49,104.75 166.49,104.66 166.76,104.39 166.94,104.39 167.21,104.12 167.21,104.03 167.21,103.94 167.48,103.67 167.66,103.67 168.82,102.51 168.82,100.26 168.04,99.48 167.22,99.48 v1(166.74,99.96)
PCA9535_INT_N: length 71.3
  TOP w0.102: U61.6 126.23,163.66 125.82,164.07 125.82,164.44 125.4,164.86 125.4,165.17 v1(124.99,165.58) 124.91,165.51 R677.2
  IN3 w0.114: v1(124.99,165.58) 123.16,165.58 122.87,165.29 122.02,165.29 121.82,165.09 117.06,165.09 116.77,165.38 116.22,165.38 115.92,165.07 109.57,165.07 107,162.5 103.03,162.5 102.9,162.63 99.74,162.63 99.18,162.07 99.18,161.77 98.77,161.36 94.18,161.36 92.47,163.08 92.47,163.27 92.21,163.52 91.76,163.52 91.26,164.02 86.82,164.02 82.73,168.1 78.68,168.1 78.11,168.67 78.11,169.03 78.11,169.03 78.11,172.75 v1(72.01,178.86)
  BOTTOM w0.102: U63.1 71.54,179.89 72.01,179.42 v1(72.01,178.86)
PCA_CPLD_WDT2: length 11.3
  BOTTOM w0.102: U65.14 114.14,179.49 111.97,181.67 v2(111.55,181.67) R755.2 110.45,182.16 110.08,182.53 106.1,182.53 105.74,182.89 R1196.1
PCH_I2C_ALERT_N: length 133.5
  TOP w0.102: v1(165.66,140.98) 165.15,140.98 164.54,141.59 R591.1 ; R561.1 v1(63.06,167.57)
  IN1 w0.114: v1(63.06,167.57) 63.57,167.57 63.64,167.51 71.46,167.51 71.88,167.92 78.94,167.92 79.13,168.11 84.35,168.11 86.18,166.28 86.81,166.28 88.72,164.37 93.31,164.37 93.99,163.69 97.32,163.69 97.34,163.72 97.87,163.72 98.38,164.22 99.64,164.22 100.75,165.34 103.59,165.34 104.14,164.79 104.5,164.79 104.83,165.12 104.83,165.14 105.29,165.6 107.76,165.6 108.28,166.12 111,166.12 112.47,167.59 113.04,167.59 113.35,167.27 116.86,167.27 117.24,167.65 123.59,167.65 125.04,166.21 128.23,166.21 128.72,166.7 130.4,166.7 130.82,167.12 131.21,167.12 132.47,165.85 132.47,163.02 133.56,161.94 137.3,161.94 137.93,162.57 140.69,162.57 142.03,163.91 146.83,163.91 147.6,163.14 152.3,163.14 152.97,162.47 154.59,162.47 155.52,161.54 158.82,161.54 164.4,155.96 164.4,152.82 165.34,151.88 165.34,145.73 165.79,145.27 165.79,143.81 166,143.61 166,141.5 165.76,141.26 165.76,141.09 v1(165.66,140.98)
PCI_STP_NODE1: length 3.7
  TOP w0.102: v1(145.54,122.94) 145.54,122.71 145.06,122.23 145.06,121.75 145.19,121.62 U1.35
  BOTTOM w0.102: v1(145.54,122.94) 146.21,122.94 146.31,122.84 147.04,122.84 R5.2
PCIE_LAN1_RX_C_DN: length 5.3
  TOP w0.127: C392.2 65.58,152.03 63.42,152.03 62.68,152.77 v4(62.38,152.77) 61.89,152.77 61.79,152.67 U35.20
PCIE_LAN1_RX_C_DP: length 5.3
  TOP w0.127: C391.2 65.67,152.33 v4(64.97,152.33) 63.55,152.33 62.81,153.08 61.89,153.08 61.79,153.17 U35.21
PCIE_LAN2_RX_C_DN: length 5.5
  TOP w0.127: C436.2 163.9,155.99 166.04,155.99 166.79,155.25 v4(167.17,155.25) 167.76,155.25 167.86,155.35 U37.20
PCIE_LAN2_RX_C_DP: length 5.5
  TOP w0.127: U37.21 167.86,154.85 167.76,154.94 166.66,154.94 165.92,155.69 v4(164.61,155.69) 163.9,155.69 C435.2
PCIE_SW_EEPROM_CLK: length 17.2
  TOP w0.102: R301.1 159.96,151.38 160.51,151.92 160.51,153.7 160.23,153.98 U13.6 v1(157.85,153.98) ; U125.40 148.97,152.08 149.33,152.44 v1(149.33,152.66)
  BOTTOM w0.102: v1(157.85,153.98) 157.73,153.86 155.72,153.86 155.5,154.09 150.13,154.09 149.33,153.29 v1(149.33,152.66)
PCIE_SW_EEPROM_DAT: length 15.9
  TOP w0.102: U125.41 148.57,152.1 148.89,152.43 v1(148.89,153.15) ; v1(156.54,154.37) 158.2,152.71 U13.5 159.35,151.43 158.95,151.03 R303.1
  BOTTOM w0.102: v1(148.89,153.15) 148.89,153.21 150.02,154.34 156.51,154.34 v1(156.54,154.37)
PCIE_SW_GPIO5: length 3.5
  TOP w0.102: U125.26 154.14,147.38 154.51,147.01 155.11,147.01 v1(155.76,146.35) 155.91,146.21 R308.2
PCIE_SW_GPIO6: length 3.3
  TOP w0.102: R306.2 155.43,147.2 154.85,147.78 v1(154.58,147.78) U125.27
PCIE_SW_GPIO7: length 3.4
  TOP w0.102: R307.2 155.96,148.22 v1(155.64,148.53) 154.51,148.53 154.16,148.18 U125.28
PCIE_SW_I2C_SCL: length 7.3
  TOP w0.102: R309.1 159.07,141.03 v1(158.79,141.31) 158.41,141.69 157.03,141.69 R232.2 156.34,141.2 155.29,142.25 154.31,142.25 154.23,142.18 U125.13
PCIE_SW_I2C_SDA: length 7.3
  TOP w0.102: U125.16 v1(154.57,143.38) 154.62,143.32 155.24,143.32 156.36,142.2 R233.2 156.59,142.2 157.08,142.68 158.36,142.68 158.94,142.1 R310.1
PCIE_SW_P0_CTCDIS: length 4
  TOP w0.102: U125.18 154.13,144.18 154.55,144.6 154.55,145.1 v1(154.68,145.23) 154.69,145.22 R277.2
PCIE_SW_P0_ERR: length 189.4
  TOP w0.102: U2.E55 80.85,86.95 v1(81.21,86.59) ; R234.2 146.81,155.24 R299.2 145.09,155.24 v1(145.08,155.23)
  IN1 w0.114: v1(145.08,155.23) 145.92,155.23 146.03,155.12 153.66,155.12 159.43,149.36 159.43,145.28 159.43,145.28 159.43,141.67 159.49,141.61 159.49,138.27 169.37,128.4 169.37,124.33 170.48,123.21 170.48,113.85 165.04,108.41 165.04,104.54 164.24,103.74 164.24,95.05 v1(159.3,90.1) ; v1(112.55,103.51) 113.68,102.38 119.23,102.38 125.23,96.39 125.23,94.45 134.16,85.51 v1(134.16,84.82)
  IN3 w0.114: v1(85.24,98.97) 88.42,102.15 109.18,102.15 110.49,103.46 112.5,103.46 v1(112.55,103.51) ; v1(159.3,90.1) 142.23,90.1 142.05,89.93 139.28,89.93 v1(134.16,84.82)
  BOTTOM w0.102: v1(85.24,98.97) 85.24,98.53 83.03,96.32 82.44,96.32 81.86,95.74 81.86,93.63 81.55,93.31 81.55,86.93 v1(81.21,86.59)
PCIE_SW_P0_ERR_R: length 3.4
  TOP w0.102: U125.45 146.97,152.82 v1(146.5,153.29) 146.84,153.62 R234.1
PCIE_SW_P1_CTCDIS: length 4.6
  TOP w0.102: R278.2 156.42,151.08 v1(156.35,151.16) 155.07,151.16 153.68,149.78 U125.32
PCIE_SW_P2_CTCDIS: length 3.7
  TOP w0.102: U125.33 v1(151.77,153.58) 151.21,153.58 150.95,153.83 R279.2
PCIE_SW_PRSNT1: length 3.4
  TOP w0.102: R1228.1 153.82,134.19 v1(152.97,135.05) 152.19,135.83 U125.128
PCIE_SW_PRSNT2: length 7.5
  TOP w0.102: U125.7 154.14,139.78 156.04,137.87 158.29,137.87 v1(158.39,137.77) 158.84,137.32 R1229.1
PCIE_SW_PWR_SAV: length 6.5
  TOP w0.102: U125.17 154.24,143.78 154.66,144.2 v1(155.89,144.2) R276.2 156.6,144.15 156.6,144.15 156.71,144.04 156.77,144.04 157.21,143.61 158.74,143.61 159.07,143.94 R275.2
PCIE_SW_RST_N: length 3.2
  TOP w0.102: R231.2 147.83,153.24 v1(147.93,153.13) 147.77,152.97 U125.43
PCIE_SW_SCAN_EN: length 3.5
  TOP w0.102: U125.56 142.57,153.65 v1(142.6,153.68) 142.91,153.99 R297.2
PCIE_SW_SLOTCLK: length 5.8
  TOP w0.102: R305.1 154.54,136.06 v1(154.86,136.37) 154.52,136.71 152.03,136.71 151.98,136.77 151.52,136.77 151.37,136.62 U125.127
PCIE_SW_TEST1: length 3.4
  TOP w0.102: U125.31 154.35,149.38 v1(154.67,149.7) 155.29,149.7 155.78,149.21 R285.2
PCIE_SW_TEST2: length 5.4
  TOP w0.102: R283.2 138.58,150.5 139.17,149.92 v1(139.17,149.49) 139.06,149.38 U125.66
PCIE_SW_TEST3: length 3.9
  TOP w0.102: R286.2 155.99,140.78 v1(155.88,140.78) 155.7,140.78 154.71,141.77 154.31,141.77 154.3,141.78 U125.12
PCIE_SW_TEST4: length 7.7
  TOP w0.102: R284.2 159.24,138.49 v1(158.3,139.43) 158.09,139.63 156.16,139.63 154.42,141.38 U125.11
PCIE_SW_TEST5: length 4.3
  TOP w0.102: U125.10 154.21,140.98 v1(155.87,139.31) 156.55,138.63 R288.2
PCIE_SW_TEST6: length 5.4
  TOP w0.102: R289.2 152.45,133.18 v1(151.71,133.92) 150.97,134.66 U125.126
PCIE_SW_TEST7: length 3.2
  TOP w0.102: U125.38 149.77,153.01 v1(149.92,153.16) 149.81,153.26 R287.2
PCIE_SW_TMS: length 2.4
  TOP w0.102: R296.2 139.17,152.84 v1(139.17,152.63) 139.77,152.03 U125.63
PCIE_SW_TRST: length 3.6
  TOP w0.102: R295.2 v1(137.57,152.51) 137.57,152.03 137.7,151.89 137.7,150.73 137.82,150.62 U125.65
PCIE_SW_WAKE_N: length 4.5
  TOP w0.102: U125.6 154.08,139.38 155.07,138.39 155.07,137.66 v1(155.08,137.65) 155.36,137.37 R263.1
PCIE_SW_WP_N: length 5.7
  TOP w0.102: U13.7 159.96,155.25 160.97,154.23 160.97,153.36 v1(161.08,153.25) 160.97,153.14 R1227.1
PD_BMC_LPC: length 17.7
  TOP w0.102: U14.B21 U14.A22 U14.A21 87.76,127.26 87.99,127.03 89.54,127.03 89.68,127.18 v1(89.68,127.77) 89.37,128.09 87.29,128.09 86.91,128.47 84.95,128.47 84.57,128.84 U14.C19 84.17,128.46 82.47,128.46 82.17,128.75 U14.F19 82.3,128.99 82.3,129.13 82.57,129.4 82.57,130.06 U14.E17
  BOTTOM w0.102: R1230.2 v1(89.68,127.77)
PD_BMC_NODE1_PEREXT: length 4.4
  TOP w0.102: U14.D20 v5(84.17,127.66)
  BOTTOM w0.102: R256.1 85.5,128.99 v5(84.17,127.66)
PD_CPU_NODE1_AJ23: length 3.2
  TOP w0.305: v1(64.43,74.6) U2.AJ23
  BOTTOM w0.381: R42.1 64.36,76.14 63.72,75.49 63.72,75.39 v2(63.51,75.19) 63.79,74.91 64.12,74.91 v1(64.43,74.6)
PD_CPU_NODE1_AL5: length 1.9
  TOP w0.114: v1(56.27,73.48) 56.14,73.6 56.03,73.6 U2.AL5
  BOTTOM w0.102: R38.1 v1(56.27,73.48)
PD_CPU_NODE1_AM23: length 5.3
  TOP w0.305: U2.AM23 64.76,73.4 64.43,73.73 v1(64.43,73.8)
  BOTTOM w0.102: R39.1 v2(60.79,75.62)
  BOTTOM w0.381: v1(64.43,73.8) 64.03,74.2 63.86,74.37 63.09,74.37 62.7,74.76 62.7,74.89 62.29,75.31 R39.1
PD_CPU_NODE1_AN5: length 4.8
  TOP w0.114: U2.AN5 55.83,73.05 56.44,72.44 56.92,72.44 v1(57.45,72.96)
  BOTTOM w0.102: v1(57.45,72.96) 56.96,72.48 R37.1
PD_CPU_NODE1_BOOTDEVSEL: length 12.3
  TOP w0.102: R154.1 R151.1 85.47,92.86 v3(85.18,92.57) 84.24,91.63 81.72,91.63 80.78,90.69 80.3,90.69 79.98,90.38 79.98,89.08 79.99,89.07 79.99,88.41 79.72,88.15 79.69,88.15 79.27,87.73 79.27,87.46 79.45,87.28 U2.E52
PD_CPU_NODE1_BRD_ID1: length 15.6
  TOP w0.102: v1(76.78,83.11) 76.41,83.48 U2.M46
  BOTTOM w0.102: v1(76.78,83.11) 77.79,84.13 77.79,88.8 v2(77.77,88.82) 77.39,89.2 77.39,90.25 77.69,90.56 77.69,91.51 77.5,91.71 77.5,92.96 77.75,93.21 R155.2 78.16,94.26 78.74,94.85 78.74,95.62 78.25,96.12 R152.1
PD_CPU_NODE1_DFX_GPIO_GRP0_0: length 9.2
  TOP w0.102: U2.D30 67.78,88.06 67.78,88.63 67.67,88.74 67.67,91.28 67.36,91.59 v3(67.36,93.64) 67.36,94.88 68.1,95.62 R497.2
PD_CPU_NODE1_DFX_GPIO_GRP0_1: length 9.9
  TOP w0.102: R84.2 65.05,92.37 v1(64.6,91.92) 66,90.53 66,89.19 67.25,87.94 U2.D28
PD_CPU_NODE1_DFX_GPIO_GRP0_2: length 8.6
  TOP w0.102: U2.B28 67.22,89.82 v1(66.56,90.48) 66.38,90.66 66.38,91.32 65.73,91.97 65.73,95.4 66.07,95.73 R83.2
PD_CPU_NODE1_DFX_GPIO_GRP0_3: length 8.4
  TOP w0.102: U2.B30 68.14,88.56 67.98,88.72 67.98,94.56 v3(68.36,94.94) 69.11,95.69 R82.2
PD_CPU_NODE1_DFX_GPIO_GRP0_4: length 13.4
  TOP w0.102: U2.H32 69.56,85.37 v1(69.18,84.99)
  BOTTOM w0.102: v1(69.18,84.99) 69.18,85.86 69.46,86.14 69.46,90.62 v2(68.89,91.19) 66.05,94.02 R81.2
PD_CPU_NODE1_DFX_GPIO_GRP0_6: length 10.2
  TOP w0.102: R80.2 67.08,95.64 66.39,94.95 v1(66.39,92.13) 67.1,91.41 67.1,90.33 67.42,90.01 67.42,88.71 67.55,88.58 67.55,87.93 67.58,87.9 67.58,87.56 67.34,87.33 U2.E28
PD_CPU_NODE1_DFX_GPIO_GRP0_7: length 14.8
  TOP w0.102: U2.J30 68.28,85 v1(68.65,84.62)
  BOTTOM w0.102: v1(68.65,84.62) 67.6,85.67 67.6,88.48 67.23,88.85 67.23,90.58 66.6,91.2 66.15,91.2 63.01,94.35 v2(63.01,95.13) R79.2
PD_CPU_NODE1_DFX_GPIO_GRP1_0: length 9.5
  TOP w0.102: U2.C33 69.98,88.54 69.53,88.99 69.53,93.12 v1(69.88,93.47) 71.51,95.1 71.51,95.17 72.16,95.82 R56.1
PD_CPU_NODE1_DFX_GPIO_GRP1_1: length 10.2
  TOP w0.102: U2.D33 69.93,87.43 69.5,87.86 69.5,88.72 69.1,89.12 69.1,90.73 69.27,90.9 69.27,93.63 v1(70.46,94.82) 70.46,95.02 71.15,95.71 R55.1
PD_CPU_NODE1_DFX_GPIO_GRP1_2: length 12.2
  TOP w0.102: U2.G34 70.51,86.14 v1(70.74,85.91)
  BOTTOM w0.102: v1(70.74,85.91) 70.67,85.98 70.67,90.19 70.81,90.33 70.81,90.94 69.82,91.93 69.82,92.46 v2(68.09,94.2) R54.1
PD_CPU_NODE1_DFX_GPIO_GRP1_4: length 9.1
  TOP w0.102: U2.B35 70.55,88.65 70.55,89.35 70.57,89.37 70.57,90.1 70.52,90.15 70.52,91.24 70.32,91.43 70.32,92.31 v1(71.25,93.24) 71.25,93.96 73.18,95.89 R52.1
PD_CPU_NODE1_DFX_GPIO_GRP1_7: length 14.3
  TOP w0.102: v1(68.7,85.41) 68.8,85.41 69.54,86.14 U2.G32
  BOTTOM w0.102: R50.1 64.02,94.14 65,93.17 v2(65,93.16) 65,92.77 66.27,91.5 66.81,91.5 67.49,90.83 67.49,88.92 67.83,88.57 67.83,86.28 v1(68.7,85.41)
