# Allegro board T6M_CM_d_v01_1031_1645.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART_RI_P5_N: length 249.5
  TOP w0.102: U43.70 139.29,31.25 139.04,31.5 v1(138.38,31.5) ; U144.D 16.58,152.72 17.08,152.72 17.5,153.15 R1262.2 ; U144.D 15.21,152.01 15.21,154.82 15.13,154.91 R1068.2 ; U144.D 15.58,151.65 15.58,150.46 v1(15.46,150.35)
  IN1 w0.114: v1(15.46,150.35) 15.39,150.28 15.39,102.21 27.74,89.85 27.74,85.67 29.59,77.71 29.59,75 29.59,74.99 29.83,68.49 29.83,57.23 31.97,52.33 32.15,51.57 32.15,48.51 32.36,47.59 33.05,44.63 33.05,43.9 33.74,41.66 37.14,38.26 37.14,34.42 44.48,27.08 45.44,25.28 45.44,23.53 45.66,23.19 v1(45.66,22.39)
  IN2 w0.114: v1(138.38,31.5) 137.76,30.89 135.43,30.89 133.58,30.2 127.58,30.2 123.18,25.8 123.18,24.08 117.72,18.62 115.39,18.62 115,19 111.78,19 111.42,18.64 108.18,18.2 79.21,18.2 75.92,19.43 52.92,19.43 52.71,19.65 47.29,21.66 46.28,21.66 45.66,22.29 v1(45.66,22.39)
UART_RI_P6_L_N: length 64.9
  TOP w0.102: v1(24.65,147.25) 24.09,146.69 21.83,146.69 21.12,147.4 U56.5
  IN1 w0.114: v1(24.65,147.25) 24.55,147.35 24.55,155.03 23.29,156.3 23.29,160.89 23.76,161.36 24.56,161.36 24.59,161.33 24.96,161.33 26.47,162.84 27.83,162.84 41.1,176.12 41.1,179.7 40.15,180.65 40.15,189.53 42.14,191.52 v1(42.49,191.52)
  BOTTOM w0.102: v1(42.49,191.52) 42.49,191.52 43.86,190.14 43.86,188.14 R1331.2
UART_RI_P6_L_N_R: length 39.3
  BOTTOM w0.102: R1331.1 45.54,188.19 v2(45.54,193.27) 45.05,193.75 36.61,193.75 35.89,194.47 35.89,195.98 36.91,197 48.56,197 49.52,197.97 49.52,198.72 v1(49.15,199.09) 49.05,199.2 J35.A58
UART_RI_P6_LS_N: length 211.3
  TOP w0.102: v1(18.03,144.3) 17.22,143.49 U56.18 17.22,141.89 16.77,141.43 16.77,141 17.72,140.04 18.67,139.09 R1311.2
  IN1 w0.114: v1(57.22,187.78) 57.22,185.15 56.16,184.09 56.16,182.33 58.22,180.27 58.22,178.81 58.84,178.19 58.84,170.66 62.76,166.74 71.74,166.74 72.19,167.19 79.49,167.19 79.68,167.38 83.99,167.38 87.35,164.02 87.9,164.02 88.58,163.33 88.58,162.22 88.84,161.96 89.63,161.96 90,162.33 91.51,162.33 91.75,162.1 92.8,162.1 93.84,161.06 96.71,161.06 96.75,161.02 101.14,161.02 101.59,160.57 101.95,160.57 102.62,161.24 106.33,161.24 106.62,161.53 108.53,161.53 108.6,161.46 110.03,161.46 111.29,162.72 114.82,162.72 115.05,162.95 118.95,162.95 119.14,162.76 119.91,162.76 120.61,162.06 124.93,162.06 125.27,161.72 127.56,161.72 128.72,160.57 131.39,160.57 132.56,159.4 135.77,159.4 136.4,158.77 136.4,158.13 v1(136.5,158.02) ; v1(18.03,144.3) 18.03,146.57 16.83,147.77 16.83,162.64 22.49,168.3 24.59,168.3 27.4,171.1 27.4,185.3 v1(36.77,194.67)
  BOTTOM w0.102: R1069.1 141.81,160.01 140.66,161.16 U143.S 140.66,162.01 139.62,163.05 138.72,163.05 138.31,163.45 137.2,163.45 136.79,163.05 136.33,163.05 135.87,162.58 135.87,159.89 136.5,159.25 v1(136.5,158.02) ; v1(57.22,187.78) 57.22,191.33 53.87,194.69 40.25,194.69 40.25,194.7 40.23,194.67 v1(36.77,194.67)
UART_RI_P6_N: length 183.8
  TOP w0.102: v1(141.5,32.33) 147.07,32.33 147.79,31.6 U43.87
  IN1 w0.114: v1(144.21,158.79) 144.3,158.79 144.98,159.47 148.96,159.47 150.73,157.7 156.4,157.7 159.45,154.64 159.45,152.75 162.36,149.84 162.36,145.19 162.69,144.86 162.69,144.34 162.99,144.04 162.99,139.49 168.19,134.29 170.14,134.29 170.67,133.76 175.94,133.76 176.31,133.39 176.31,130.99 175.7,130.38 175.7,114.54 171.32,110.17 168.45,110.17 166.29,108 166.29,103.97 165.41,103.09 165.41,93.73 146.92,75.25 146.92,74.48 144.56,72.12 144.56,71.14 139.65,66.23 139.65,52.09 140.89,50.85 140.89,40.75 141.5,40.14 v1(141.5,32.33)
  BOTTOM w0.102: R776.2 142.2,31.63 v1(141.5,32.33) ; v1(144.21,158.79) 144.14,158.86 143.04,158.86 142.69,159.2 R1069.2 141.59,159.2 141.07,159.72 U143.D
UART_RI_RP5_L_N: length 15.8
  TOP w0.102: R1334.1 175.48,186.61 v3(175.35,186.49) 175.35,186.38 174.04,185.06 174.04,176.75 176.59,174.2 U57.5
UART_RI_RP5_L_N_R: length 19.1
  TOP w0.102: J18.B25 173.05,202.78 173.69,202.14 173.69,200.69 172.03,199.04 v1(172.03,195.38) 172.03,194.66 175.02,191.67 175.02,188.94 R1334.2
UART_RI_RP6_L_N: length 16.4
  BOTTOM w0.102: U59.5 172.62,174.2 174.12,175.7 174.12,182.45 174.43,182.77 174.43,184.05 175.15,184.77 175.15,185.34 175.75,185.94 175.75,186.38 v2(175.96,186.59) 176.62,187.25 R1333.2
UART_RI_RP6_L_N_R: length 19
  TOP w0.102: v1(176.24,189.56) 175.46,190.35 175.46,191.62 172.56,194.51 v1(172.56,196.95)
  BOTTOM w0.102: R1333.1 176.62,189.18 v1(176.24,189.56) ; v1(172.56,196.95) 173.2,197.59 173.2,200.25 174.05,201.11 J18.A24
UART_RTS_P1_L_N: length 358
  TOP w0.102: v1(47.49,198.45) 47.05,198.89 47.05,199.51 J35.B60 ; U51.9 174.4,34.44 174.89,33.95 174.89,21.57 168.44,15.12 151.32,15.12 149.46,13.25 138.43,13.25 136.24,15.44 v1(135.68,15.44)
  IN1 w0.114: v1(135.68,15.44) 133.82,17.3 128.08,17.3 127.28,16.51 119.29,16.51 117.4,14.61 101.81,14.61 101.42,14.22 100.48,14.22 100,14.4 96.42,17.98 80,17.98 79.27,18.71 78.33,18.71 77.26,19.78 70.62,19.78 68.47,21.93 54.72,21.93 52.41,24.25 52.41,25.58 50.67,27.32 50.11,27.87 50.11,28.33 45.9,32.54 45.9,33.94 42.34,37.5 42.34,43.68 40.78,45.24 40.78,46.09 42,47.31 42,80.08 33.92,88.16 33.92,93.62 29.29,98.25 29.29,98.57 24.24,103.61 23.69,103.61 22.54,104.75 22.54,112.97 23.07,113.49 23.07,134.65 24.51,136.08 24.51,137.91 23.83,138.58 23.83,143.01 23.36,143.49 23.36,149.47 22.5,150.32 22.5,161 24.3,162.8 25.08,162.8 31.18,168.9 31.18,182.36 43.61,194.79 44.56,194.79 47.49,197.72 v1(47.49,198.45)
UART_RTS_P1_N: length 14.8
  TOP w0.102: U51.14 169.16,37.68 v1(167.84,39) 166.91,39.93 165.01,39.93 162.88,42.06 162.31,42.06 R1011.2 R1013.2 160.89,42.1 160.13,42.1 159.92,41.89 U43.122
UART_RTS_P2_L_N: length 217.5
  TOP w0.102: U52.9 23.27,31.54 26.09,34.36 38.98,34.36 41.14,36.53 41.14,38.51 39.85,39.8 39.85,41.85 41.22,43.22 v1(41.22,45.49)
  IN1 w0.114: v1(47.51,199.29) 47.93,198.87 47.93,197.54 44.86,194.47 43.74,194.47 31.5,182.23 31.5,168.77 25.22,162.48 24.43,162.48 22.97,161.02 22.97,156.16 23.78,155.36 23.78,150.71 23.67,150.61 23.67,143.84 24.15,143.36 24.15,138.72 24.83,138.04 24.83,135.84 23.39,134.4 23.39,113.18 22.86,112.65 22.86,104.88 23.42,104.33 23.97,104.33 29.6,98.7 29.6,98.38 34.24,93.75 34.24,88.29 42.32,80.21 42.32,46.58 v1(41.22,45.49)
  BOTTOM w0.102: J35.A60 47.05,199.91 47.51,199.45 v1(47.51,199.29)
UART_RTS_P2_N: length 178.9
  TOP w0.102: R1017.2 R1018.2 154.76,49.82 154.79,49.79 U43.2 154.79,45.68 154.18,45.07 v1(154.18,44.32) ; v1(20.23,24.61) 20.02,24.82 U52.14
  IN3 w0.114: v1(20.23,24.61) 20.23,13.65 24.65,9.23 32.99,9.23 34.03,10.28 45.74,10.28 46.28,10.81 47.76,10.81 48.75,11.8 49.16,11.8 49.16,11.8 49.9,11.8 52.31,14.21 54.89,14.21 55.59,14.91 75.55,14.91 75.79,14.67 77.24,14.67 77.25,14.69 77.62,14.69 77.99,14.32 97.79,14.32 99.59,12.52 125.89,12.52 132.32,18.96 132.32,28.96 136.19,32.84 137.37,32.84 138.56,34.03 139.33,34.03 144.41,39.11 149.37,39.11 154.18,43.92 v1(154.18,44.32)
UART_RTS_P3_N: length 196.1
  TOP w0.102: R1157.2 148.34,52.1 v1(147.24,53.21) ; v1(161.63,165.12) 161.58,165.16 R1158.1 160.72,165.96 160.29,166.4 159.28,166.4 158.95,166.06 158.21,166.06 158.16,166.11 U129.78
  IN1 w0.114: v1(147.24,53.21) 147.24,55.44 145.73,56.95 145.73,59.1 145.8,59.16 145.8,67.42 146.61,68.24 146.61,69.27 149.46,72.13 149.46,74.2 160.46,85.2 164.69,85.2 164.73,85.16 187.86,85.16 188.14,85.44 190.43,85.44 203.28,98.28 203.28,121.78 203.55,122.05 203.55,128.65 203.41,128.79 203.41,153.06 193.78,162.69 183.6,162.69 181.7,164.58 169.29,164.58 168.66,165.21 164.16,165.21 164.16,165.2 161.71,165.2 v1(161.63,165.12)
UART_RTS_P3_R_N: length 6.9
  TOP w0.102: U43.16 147.79,48.35 v1(148.24,48.79) 148.34,48.9 R1157.1
  BOTTOM w0.102: v1(148.24,48.79) 147.61,48.16 R1137.2 147.6,47.36 R1136.2
UART_RTS_P4_N: length 276
  TOP w0.102: v1(89.17,181.46) 89.53,181.1 U128.18 ; v1(143.24,54.61) 143.29,54.55 143.29,51.88 R1164.2
  IN1 w0.114: v1(169.64,162.41) 169.71,162.34 170.54,162.34 171.08,161.81 181.32,161.81 183.89,159.24 188.37,159.24 199.98,147.63 199.98,142.96 201.29,141.65 201.29,125.63 200.88,125.22 200.88,124.59 201.29,124.18 201.29,98.08 190.35,87.15 160.62,87.15 148.19,74.72 148.19,73.95 145.83,71.59 145.83,70.42 142.26,66.85 142.26,55.67 143.24,54.7 v1(143.24,54.61)
  IN2 w0.114: v1(89.17,181.46) 91.14,183.44 92.08,183.44 93.24,184.6 97.21,184.6 97.27,184.54 99.81,184.54 101.36,182.98 103.2,182.98 103.84,182.34 108.97,182.34 109.17,182.14 112.4,182.14 112.87,181.68 114.9,181.68 115.42,182.2 115.6,182.2 116.77,183.37 116.77,183.4 117.03,183.66 117.39,183.66 117.64,183.41 120.42,183.41 120.59,183.58 121.31,183.58 121.91,182.97 123.62,182.97 124.28,182.31 132.77,182.31 133.02,182.06 138.96,182.06 141.03,179.99 v1(146.66,179.99)
  BOTTOM w0.102: R1165.1 88.14,181.18 88.42,181.46 v1(89.17,181.46) ; v1(146.66,179.99) 148.58,178.06 148.58,171.28 152.68,167.19 153.3,167.19 158.29,162.19 168.15,162.19 168.37,162.41 v1(169.64,162.41)
UART_RTS_P4_R_N: length 4
  TOP w0.102: R1164.1 143.26,48.96 142.91,48.6 v1(142.9,48.6) 142.79,48.49 U43.26
UART_RTS_P5_L_N: length 71.3
  TOP w0.102: J35.B52 v1(55.05,199.51) ; U55.9 17.89,162.96 20.36,160.49 25.86,160.49 v1(26.32,160.04)
  IN1 w0.114: v1(55.05,199.51) 55,199.47 53.71,199.47 53.16,198.91 52.32,198.91 51.91,198.5 51.91,197.66 43.57,189.32 42.26,189.32 41.79,188.85 41.79,186.88 42.6,186.07 42.6,182.29 42.74,182.15 42.74,175.44 28.38,161.08 27.16,161.08 26.32,160.24 v1(26.32,160.04)
UART_RTS_P5_N: length 263.2
  TOP w0.102: U43.34 138.79,45.76 138.76,45.73 v1(138.76,45.65) ; U55.14 14.64,162.49 14.38,162.23 v1(14.38,162.23)
  IN1 w0.114: v1(43.57,24.04) 41.96,26.99 35.42,33.52 35.42,37.51 30.88,42.05 29.93,44.94 29.93,45.29 28.65,52.25 28.58,52.62 28.43,52.96 27.48,57.66 27.33,58.32 27.33,73.02 27.27,73.4 26.39,79.03 26.1,80.82 26.05,80.88 26.05,81.21 25.74,83.13 25.74,88.8 23.27,91.27 23.27,91.99 18.16,97.11 15.06,97.11 14.21,97.95 13.64,100.93 13.64,161.08 14.38,161.82 v1(14.38,162.23)
  IN2 w0.114: v1(138.76,45.65) 138.69,45.65 138.09,45.06 137.46,45.06 136.44,44.03 136.02,44.03 133.58,41.59 133.58,39.79 132.41,38.63 125.33,33.79 123.2,31.66 123.2,30.55 120.19,26.59 120.19,24.77 116.6,21.17 53.31,21.17 51.44,23.04 48.55,23.04 47.86,23.74 46.73,24.04 v1(43.57,24.04)
UART_RTS_P6_L_N: length 83.6
  TOP w0.102: v1(26.69,145.52) 24.92,145.52 24.82,145.42 20.29,145.42 18.52,147.19 U56.9
  IN1 w0.114: v1(26.69,145.52) 34.95,153.78 34.95,164.18 44.57,173.8 44.94,173.8 45.39,174.25 45.39,176.28 45.23,176.44 45.23,179.18 45.27,179.22 45.27,183.62 45.1,183.79 45.1,186.72 45.54,187.15 47.04,187.15 48.26,188.37 48.26,189.95 55.87,197.57 v1(55.87,198.16)
  BOTTOM w0.102: v1(55.87,198.16) 55.87,199.35 55.05,200.18 J35.A52
UART_RTS_P6_N: length 253.3
  TOP w0.102: v1(16.15,144) 15.27,144.87 U56.14 ; U43.85 146.79,28.21 v1(147.4,27.6) R1149.2
  IN1 w0.114: v1(16.15,144) 16.1,143.95 16.1,102.4 28.39,90.11 28.39,85.89 32.49,81.79 32.49,72.26 32.69,72.06 32.69,69.49 30.98,67.78 30.98,58.2 32.11,57.08 32.11,55.61 33.07,54.65 33.07,50.82 33.76,50.13 33.76,44.57 34.45,43.87 34.45,41.85 37.81,38.49 37.81,34.72 46.12,26.41 46.12,23.65 47.68,21.28 v1(47.68,20.66)
  IN2 w0.114: v1(47.68,20.66) 48.89,19.45 50.26,19.45 51.18,18.53 52.36,18.53 52.61,18.79 75.82,18.79 79.14,17.54 112.13,17.54 112.45,17.23 113.69,17.23 114.01,17.54 117.57,17.54 123.83,23.81 123.83,25.22 127.83,29.22 144.98,29.22 146.6,27.6 v1(147.4,27.6)
UART_RTS_RP5_L_N: length 33.3
  TOP w0.102: U57.9 176.52,176.8 174.34,178.98 174.34,184.61 177.06,187.32 177.06,189.41 175.86,190.61 175.86,192.48 176.21,192.83 v1(176.21,192.85) ; J18.B19 179.05,201.3 178.46,200.71 178.46,196.33 176.99,194.86 176.51,194.86 v1(176.47,194.83)
  BOTTOM w0.102: v1(176.21,192.85) 176.21,193.08 176.15,193.14 176.15,194.51 v1(176.47,194.83)
UART_RTS_RP6_L_N: length 33.8
  BOTTOM w0.102: J18.A18 180.05,201.65 179.61,201.21 179.61,196.99 v2(178.9,196.28) 177.19,196.28 175.67,194.76 175.67,187.17 175.35,186.86 175.35,186.18 174.85,185.67 174.85,184.9 174.13,184.18 174.13,182.89 173.82,182.58 173.82,177.76 172.86,176.8 U59.9
UART_RX_P1: length 16.8
  TOP w0.102: U43.125 156.55,43.39 v1(155.14,41.98) ; U51.19 v1(163.27,35.09)
  BOTTOM w0.102: v1(163.27,35.09) 163.27,37.18 159.83,40.61 159.83,41.19 159.05,41.98 v1(155.14,41.98)
UART_RX_P1_L: length 352.7
  TOP w0.102: v1(45.27,198.74) 44.66,199.36 44.66,199.84 45.05,200.23 J35.B62 ; v1(132.69,16.23) 133.08,16.62 136.86,16.62 139.31,14.17 148.68,14.17 150.7,16.19 168.22,16.19 173.3,21.27 173.3,29.89 172.01,31.18 U51.4
  IN1 w0.114: v1(45.27,198.74) 44.98,198.45 44.98,197.45 43.87,196.34 42.3,196.34 29.87,183.92 29.87,170.42 20.28,160.83 20.28,156.76 20.01,156.5 20.01,147.86 21.23,146.64 21.23,138.47 21.13,138.37 21.13,137.75 21.17,137.71 21.17,103.68 24.76,100.09 25.13,100.09 25.34,100.29 25.76,100.29 27.85,98.2 27.85,97.67 32.65,92.87 32.65,87.56 40.73,79.49 40.73,54.11 39.26,52.64 39.26,45.51 41.45,43.31 41.45,36.08 45.26,32.28 49.03,28.51 49.03,28.5 49.18,28.36 49.18,24.68 52.28,21.58 53.71,21.58 54.08,21.21 68.27,21.21 70.37,19.11 77.03,19.11 78.07,18.07 78.92,18.07 79.73,17.25 95.86,17.25 99.03,14.09 99.84,13.78 99.92,13.75 100.38,13.58 100.42,13.53 100.57,13.38 101.48,13.38 101.55,13.45 102.05,13.95 119.08,13.95 121,15.87 131.32,15.87 131.67,16.23 v1(132.69,16.23)
UART_RX_P2: length 165.2
  TOP w0.102: U52.19 v1(22.62,18.57) ; U43.6 152.79,46.33 152.43,45.96 152.43,44.58 152.09,44.24 v1(152.09,44.24)
  IN3 w0.114: v1(152.09,44.24) 151.85,44.24 147.67,40.06 144.01,40.06 139.73,35.78 138.69,35.78 138.14,35.23 135.3,35.23 131.37,31.29 131.37,19.35 125.7,13.69 125.49,13.48 100.11,13.48 98.32,15.27 78.44,15.27 78.07,15.64 76.7,15.64 76.68,15.63 76.32,15.63 75.89,16.05 51.66,16.05 49,13.39 49.01,13.38 49.01,13.01 48.76,12.76 48.39,12.76 48.37,12.77 47.39,11.79 34.19,11.79 32.59,10.18 25.04,10.18 22.11,13.11 22.11,18.06 v1(22.62,18.57)
UART_RX_P2_L: length 217.6
  TOP w0.102: U52.4 26.52,27.39 25.37,28.54 25.37,31.42 27.16,33.21 39.13,33.21 42.06,36.15 42.06,46.71 v1(39.7,49.07)
  IN1 w0.114: v1(45.22,199.54) 45.71,199.06 45.71,197.48 44.25,196.03 42.43,196.03 30.19,183.78 30.19,170.29 26.12,166.23 26.12,165.43 25.87,165.18 25.1,165.18 20.66,160.74 20.66,153.38 20.89,153.15 20.89,152.56 20.34,152.02 20.34,148.13 22.21,146.26 22.21,139 21.45,138.24 21.45,137.88 21.49,137.84 21.49,135.36 22.12,134.72 22.12,114.35 21.59,113.82 21.59,104.36 23.61,102.34 24.16,102.34 28.22,98.29 28.22,97.81 32.97,93.05 32.97,87.77 41.05,79.69 41.05,53.85 39.7,52.49 v1(39.7,49.07)
  BOTTOM w0.102: v1(45.22,199.54) 45.05,199.72 J35.A62
UART_RX_P3: length 261.2
  TOP w0.102: U129.19 146.56,174.37 147.48,173.45 v1(147.48,172.56) ; U43.19 146.29,48.19 145.8,48.69 v1(145.46,48.69)
  IN1 w0.114: v1(147.48,172.56) 147.85,172.19 147.85,169.74 149.51,168.07 151.36,168.07 152.74,166.68 153.48,166.68 154.94,165.23 157.49,165.23 158.18,164.54 160.96,164.54 161.62,163.88 167.48,163.88 167.95,163.41 168.32,163.41 168.78,163.87 181.22,163.87 183.04,162.05 186.59,162.05 202.65,145.99 202.65,128.02 202.66,128.02 202.79,127.89 202.79,122.68 202.65,122.54 202.65,98.55 190.61,86.5 175.71,86.5 175.09,85.88 174.57,85.88 174.1,86.36 160.73,86.36 148.83,74.46 148.83,72.43 144.54,68.14 144.54,53.31 145.52,52.34 145.52,49.79 145.31,49.58 145.31,48.84 v1(145.46,48.69)
  IN3 w0.114: J5.3 166.05,21.93 166.05,24.46 162.96,27.55 161.32,27.55 156.81,32.06 156.81,45.91 154.95,47.77 146.38,47.77 v1(145.46,48.69)
UART_RX_P4: length 282.4
  TOP w0.102: v1(140.62,52.67) 140.58,52.7 139.82,52.7 139.54,52.98 139.54,53.5 139.11,53.93 U136.2 ; v1(91.59,178.43) 90.89,178.43 90.53,178.79 U128.16 ; U129.16 148.06,176.74 147.06,175.74 v1(147.06,175.22)
  IN1 w0.114: v1(91.59,178.43) 90.47,178.43 89.32,177.27 89.32,176.9 89.66,176.56 92.52,176.56 96.27,172.81 101.72,172.81 102.14,172.39 104.75,172.39 104.92,172.56 106.93,172.56 108.41,174.04 112.55,174.04 113.37,174.86 115.85,174.86 116.19,175.2 117.9,175.2 119.95,173.15 120.02,173.15 120.09,173.08 121.6,173.08 123.04,174.53 127.02,174.53 128.54,176.05 135.78,176.05 136.59,175.23 137.99,175.23 139.03,176.28 146,176.28 v1(147.06,175.22) 147.23,175.05 147.23,173.59 146.73,173.09 146.73,170.44 147.19,169.98 147.19,169.5 149.54,167.14 151.34,167.14 153.37,165.11 153.37,164.98 153.89,164.47 156.47,164.47 157.08,163.85 160.75,163.85 163.07,161.53 166.94,161.53 168.37,160.1 169,160.1 169.07,160.17 172.02,160.17 172.67,160.82 180.78,160.82 183.31,158.29 187.97,158.29 199.03,147.24 199.03,142.19 199.03,142.19 199.96,141.26 199.96,125.68 198.88,124.61 198.88,116.61 199.49,116 199.49,97.64 190.26,88.41 174.38,88.41 174.13,88.66 160.78,88.66 147.24,75.12 147.24,74.35 144.88,71.99 144.88,71.01 140.76,66.89 140.76,64.74 140.25,64.24 140.25,58.88 140.84,58.29 140.84,52.89 v1(140.62,52.67)
UART_RX_P4_BUF: length 52.1
  TOP w0.102: U43.31 140.29,48.75 v1(140.45,48.91) 140.45,49.52 140.56,49.63 140.56,51.71 141.09,52.25 141.09,52.25 141.09,52.29 141.1,52.29 141.1,53.05 140.87,53.28 U136.4
  IN3 w0.114: J6.3 160.63,21.08 160.63,26.97 155.99,31.62 155.99,45.38 154.35,47.02 142.34,47.02 v1(140.45,48.91)
UART_RX_P5: length 253.9
  TOP w0.102: U55.19 17.24,157.34 17.37,157.2 17.37,155.01 17.09,154.73 15.96,154.73 15.72,154.49 v1(15.72,152.9) ; v1(136.04,40.01) 135.66,40.39 U43.48
  IN1 w0.114: v1(15.72,152.9) 15.92,151.68 15.92,144.39 15.71,144.18 15.71,102.34 28.06,89.99 28.06,85.76 32.16,81.67 32.16,72.01 32.38,71.79 32.38,69.66 30.51,67.8 30.51,58.22 31.79,56.95 31.79,55.36 32.68,54.48 32.68,50.76 33.44,50 33.44,44.43 34.14,43.74 34.14,41.72 37.5,38.36 37.5,34.55 45.75,26.29 45.75,26.29 45.75,23.62 46.4,22.65 v1(46.4,22.27)
  IN2 w0.114: v1(136.04,40.01) 135.47,40.01 127.84,32.38 126.78,32.38 126.03,31.63 126.03,29.36 122.67,26 122.67,25.2 117.43,19.96 52.78,19.96 51.51,21.23 50.26,21.8 48.14,21.8 47.67,22.27 v1(46.4,22.27)
UART_RX_P5_L: length 62.4
  TOP w0.102: v1(27.12,163.3) 26.77,162.95 21.49,162.95 21.14,163.3 U55.4 ; v1(52.75,199.73) 52.75,199.79 53.05,200.09 J35.B54
  IN1 w0.114: v1(52.75,199.73) 52.56,199.54 48.98,199.54 48.34,198.89 48.34,197.5 44.94,194.1 43.82,194.1 31.88,182.16 31.88,168.63 27.12,163.86 v1(27.12,163.3)
UART_RX_P6: length 253.7
  TOP w0.102: v1(17.2,141.17) 17.28,141.17 17.87,141.77 U56.19 ; U43.93 v1(150.79,27.99)
  IN1 w0.114: v1(17.2,141.17) 16.41,140.39 16.41,102.66 24.15,94.92 25.52,94.92 28.83,91.62 28.83,86.12 33.45,81.5 33.45,67.79 32.09,66.43 32.09,64.5 31.87,64.28 31.87,62.2 31.3,61.63 31.3,58.44 32.59,57.15 32.59,55.68 33.39,54.88 33.39,50.95 34.07,50.26 34.07,44.9 34.77,44.2 34.77,41.98 38.2,38.56 38.2,34.83 46.45,26.57 46.45,23.72 48.32,20.89 48.62,20.43 48.64,20.4 50.09,18.96 50.69,18.96 51.46,18.19 65.25,18.19 67.88,15.56 75.57,15.56 75.92,15.21 78.1,15.21 79.42,13.89 91.5,13.89 99.39,10.89 99.49,10.79 102.95,10.79 103.33,11.17 124.14,11.17 125.28,12.3 130.9,12.3 131.8,13.21 136.29,13.21 147.9,24.82 147.9,25.83 149.72,27.64 150.45,27.64 v1(150.79,27.99)
UART_RX_P6_L: length 75.8
  TOP w0.102: U56.4 21.77,147.67 22.11,147.33 23.95,147.33 24.86,148.24 26.12,148.24 v1(26.62,148.74)
  IN1 w0.114: v1(26.62,148.74) 27.61,148.74 34.22,155.35 34.22,164.84 44.48,175.1 44.48,182.88 44.53,182.94 44.53,183.3 44.37,183.47 44.37,187.71 45.66,189 46.67,189 47.34,189.67 47.34,190.78 53.98,197.42 53.98,197.94 53.85,198.07 v1(53.85,198.43)
  BOTTOM w0.102: J35.A54 53.05,200.19 53.85,199.39 v1(53.85,198.43)
UART_RX_RP5_L: length 36.1
  TOP w0.102: v1(174.57,191.4) 174.57,188.59 175.02,188.14 175.02,187.35 174.77,187.1 174.77,186.51 173.95,185.68 173.44,185.68 173.19,185.43 173.19,185.07 173.49,184.77 173.49,176.7 176.64,173.55 U57.4 ; J18.B21 177.05,200.59 176.03,199.57 176.03,199.1 v1(174.6,197.67)
  BOTTOM w0.102: v1(174.6,197.67) 174.71,197.55 174.71,191.54 v1(174.57,191.4)
UART_RX_RP6_L: length 36
  TOP w0.102: v1(177.56,197.64) 177.56,197.3 177.23,196.97 v1(177.23,195.71)
  BOTTOM w0.102: J18.A20 178.05,201.89 176.89,200.73 176.89,198.3 v1(177.56,197.64) ; v1(177.23,195.71) 177.78,195.17 177.78,191.85 177.26,191.33 177.26,187.12 176.6,186.46 176.6,186.35 175.46,185.21 175.46,184.64 174.74,183.92 174.74,182.64 174.42,182.33 174.42,175.52 172.45,173.55 U59.4
UART_SDC_RX: length 22.6
  TOP w0.102: U128.21 88.03,179.04 v1(87.43,178.45) 87.43,178.44 87.11,178.13 87.11,176.42 88.41,175.13 88.41,171.29 89.8,169.89 90.01,169.89 93.53,166.37 94.99,166.37 v1(95.54,166.91)
  BOTTOM w0.102: v1(95.54,166.91) 95.54,166.55 95.71,166.37 95.71,165.59 94.47,164.35 U73.10
UART_SDC_TX: length 23.3
  TOP w0.102: U128.20 88.53,178.79 88.09,178.36 88.09,177.94 87.55,177.39 v1(87.55,177.09) 87.55,176.44 88.92,175.06 88.92,171.79 89.8,170.91 90.01,170.91 90.59,170.32 91.17,170.32 92.69,168.8 93.8,168.8 94.35,168.25 v1(95.83,168.25)
  BOTTOM w0.102: v1(95.83,168.25) 95.98,168.1 95.98,167.43 96.02,167.39 96.02,165.19 94.53,163.7 U73.9
UART_SW_S0_N: length 87.4
  TOP w0.102: U128.2 97.53,180.52 97.95,180.94 v1(98.69,180.94) ; U129.2 155.06,180.98 154.92,181.12 v1(154.92,181.22) ; D15.A 134.06,182.77 v1(133.37,183.46) 132.05,183.46 131.35,182.76 125.31,182.76 124.68,182.13 123,182.13 122.63,181.76 120.85,181.76 119.66,180.57 v1(117.63,180.57)
  IN1 w0.114: v1(154.92,181.22) 154.54,180.84 153.44,180.84 152.97,181.32 152.46,181.32 151.89,181.89 151,181.89 150.91,181.97 149.85,181.97 148.59,183.24 148.59,183.52 147.09,185.02 140.01,185.02 139.37,184.39 134.29,184.39 v1(133.37,183.46)
  IN2 w0.114: v1(117.63,180.57) 116.99,180.57 115.69,179.26 112.21,179.26 111.72,179.75 109.73,179.75 109.29,180.19 104.21,180.19 104.19,180.17 102.17,180.17 101.59,180.75 99.42,180.75 99.23,180.94 v1(98.69,180.94)
  IN3 w0.114: v1(98.61,168.92) 99.12,169.43 99.12,172.52 97.4,174.25 97.4,175.05 98.77,176.42 98.77,178.13 98.52,178.38 98.52,180.77 v1(98.69,180.94)
  BOTTOM w0.102: R784.1 100.93,167.93 100.6,168.25 U73.1 99.11,168.25 98.61,168.76 v1(98.61,168.92)
UART_SW_S1_N: length 90.4
  TOP w0.102: v1(119.54,179.82) 119.79,180.08 120.27,180.08 121.65,181.46 123.01,181.46 123.38,181.83 124.81,181.83 125.44,182.45 131.36,182.45 v1(132.41,181.4) D16.A ; v1(97.16,170.37) 96.76,170.76 96.76,173.68 96.11,174.33 96.11,177.51 96.38,177.79 96.42,177.79 96.67,178.04 96.67,178.73 97.03,179.08 U128.3 ; v1(154.29,180) 154.56,179.73 U129.3
  IN1 w0.114: v1(154.29,180) 153.81,180 152.83,180.99 152.34,180.99 151.75,181.57 150.86,181.57 150.78,181.66 149.61,181.66 148.23,183.03 148.23,183.43 146.95,184.71 140.14,184.71 139.47,184.04 135.05,184.04 v1(132.41,181.4)
  IN2 w0.114: v1(97.16,170.37) 97.61,169.92 100.84,169.92 101.12,169.64 101.49,169.64 101.74,169.89 102.46,169.89 102.95,169.4 104.82,169.4 105.61,168.6 105.98,168.6 106.76,167.82 108.07,167.82 108.4,168.14 108.76,168.14 108.78,168.12 110.87,168.12 115.56,172.81 115.56,176 117.07,177.51 117.35,177.51 117.93,178.09 117.93,178.22 v1(119.54,179.82)
  BOTTOM w0.102: R785.1 101.04,166.91 100.35,167.6 U73.2 99.2,167.6 99.2,167.61 98.81,168 98.81,168.13 98.55,168.38 98.54,168.38 98.12,168.8 98.12,169.4 v1(97.16,170.37)
UART_SW_S2_N: length 95.6
  TOP w0.102: v1(96.66,169.07) 96.66,169.79 96.46,170 96.46,173.55 95.81,174.21 95.81,178.49 96.53,179.21 U128.4 ; U129.4 154.06,179.51 153.83,179.74 153.83,180.93 153.63,181.13 v1(153.63,181.28) ; D17.A 130.76,181.18 v1(130.55,181.39) 129.79,182.15 125.56,182.15 124.94,181.52 123.61,181.52 123.24,181.15 123.24,180.29 122.02,179.07 121.28,179.07 120.34,178.13 v1(120.34,178.1)
  IN1 w0.114: v1(153.63,181.28) 153.25,181.66 152.58,181.66 152.03,182.21 151.13,182.21 151.04,182.29 150.17,182.29 149.63,182.83 149.63,183.43 147.72,185.34 139.87,185.34 139.24,184.71 133.99,184.71 132.66,183.37 132.66,182.72 131.75,181.81 130.98,181.81 v1(130.55,181.39)
  IN2 w0.114: v1(96.66,169.07) 97.96,169.07 98.3,169.41 99.16,169.41 99.58,168.98 102.7,168.98 103.62,168.06 104.64,168.06 104.72,167.98 106.15,167.98 106.63,167.5 107.05,167.5 107.99,166.56 109.96,166.56 115.87,172.47 115.87,175.87 116.6,176.59 117.7,176.59 119.2,178.1 v1(120.34,178.1)
  BOTTOM w0.102: v1(96.66,169.07) 96.92,169.07 97.38,168.61 97.38,167.78 97.94,167.22 97.94,165.98 98.27,165.65 U73.5 100.87,165.65 100.87,165.65 102,165.65 102.24,165.89 R786.1
UART_SW_S3_N: length 97.5
  TOP w0.102: v1(120.13,176.76) 120.13,176.92 121.38,178.17 121.6,178.17 121.93,178.5 122.27,178.5 124.86,181.09 125.72,181.09 126.48,181.85 128.63,181.85 129.08,181.39 v1(129.08,181.01) 129.11,180.98 D23.A ; U128.5 96.03,179.14 95.5,178.62 95.5,174.08 96.13,173.45 96.13,168.87 96.52,168.48 96.9,168.48 v1(96.95,168.43) ; v1(152.68,182.18) 153.07,181.79 153.07,180.82 153.51,180.39 153.51,179.64 153.56,179.59 U129.5
  IN1 w0.114: v1(152.68,182.18) 152.34,182.53 151.26,182.53 151.18,182.61 150.31,182.61 149.99,182.93 149.99,183.53 147.85,185.66 138.95,185.66 138.45,185.16 134,185.16 132.24,183.4 132.24,182.75 131.73,182.24 130.32,182.24 v1(129.08,181.01)
  IN2 w0.114: v1(96.95,168.43) 96.95,168.43 97.06,168.54 98.3,168.54 98.47,168.38 99.52,168.38 99.9,168 102.7,168 102.97,167.73 104.4,167.73 104.52,167.61 105.63,167.61 107.52,165.72 107.88,165.72 108.19,166.02 110.11,166.02 112.56,168.47 114.05,168.47 116,170.42 116.78,170.42 117.96,171.6 117.96,175.24 118.26,175.53 118.26,176.41 119.28,177.44 119.64,177.44 120.13,176.94 v1(120.13,176.76)
  BOTTOM w0.102: R787.1 101.96,164.39 101.13,164.39 100.51,165 U73.6 98.18,165 97.35,165.83 97.35,166.36 96.85,166.87 96.85,167.62 96.95,167.72 v1(96.95,168.43)
UART_SW_S4_N: length 92.8
  TOP w0.102: D22.A 127.37,180.15 v1(127.37,181.41) 126.51,181.41 125.8,180.7 125.13,180.7 121.5,177.07 121.15,177.07 120.37,176.28 v1(119.06,176.28) ; v1(153.02,180) 153.06,179.96 U129.6 ; U128.6 95.53,179.08 95.2,178.75 95.2,173.95 95.83,173.32 95.83,169.48 95.29,168.94 v1(94.57,168.94)
  IN1 w0.114: v1(127.37,181.41) 128.24,180.54 132.24,180.54 135.42,183.72 139.61,183.72 140.27,184.39 146.4,184.39 146.68,184.1 146.68,183.74 147.45,182.97 147.82,182.97 149.45,181.34 150.65,181.34 150.73,181.26 151.58,181.26 152.17,180.66 152.36,180.66 v1(153.02,180)
  IN2 w0.114: v1(94.57,168.94) 95.75,168.94 97.08,167.62 97.46,167.62 98.24,166.83 102.89,166.83 103.43,166.29 104.24,166.29 104.56,165.97 106.6,165.97 107.23,165.34 107.99,165.34 108.24,165.6 110.98,165.6 112.1,166.71 113.04,166.71 114.69,168.37 114.69,168.42 116.33,170.06 117.02,170.06 118.34,171.38 118.34,175.17 118.58,175.4 118.58,175.8 v1(119.06,176.28)
  BOTTOM w0.102: R790.1 92.04,167.43 92.22,167.6 U73.15 94.63,167.6 94.91,167.89 94.91,168.6 v1(94.57,168.94)
UART_SW_S5_N: length 92.4
  TOP w0.102: U129.7 152.56,179.74 152.07,180.23 v1(151.73,180.23) ; v1(126.79,180.9) 126.01,180.11 D24.A 125.06,180.11 122.67,177.72 122.67,177.17 121.49,175.99 121.29,175.99 121.06,175.75 v1(120.54,175.75) ; U128.7 95.03,179.01 94.89,178.88 94.89,173.57 95.49,172.97 95.49,171.57 95.15,171.22 94.98,171.22 94.72,170.97 94.72,170.61 95.22,170.12 v1(95.22,169.48)
  IN1 w0.114: v1(126.79,180.9) 127.53,180.16 132.32,180.16 134.31,182.16 136.17,182.16 137,182.99 142.02,182.99 142.04,182.97 146.75,182.97 147.36,182.37 147.97,182.37 149.32,181.02 150.14,181.02 150.94,180.23 v1(151.73,180.23)
  IN2 w0.114: v1(95.22,169.48) 95.12,169.38 94.39,169.38 94.14,169.13 94.14,168.76 94.39,168.5 94.89,168.5 96.37,167.02 96.81,167.02 98.39,165.45 102.54,165.45 103.28,164.71 107.26,164.71 107.34,164.63 109.14,164.63 109.79,165.28 111.45,165.28 112.53,166.36 113.2,166.36 115.48,168.65 116.02,168.65 116.35,168.97 116.93,168.97 118.66,170.7 118.66,172.67 120.82,174.82 120.82,175.48 v1(120.54,175.75)
  BOTTOM w0.102: R791.1 91.9,166.41 92.45,166.95 U73.14 94.9,166.95 95.22,167.27 v1(95.22,169.48)
UART_T1_NODE1_RXD: length 24.9
  TOP w0.102: v1(67.1,183.72) 67.1,183.49 68.3,182.29 73.02,182.29 73.74,181.56 75.99,181.56 76.7,182.27 78.48,182.27 83.13,177.62 U128.27
  BOTTOM w0.102: R907.1 66.56,187.16 66.56,185.38 C670.1 67.14,183.75 v1(67.1,183.72)
UART_T1_NODE1_RXD_R: length 17.5
  BOTTOM w0.102: J35.A42 65.05,199.8 65.44,199.42 v2(65.44,199.37) 65.44,192.3 67.14,190.6 R907.2
UART_T1_NODE1_TXD: length 22.1
  TOP w0.102: U128.26 84.28,178.44 83.62,179.09 v1(82.74,179.09)
  IN3 w0.114: v1(82.74,179.09) 82.21,179.09 78.56,182.74 v1(75.69,182.74)
  BOTTOM w0.102: R910.1 65.99,184.8 66.4,184.39 66.4,183.66 67.71,182.35 69.25,182.35 69.25,182.35 69.33,182.27 75.27,182.27 75.72,182.72 75.72,182.74 v1(75.69,182.74)
UART_T1_NODE1_TXD_R: length 20.9
  BOTTOM w0.102: R910.2 65.99,185.75 65.43,186.31 65.43,187.97 C673.1 65.99,190.98 65.04,191.93 65.04,196.26 64.4,196.9 v2(64.4,197.52) 64.05,197.88 64.05,198.67 J35.A43
UART_T1_NODE2_RXD: length 19.8
  TOP w0.102: U128.29 83.58,176.62 82.47,177.74 v1(81.5,177.74)
  IN3 w0.114: v1(75.16,183.34) 75.16,182.65 75.51,182.3 78.1,182.3 81.5,178.9 v1(81.5,177.74)
  BOTTOM w0.102: R913.1 73.51,187.25 73.51,186.66 73.99,186.18 C676.1 73.53,185.61 73.41,185.49 73.41,183.69 73.76,183.34 v1(75.16,183.34)
UART_T1_NODE2_RXD_R: length 17.5
  BOTTOM w0.102: J35.A35 72.05,200.51 73.01,199.54 v2(73.01,198.1) 73.01,196.1 73.41,195.7 73.41,192.88 73.99,192.3 R913.2
UART_T1_NODE2_TXD: length 19.5
  TOP w0.102: U128.28 85.06,177.12 85.43,177.49 85.43,178.31 v1(84.88,178.85) 84.33,178.85 82.23,180.95 80.24,180.95 78.61,182.58 76.58,182.58 75.86,181.87 73.87,181.87 72.85,182.89 v1(72.79,182.89)
  BOTTOM w0.102: R916.1 72.59,184.81 72.59,183.37 72.79,183.17 v1(72.79,182.89)
UART_T1_NODE2_TXD_R: length 20.8
  BOTTOM w0.102: J35.A36 71.05,201.88 71.48,201.44 71.48,199.15 72.28,198.36 72.28,195.92 v2(72.6,195.6) 72.6,194.59 72.85,194.34 C679.1 72.27,187.95 72.27,186.18 R916.2
UART_T1_NODE3_RXD: length 22.2
  TOP w0.102: U128.34 83.26,174.12 83.12,173.99 82.2,173.99 82.09,174.1 80.94,174.1 79.64,175.4 v1(79.64,176.49)
  IN3 w0.114: v1(79.64,176.49) 79.19,176.49 73.23,182.45 73.23,183.52 71.71,185.05 v1(71.71,186.27)
  BOTTOM w0.102: R919.1 71.27,187.29 71.27,186.71 v1(71.71,186.27) C682.1
UART_T1_NODE3_RXD_R: length 17.4
  BOTTOM w0.102: J35.A37 70.05,199.69 70.82,198.92 v2(70.82,198.16) 70.82,191.26 71.71,190.38 R919.2
UART_T1_NODE3_TXD: length 24.3
  TOP w0.102: v1(71.7,183.09) 71.93,183.32 72.97,183.32 73.98,182.31 75.87,182.31 76.45,182.88 78.74,182.88 80.37,181.26 83.3,181.26 85.4,179.15 85.4,178.76 85.84,178.33 85.84,174.94 85.52,174.62 U128.33
  BOTTOM w0.102: v1(71.7,183.09) 71.7,183.13 71.08,183.74 71.08,184.28 R922.1
UART_T1_NODE3_TXD_R: length 21
  BOTTOM w0.102: R922.2 70.56,185.94 69.99,186.52 69.99,187.95 C685.1 70.56,190.52 69.1,191.99 69.1,197.51 69.5,197.91 v2(69.5,199.62) 69.05,200.08 J35.A38
UART_T1_NODE4_RXD: length 23.6
  TOP w0.102: U128.36 v1(82.06,173.12)
  IN3 w0.114: v1(82.06,173.12) 82.06,173.16 72.78,182.45 72.61,182.45 72.35,182.71 72.35,183.95 71.89,184.42 71.36,184.42 v1(69.42,186.35)
  BOTTOM w0.102: R925.1 68.92,187.22 68.92,186.86 v1(69.42,186.35) C688.1
UART_T1_NODE4_RXD_R: length 17.8
  BOTTOM w0.102: R925.2 69.42,190.44 67.79,192.07 v2(67.79,195.79) 67.03,196.55 67.03,198.96 66.84,199.15 66.84,199.65 67.05,199.86 J35.A40
UART_T1_NODE4_TXD: length 21.8
  TOP w0.102: v1(79.91,173.36) 80.18,173.62 U128.35
  IN3 w0.114: v1(69.86,183.08) 69.86,182.13 75.69,176.3 76.58,176.3 79.52,173.36 v1(79.91,173.36)
  BOTTOM w0.102: v1(69.86,183.08) 69.86,183.08 69.58,183.35 69.19,183.35 69.08,183.46 68.91,183.46 68.28,184.1 R928.1
UART_T1_NODE4_TXD_R: length 21
  BOTTOM w0.102: R928.2 68.28,185.65 67.7,186.23 67.7,187.95 C691.1 68.28,190.64 66.48,192.44 66.48,197.98 v2(66.43,198.03) 66.43,198.03 66.48,198.07 66.48,201.67 66.05,202.1 J35.A41
UART_T2_NODE1_RXD: length 23.4
  TOP w0.102: v1(86.47,171.99) 85.6,171.99 85.46,172.12 U128.38 ; C694.1 v1(76.28,186.33) 75.8,186.8 75.8,187.25 R931.1
  IN3 w0.114: v1(86.47,171.99) 86.01,172.45 86.01,175.14 83.18,177.97 83.18,179.27 79.39,183.06 79.23,183.06 78.45,183.84 78.45,184.16 v1(76.28,186.33)
UART_T2_NODE1_RXD_R: length 17.2
  TOP w0.102: R931.2 76.28,193.32 76.16,193.44 v1(76.16,199.59) 75.05,200.7 J35.B32
UART_T2_NODE1_TXD: length 21.9
  TOP w0.102: U128.37 85.27,172.62 v1(85.5,172.85) 85.5,173.52 86.68,174.71 86.68,177.92 85.71,178.89 85.71,179.42 83.56,181.56 80.61,181.56 78.99,183.19 76.32,183.19 75.72,183.79 75.72,184.29 75.2,184.81 R934.1
UART_T2_NODE1_TXD_R: length 20.5
  TOP w0.102: J35.B33 74.05,198.77 v1(75,197.82) 75.14,197.68 C697.1 74.56,187.95 74.56,186.34 75.14,185.76 R934.2
UART_T2_NODE2_RXD: length 24.8
  TOP w0.102: C700.1 v1(73.99,187.05) R937.1 ; U128.40 v1(85.53,171.12)
  IN3 w0.114: v1(73.99,187.05) 73.99,185.39 74.74,184.64 74.74,183.75 74.72,183.73 74.72,182.64 75.96,181.4 76.87,181.4 76.89,181.38 76.97,181.38 77.23,181.13 77.23,181.05 79.49,178.78 79.79,178.78 82.16,176.41 82.16,176.41 82.16,176.23 83.49,174.9 83.49,173.17 v1(85.53,171.12)
UART_T2_NODE2_RXD_R: length 17.1
  TOP w0.102: J35.B34 73.05,202.11 73.56,201.59 v1(73.56,196.8) 73.56,196.09 73.99,195.65 R937.2
UART_T2_NODE2_TXD: length 23.4
  TOP w0.102: R940.1 73.17,184.81 73.37,185 73.37,186.06 73.11,186.31 v1(72.87,186.31) ; U128.39 v1(83.11,171.62)
  IN3 w0.114: v1(72.87,186.31) 73.53,185.65 73.53,185.37 74.42,184.48 74.42,183.88 74.4,183.86 74.4,182.51 76.41,180.51 77.08,180.51 78.45,179.14 78.45,178.69 79.53,177.61 80.51,177.61 81.84,176.28 81.84,176.1 83.17,174.77 83.17,174.39 83.11,174.33 v1(83.11,171.62)
UART_T2_NODE2_TXD_R: length 20.6
  TOP w0.102: R940.2 72.85,185.67 72.29,186.23 72.29,188.28 72.54,188.53 C703.1 72.85,196.11 72.02,196.94 v1(72.02,199.78) 72.05,199.8 J35.B35
UART_T2_NODE3_RXD: length 26.6
  TOP w0.102: v1(81.72,171.15) 82.37,171.15 83.4,170.12 U128.42 ; C706.1 71.28,186.04 71.28,186.61 v1(71.71,187.04) R943.1
  IN3 w0.114: v1(81.72,171.15) 82.63,172.06 82.63,174.01 81.09,175.55 81.09,175.7 79.72,177.08 79.05,177.08 73.55,182.58 73.55,183.88 72.15,185.28 72.15,186.45 71.71,186.89 v1(71.71,187.04)
UART_T2_NODE3_RXD_R: length 17.4
  TOP w0.102: J35.B37 70.05,197.74 v1(71.47,196.32) 71.71,196.08 R943.2
UART_T2_NODE3_TXD: length 22.4
  TOP w0.102: U128.41 83.33,170.62 81.98,171.97 v1(80.47,171.97) ; R946.1 v1(70.56,183.96)
  IN3 w0.114: v1(80.47,171.97) 80.47,173.43 79.97,173.93 79.57,173.93 76.78,176.72 75.72,176.72 75.46,176.97 75.46,177.44 71.97,180.93 71.53,180.93 70.56,181.9 v1(70.56,183.96)
UART_T2_NODE3_TXD_R: length 20.8
  TOP w0.102: R946.2 70.56,186.26 70.01,186.82 70.01,188.18 70.35,188.53 C709.1 70.56,195.1 69.61,196.05 v1(69.61,196.42) 69.61,196.57 69.05,197.13 J35.B38
UART_T2_NODE4_RXD: length 34.3
  TOP w0.102: C712.1 69.85,186.04 69.85,186.54 69.7,186.69 69.7,186.78 v1(69.42,187.05) R949.1 ; v1(78.55,168.85) 79.51,168.85 81.18,167.18 83,167.18 83.06,167.12 U128.48
  IN3 w0.114: v1(69.42,187.05) 68.98,186.62 68.98,186.16 71,184.14 71,183.16 73.01,181.15 73.01,180.7 75.76,177.95 76.39,177.95 81.13,173.21 81.13,170.47 79.51,168.85 v1(78.55,168.85)
UART_T2_NODE4_RXD_R: length 17.6
  TOP w0.102: J35.B39 68.05,202.22 68.59,201.69 68.59,198.18 v1(68.16,197.75) 68.16,195.08 69.42,193.82 R949.2
UART_T2_NODE4_TXD: length 25.3
  TOP w0.102: R952.1 v1(69.03,182.87) ; v1(79.48,169.78) 79.48,169.67 80.16,168.99 80.16,168.82 80.85,168.14 81.01,168.14 81.17,167.98 83.16,167.98 83.51,167.62 U128.47
  IN3 w0.114: v1(69.03,182.87) 69.46,182.44 69.46,182.02 69.5,181.99 78.94,172.55 78.94,170.32 v1(79.48,169.78)
UART_T2_NODE4_TXD_R: length 20.7
  TOP w0.102: J35.B40 67.05,199.98 v1(67.47,199.56) 67.47,194.11 68.28,193.3 C715.1 68.48,188.53 68.85,188.15 68.85,186.62 68.28,186.05 R952.2
UART_T3_NODE1_RXD: length 34.4
  TOP w0.102: U128.53 87.03,167.6 87.19,167.76 v1(87.19,168.32)
  IN3 w0.114: v1(87.14,186.22) 86.99,186.37 86.99,186.71 86.3,187.41 85.24,187.41 85.14,187.31 83.25,187.31 82.75,186.81 82.75,185.42 81.67,184.33 81.67,183.14 82.29,182.52 82.29,182 82.55,181.75 83.32,181.75 86.09,178.98 86.09,177.93 88.42,175.6 88.42,170.11 87.19,168.87 v1(87.19,168.32)
  BOTTOM w0.102: C671.1 87.02,186.1 v1(87.14,186.22) 87.14,187.66 R908.1
UART_T3_NODE1_RXD_R: length 17.2
  BOTTOM w0.102: J35.A20 87.05,200.58 87.54,200.09 v2(87.54,197.85) 87.54,196.46 87.53,196.46 87.53,190.96 87.71,190.79 87.71,190.09 87.07,189.45 R908.2
UART_T3_NODE1_TXD: length 3.5
  TOP w0.102: v1(85.18,164.86) 85.65,165.33 86.26,165.33 86.53,165.06 U128.52
  BOTTOM w0.102: v1(85.18,164.86) 85.23,164.91 R911.1
UART_T3_NODE1_TXD_R: length 48.3
  IN3 w0.114: v1(86.57,190.09) 84.1,187.62 83.02,187.62 82.43,187.03 82.43,185.55 81.29,184.41 81.29,183.07 81.89,182.47 81.89,181.96 82.42,181.43 83.19,181.43 85.57,179.05 85.57,177.89 87.64,175.81 87.64,174.53 88.11,174.07 88.11,171.2 87.37,170.47 87.37,169.51 86.73,168.87 86.73,167.78 86.42,167.46 v1(86.42,166.72)
  BOTTOM w0.102: R911.2 86.31,166.61 v1(86.42,166.72) ; C674.1 86.06,189.58 v1(86.57,190.09) 86.54,190.11 86.54,199.45 86.48,199.51 86.48,201.41 86.05,201.84 J35.A21
UART_T3_NODE2_RXD: length 33.7
  TOP w0.102: U128.55 88.03,168.3 v1(88.46,168.73)
  IN3 w0.114: v1(88.46,168.73) 88.46,169 89.21,169.76 89.21,178.47 88.28,179.41 87.32,179.41 84.08,182.65 83.47,182.65 82.55,183.57 82.55,184.62 82.92,185 84.58,185 84.95,184.63 84.95,183.94 v1(85.45,183.44)
  BOTTOM w0.102: R914.1 85.04,187.34 84.78,187.08 84.78,186.12 C677.1 84.71,184.92 84.71,184.15 85.28,183.58 85.31,183.58 v1(85.45,183.44)
UART_T3_NODE2_RXD_R: length 17
  BOTTOM w0.102: R914.2 85.04,188.93 85.42,189.31 85.42,193.48 85.44,193.5 85.44,197.71 v2(85.45,197.71) 85.45,199.94 85.05,200.33 J35.A22
UART_T3_NODE2_TXD: length 3.8
  TOP w0.102: U128.54 87.53,166.3 87.57,166.35 v1(87.57,166.89)
  BOTTOM w0.102: v1(87.57,166.89) 87.33,166.65 R917.1
UART_T3_NODE2_TXD_R: length 51.1
  IN3 w0.114: v1(88.5,166.6) 88.17,166.27 86.25,166.27 85.98,166.53 85.98,167.55 86.29,167.86 86.29,169.94 87.23,170.88 87.23,174.49 86.76,174.96 86.76,175.43 83.84,178.36 83.84,179.56 81.36,182.04 81.36,182.55 81.1,182.81 80.83,182.81 80.41,183.23 80.41,187.03 83.24,189.86 v1(84.3,189.86)
  BOTTOM w0.102: C680.1 84.03,189.13 84.28,189.39 84.28,189.84 v1(84.3,189.86) 84.28,189.89 84.28,198.52 84.05,198.75 J35.A23 ; v1(88.5,166.6) 88.1,166.2 88.1,165.36 87.63,164.9 R917.2
UART_T3_NODE3_RXD: length 28.5
  TOP w0.102: v1(88.94,167.54) 88.94,167.54 89.01,167.47 89.01,165.25 89.03,165.23 U128.57
  IN3 w0.114: v1(83.62,183.43) 83.62,183.25 83.9,182.97 84.21,182.97 85.18,182 86,182 87.06,180.94 87.45,180.94 90.29,178.09 90.29,169.16 90.01,168.88 89.65,168.88 89.39,168.63 89.39,168.12 88.94,167.66 v1(88.94,167.54)
  BOTTOM w0.102: R920.1 83.01,187.65 82.56,187.2 82.56,186.11 C683.1 83.7,184.97 83.7,183.7 83.62,183.62 v1(83.62,183.43)
UART_T3_NODE3_RXD_R: length 17.2
  BOTTOM w0.102: R920.2 83.01,189.23 83.14,189.36 83.14,192.12 83.02,192.24 83.02,199.51 v2(82.78,199.74) 82.05,200.48 J35.A25
UART_T3_NODE3_TXD: length 24.7
  TOP w0.102: v1(88.58,165.65) 88.53,165.6 U128.56
  IN3 w0.114: v1(88.58,165.65) 89.03,166.11 89.03,166.82 88.5,167.36 88.5,167.71 87.86,168.35 87.86,168.85 88.79,169.79 88.79,175.72 88.13,176.39 88.13,178.38 87.62,178.88 87.04,178.88 v1(84.46,181.47)
  BOTTOM w0.102: R923.1 82.45,184.35 82.45,183.8 82.61,183.63 82.61,183.31 v1(84.46,181.47)
UART_T3_NODE3_TXD_R: length 20.8
  BOTTOM w0.102: R923.2 81.99,185.97 81.42,186.55 81.42,187.95 C686.1 v2(81.99,195.78) 81.99,196.07 81.34,196.72 81.34,197.8 81.69,198.15 81.69,201.45 81.05,202.09 J35.A26
UART_T3_NODE4_RXD: length 36.4
  TOP w0.102: U128.67 94.03,163.64 93.52,163.14 v1(93.4,163.14)
  IN3 w0.114: v1(80.92,182.37) 80.92,182.03 83.52,179.43 83.52,178.23 86.45,175.3 86.45,174.82 86.91,174.36 86.91,171.8 85.97,170.86 85.97,167.99 85.44,167.46 85.44,166.46 87,164.89 92.02,164.89 93.4,163.49 v1(93.4,163.14)
  BOTTOM w0.102: v1(80.92,182.37) 80.92,182.73 80.42,183.23 80.42,183.92 80.85,184.35 C689.1 80.27,185.39 80.27,187.31 80.68,187.73 R926.1
UART_T3_NODE4_RXD_R: length 17
  BOTTOM w0.102: R926.2 80.85,189.2 80.58,189.47 v2(80.58,196.41) 80.58,199.93 80.05,200.46 J35.A27
UART_T3_NODE4_TXD: length 27.4
  TOP w0.102: v1(87.2,175.14) 88.1,174.24 88.1,170.58 89.65,169.03 90.38,169.03 93.53,165.88 U128.66
  IN3 w0.114: v1(87.2,175.14) 87.2,175.58 84.44,178.34 84.44,179.5 v1(84.36,179.58)
  BOTTOM w0.102: v1(84.36,179.58) 84.15,179.58 83.57,180.16 82.41,180.16 79.83,182.74 79.83,184.68 R929.1
UART_T3_NODE4_TXD_R: length 20.4
  BOTTOM w0.102: R929.2 79.71,186.12 79.14,186.69 79.14,187.96 C692.1 79.71,199.53 v2(79.81,199.64) 79.05,200.4 J35.A28
UART_T4_NODE1_RXD: length 35
  TOP w0.102: C695.1 90.06,185.67 90.06,186.32 90.1,186.36 ; v1(97.65,162.5) 97.37,162.78 96.27,162.78 96.18,162.87 95.59,162.87 95.53,162.81 95.17,162.81 94.92,163.06 94.92,163.44 95.03,163.54 U128.69 ; 90.1,186.36 v1(90.08,186.36) ; 90.1,186.36 89.88,186.58 89.88,186.81 89.82,186.88 89.82,187.55 R932.1
  IN3 w0.114: v1(90.08,186.36) 90.08,186.12 91.44,184.76 91.44,183.69 91.82,183.32 92.88,183.32 94.24,181.96 94.24,180.23 95.11,179.35 95.11,172.49 94.37,171.74 94.37,170.96 96.22,169.11 96.22,168.51 96.85,167.88 96.85,167.37 96.84,167.36 96.84,166.99 97.09,166.74 97.09,164.67 97.65,164.11 v1(97.65,162.5)
UART_T4_NODE1_RXD_R: length 16.2
  TOP w0.102: R932.2 90,194.74 90.05,194.79 v1(90.05,195.43) J35.B17
UART_T4_NODE1_TXD: length 3
  TOP w0.102: U128.68 94.53,162.98 94.93,162.58 v1(94.93,162.3) 94.57,162.3 94.41,162.46 R935.1
UART_T4_NODE1_TXD_R: length 50.5
  TOP w0.102: v1(88.95,186.39) 89.04,186.48 89.14,186.48 89.47,186.8 89.47,187.91 C698.1 88.85,189.78 89.44,190.37 v1(89.44,197.43) 89.44,200.27 89.05,200.66 J35.B18 ; R935.2 95.17,161.66 95.94,162.43 v1(95.96,162.43)
  IN3 w0.114: v1(95.96,162.43) 95.97,162.44 96.81,162.44 97.3,162.93 97.3,164.01 95.67,165.64 95.67,166.15 94.05,167.77 94.05,176.95 93.49,177.51 93.49,178.12 93.78,178.4 93.78,178.77 93.27,179.28 93.27,181.25 92.07,182.44 92.07,182.61 91.06,183.62 91.06,184.27 v1(88.95,186.39)
UART_T4_NODE2_RXD: length 33.5
  TOP w0.102: R938.1 87.94,187.5 87.94,187.5 88.2,187.25 88.2,186.67 v1(87.87,186.35) 87.71,186.19 C701.1 ; U128.71 96.03,163.56 95.7,163.24 v1(95.35,163.24)
  IN3 w0.114: v1(87.87,186.35) 88.78,185.45 89.36,185.45 90.67,184.14 90.67,183.57 91.75,182.48 91.75,182.28 92.39,181.65 92.39,180.7 92.83,180.25 92.83,177.72 93.73,176.82 93.73,166.67 96.98,163.43 96.98,163.06 96.69,162.77 96.25,162.77 95.78,163.24 v1(95.35,163.24)
UART_T4_NODE2_RXD_R: length 17.2
  TOP w0.102: R938.2 87.71,190.92 88.04,191.25 v1(88.04,195.94) 88.04,199.28 88.5,199.74 88.5,201.91 88.05,202.37 J35.B19
UART_T4_NODE2_TXD: length 25.4
  TOP w0.102: R941.1 86.57,184.18 v1(86.58,184.17) ; U128.70 95.53,165.29 96.14,166.7 96.14,166.71 v1(96.41,167.61)
  IN1 w0.114: v1(86.58,184.17) 86.09,182.82 86.09,182.41 86.47,181.43 86.47,180.8 86.09,178.87 86.09,178.55 86.72,177.27 88.33,175.66 89.51,175.05 89.86,175.05 91.91,173 94.92,170.22 95.4,169.92 95.65,169.67 96.09,168.82 96.41,167.99 v1(96.41,167.61)
UART_T4_NODE2_TXD_R: length 20.3
  TOP w0.102: R941.2 86.57,186.57 86.71,186.71 86.71,186.71 87.13,187.13 87.13,187.97 C704.1 86.57,189.09 87.04,189.57 87.04,199.66 v1(86.99,199.71) 87.05,199.77 J35.B20
UART_T4_NODE3_RXD: length 32.5
  TOP w0.102: U128.73 97.03,163.73 v1(96.54,163.24) ; C707.1 85.42,186.5 v1(85.28,186.64) 85.39,186.75 85.39,187.7 R944.1
  IN3 w0.114: v1(85.28,186.64) 85.51,186.41 85.98,186.41 87.69,184.7 88.46,184.7 90.84,182.32 90.84,182.09 91.29,181.64 91.53,181.64 92.07,181.1 92.07,180.37 92.45,179.99 92.45,177.4 93.41,176.44 93.41,166.39 96.54,163.26 v1(96.54,163.24)
UART_T4_NODE3_RXD_R: length 17.3
  TOP w0.102: 86.04,195.89 v1(86.03,195.89) ; 86.04,195.89 86.04,189.91 85.42,189.29 R944.2 ; 86.04,195.89 86.04,199.15 85.05,200.14 J35.B22
UART_T4_NODE3_TXD: length 25.2
  TOP w0.102: v1(84.65,183.46) 84.64,183.46 84.64,184.27 R947.1 ; v1(96.55,166.53) 96.53,166.51 U128.72
  IN1 w0.114: v1(84.65,183.46) 84.8,182.35 85.66,178.6 86.32,177.2 89.43,174.09 89.85,174.09 91.88,172.06 93.43,169.47 95.16,167.74 96.13,167.18 v1(96.55,166.53)
UART_T4_NODE3_TXD_R: length 20.8
  TOP w0.102: R947.2 84.12,185.61 83.7,186.03 83.7,188.08 84.15,188.54 84.27,188.54 ; 84.27,188.54 84.27,189.22 84.86,189.81 v1(84.86,199.63) 84.44,200.05 84.44,202.33 84.05,202.72 J35.B23 ; 84.27,188.54 C710.1
UART_T4_NODE4_RXD: length 38.1
  TOP w0.102: R950.1 83.14,186.71 v1(83.21,186.64) 83.14,186.57 C713.1 ; U128.75 98.03,164.32 v1(98.56,163.79)
  IN3 w0.114: v1(98.56,163.79) 98.47,163.69 98.47,162.98 98.09,162.6 98.09,162.32 97.77,162 95.78,162 95.52,162.25 95.52,162.45 93.1,164.87 93.1,176.2 92.14,177.16 92.14,178.5 91.77,178.86 91.66,178.86 89.6,180.92 89.6,181.29 89.61,181.29 89.61,181.64 89.35,181.9 89.18,181.9 87.27,183.81 87.27,184.17 85.78,185.67 84.18,185.67 v1(83.21,186.64)
UART_T4_NODE4_RXD_R: length 17.1
  TOP w0.102: R950.2 83.14,195.88 v1(83.64,196.39) 83.53,196.51 83.53,201.43 83.05,201.91 J35.B24
UART_T4_NODE4_TXD: length 30.5
  TOP w0.102: R953.1 81.99,183.54 v1(82.11,183.42) ; U128.74 97.53,165.34 97.53,166.56 97.28,166.8 v1(97.28,167.18)
  IN1 w0.114: v1(97.28,167.18) 97.28,166.64 96.73,166.09 95.74,166.09 95.1,166.73 95.1,166.84 91.36,170.58 91.36,171.89 90.3,172.95 89.54,172.95 88.07,174.43 87.29,174.43 83.41,178.3 83.41,182.12 82.11,183.42 v1(82.11,183.42)
UART_T4_NODE4_TXD_R: length 20.1
  TOP w0.102: J35.B25 82.05,197.54 v1(82.04,197.53) 82.04,188.57 C716.1 81.44,187.97 81.44,186.3 81.99,185.74 R953.2
UART_T5_NODE1_RXD: length 35.1
  TOP w0.102: v1(98.55,166.39) 98.78,166.62 U128.77 ; v1(102.87,190.07) 102.87,189.98 102.73,189.85 C672.1
  IN3 w0.114: v1(98.55,166.39) 99.68,166.39 101.36,168.08 101.55,168.08 102.36,168.89 102.36,170.82 100.64,172.55 100.64,180.7 100.68,180.75 100.68,181.64 100.42,181.89 100.42,182.98 99.78,183.63 99.78,184.23 98.39,185.61 98.39,187.31 101.82,190.73 102.48,190.73 102.87,190.35 v1(102.87,190.07)
  BOTTOM w0.102: v1(102.87,190.07) 102.87,189.98 102.73,189.85 C672.1
UART_T5_NODE1_RXD_R: length 16.7
  BOTTOM w0.102: J35.A5 v2(104.05,199.75) 104.01,199.72 104.01,198.87 103.8,198.66 103.8,197.87 103.92,197.76 103.92,197.3 104.02,197.19 104.02,196.77 103.92,196.67 103.92,189.78 103.53,189.39 R909.2
UART_T5_NODE1_TXD: length 6.6
  TOP w0.102: U128.76 99.78,165.26 99.93,165.11 99.93,164.64 99.57,164.28 99.57,163.17 v1(100.55,162.19)
  BOTTOM w0.102: R912.1 102.45,161.83 100.91,161.83 100.55,162.19 v1(100.55,162.19)
UART_T5_NODE1_TXD_R: length 54.3
  IN3 w0.114: v1(104.74,166.44) 104.89,166.59 105.65,166.59 105.91,166.84 105.91,167.2 105.4,167.71 105.4,168.54 105.08,168.86 104.73,168.86 104.21,169.38 103.77,169.38 103,170.16 103,172.19 102.46,172.73 102.46,176.18 101.9,176.73 101.9,181.94 101.06,182.79 101.06,183.41 100.64,183.82 100.64,184.63 99.38,185.89 99.38,186.94 101.82,189.39 101.82,190.06 v1(102.06,190.3)
  BOTTOM w0.102: C675.1 102.45,187.84 102.3,187.99 102.3,190.05 v1(102.06,190.3) 102.68,190.92 102.68,196.14 102.61,196.21 v2(102.61,198.65) 103.01,199.05 103.01,205.16 103.05,205.2 J35.A6 ; R912.2 104,161.83 104.01,161.82 104.98,161.82 105.62,162.46 105.62,164.15 104.88,164.9 104.88,166.3 v1(104.74,166.44)
UART_T5_NODE2_RXD: length 26
  TOP w0.102: U128.82 100.48,169.12 100.61,169.25 101.51,169.25 101.74,169.02 102.1,169.02 102.48,169.4 104.32,169.4 v1(104.84,169.92) ; C678.1 v1(107.42,185.79)
  IN3 w0.114: v1(104.84,169.92) 105.2,170.28 105.74,170.28 105.99,170.54 105.99,170.9 107.02,171.92 107.02,178.95 105.86,180.11 105.86,181.17 107.01,182.32 107.01,185.37 v1(107.42,185.79)
  BOTTOM w0.102: R915.1 106.73,186.81 107.42,186.11 v1(107.42,185.79)
UART_T5_NODE2_RXD_R: length 22.4
  BOTTOM w0.102: J35.A8 101.05,200.78 101.58,200.24 101.58,197.89 v2(101.09,197.41) 101.55,196.95 101.55,188.3 102.56,187.28 105.37,187.28 R915.2
UART_T5_NODE2_TXD: length 2.7
  TOP w0.102: R918.1 101.45,168.43 v1(101.37,168.52) 101.26,168.62 U128.81
UART_T5_NODE2_TXD_R: length 45.7
  TOP w0.102: v1(101.12,189.41) 101.13,189.41 102.71,187.84 C681.1 ; v1(104.9,168.42) 104.88,168.43 R918.2
  IN3 w0.114: v1(101.12,189.41) 99.06,187.36 99.06,185.39 100.32,184.13 100.32,183.69 100.74,183.27 100.74,182.02 101,181.77 101,180.61 100.95,180.57 100.95,173.58 102.68,171.85 102.68,169.67 103.93,168.42 v1(104.9,168.42)
  BOTTOM w0.102: v1(101.12,189.41) 99.69,190.84 v2(99.69,196.06) 99.69,197.77 100.48,198.56 100.48,200.91 100.05,201.35 J35.A9
UART_T5_NODE3_RXD: length 27.4
  TOP w0.102: v1(104.35,186.79) 104.31,186.83 C684.1 ; U128.84 101.31,170.12 v1(101.37,170.18)
  IN3 w0.114: v1(97.95,186.28) 97.95,184.81 100.11,182.66 100.11,181.76 100.36,181.5 100.36,180.88 100.32,180.83 100.32,172.42 100.95,171.79 100.95,170.61 v1(101.37,170.18)
  BOTTOM w0.102: v1(97.95,186.28) 98.49,185.74 102.96,185.74 103.53,186.32 C684.1 104.31,186.83 v1(104.35,186.79)
UART_T5_NODE3_RXD_R: length 20.2
  BOTTOM w0.102: J35.A10 99.05,198.25 v2(99.25,198.05) 99.05,197.85 99.05,190.33 102.55,186.83 R921.2
UART_T5_NODE3_TXD: length 22.5
  TOP w0.102: U128.83 99.78,169.62 99.78,169.62 101.48,169.62 101.74,169.88 103.89,169.88 v1(103.92,169.85)
  IN3 w0.114: v1(104.68,184.87) 104.16,184.87 102.17,182.87 102.17,182.13 102.22,182.08 102.22,176.94 102.92,176.23 102.92,172.71 103.32,172.32 103.32,170.46 v1(103.92,169.85)
  BOTTOM w0.102: v1(104.68,184.87) 104.61,184.79 R924.1
UART_T5_NODE3_TXD_R: length 27
  TOP w0.102: C687.1 102.38,184.79 v1(102.08,185.09)
  BOTTOM w0.102: J35.A11 v2(98.05,199.57) 98.05,199.54 97.28,198.77 97.28,192.99 96.42,192.13 96.42,186.74 97.8,185.36 101.81,185.36 v1(102.08,185.09) 102.38,184.79 C687.1
UART_T5_NODE4_RXD: length 25.6
  TOP w0.102: v1(98.21,182.07) 103.61,182.07 104.69,183.15 104.69,183.98 104.95,184.23 106.39,184.23 106.64,184.48 C690.1 v1(107.49,184.77) ; v1(98.53,171.62) 98.53,171.38 98.78,171.12 U128.86
  IN3 w0.114: v1(98.21,182.07) 97.13,180.99 97.13,180.17 96.98,180.02 96.98,176.46 96.97,176.44 96.97,173.82 98.53,172.26 v1(98.53,171.62)
  BOTTOM w0.102: v1(107.49,184.77) 106.64,185.62 R927.1
UART_T5_NODE4_RXD_R: length 31.1
  BOTTOM w0.102: R927.2 105.84,185.59 105.31,185.05 105.31,184.78 104.89,184.36 101.34,184.36 100.65,185.06 96.94,185.06 95.25,186.74 95.25,195.43 v2(95.42,195.59) 95.42,199.41 95.05,199.77 J35.A12
UART_T5_NODE4_TXD: length 21.1
  TOP w0.102: U128.85 100.77,170.62 101.08,170.94 104.76,170.94 v1(104.78,170.92)
  IN3 w0.114: v1(102.92,182.55) 102.92,177.96 103.88,177 104.16,177 104.96,176.2 104.96,175.84 104.7,175.58 103.79,175.58 103.24,175.03 103.24,172.85 104.33,171.76 104.33,171.76 104.78,171.3 v1(104.78,170.92)
  BOTTOM w0.102: R930.1 103.53,183.64 102.94,183.05 102.94,182.57 v1(102.92,182.55)
UART_T5_NODE4_TXD_R: length 30.3
  TOP w0.102: v1(101.54,183.42) 101.9,183.78 C693.1
  BOTTOM w0.102: J35.A13 94.05,199.42 v2(94.04,199.41) 94.04,186.19 95.61,184.63 99.64,184.63 100.84,183.42 v1(101.54,183.42) 101.9,183.78 C693.1
